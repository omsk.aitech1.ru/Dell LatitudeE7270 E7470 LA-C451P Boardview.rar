# Allegro board LAC451PR10-0923B.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
+3.3V_RUN_VMM on BOTTOM (solid shape): 203.67,108.19 203.67,105.52 203.52,105.37 202.01,105.37 201.92,105.46 201.92,108.14 202.18,108.4 203.46,108.4
+3.3V_RUN_VMM on BOTTOM (solid shape): 214.65,108.54 214.65,107.56 214.46,107.37 212.72,107.37 212.43,107.09 211.02,107.09 210.84,107.27 210.84,108.39 211.07,108.62 214.58,108.62
+3.3V_RUN_VMM on BOTTOM (solid shape): 221.46,119.67 221.46,118.27 221.4,118.21 220.09,118.21 219.92,118.37 219.92,118.78 220.1,118.96 220.42,118.96 220.57,119.11 220.57,119.6 220.7,119.73 221.4,119.73
+3.3V_RUN_VMM on IN3 (solid shape): 212.53,108.2 212.53,107.12 212.49,107.08 210.97,107.08 210.85,107.21 210.85,108.26 211.07,108.48 212.25,108.48
+3.3V_RUN_VMM on IN3 (solid shape): 207.45,116.83 207.45,116.44 208.2,115.69 208.2,115.37 207.7,114.86 207.25,114.86 206.37,115.75 206.37,116.9 206.46,116.99 207.29,116.99
+3.3V_RUN_VMM on IN3 (solid shape): outline of 642 points within 205.75,111.71 225.87,124.37
+3.3V_SPI on IN3 (solid shape): outline of 319 points within 165.26,73.82 188.15,88.39
+3.3V_TP on TOP (solid shape): 282.25,10.47 282.75,10.47 282.85,10.37 282.85,9.74 282.66,9.55 281.96,9.55 281.66,9.85 281.66,10.47 282.08,10.47 282.08,11.03 282.25,11.03
+3.3V_TSP on TOP (solid shape): 103.36,117.93 103.36,116.25 102.94,115.83 102.41,115.83 100.68,117.56 100.68,117.84 101.13,118.28 103.01,118.28
+3.3V_TSP on BOTTOM (solid shape): 102.72,117.94 102.72,117.56 102.52,117.37 101.93,117.37 100.92,118.08 100.91,118.18 100.91,118.27 101.16,118.52 102.14,118.52
+3.3V_WLAN on TOP (solid shape): 263.34,52.22 263.34,51.32 263.26,51.23 262.42,51.23 261.78,50.59 261.78,49.87 261.63,49.72 261.03,49.72 260.56,50.19 260.56,52.1 260.75,52.29 263.27,52.29
+3.3V_WLAN on TOP (solid shape): 243.2,53.29 246.15,53.29 246.64,52.8 246.64,50.87 246.53,50.76 246.14,50.76 246.14,51.3 246.12,51.32 245.59,51.32 245.59,50.76 245.34,50.76 245.34,51.32 244.79,51.32 244.79,50.76 244.4,50.76 244.22,50.58 243.55,50.58 243.42,50.72 243.35,50.77 242.52,51.61 242.01,52.11 242.01,53.16 242.24,53.39 243.1,53.39
+3.3V_WLAN on BOTTOM (solid shape): 244.51,53.11 244.51,51.57 244.69,51.39 244.69,50.66 244.6,50.57 243.69,50.57 243.14,51.11 243.14,53.17 243.23,53.26 244.36,53.26
+3.3V_WLAN on BOTTOM (solid shape): 262.23,53.08 262.23,51.04 261.78,50.59 261.78,50.01 261.66,49.88 261.11,49.88 261.01,49.98 261.01,51.52 261.2,51.71 261.2,53.11 261.3,53.21 262.1,53.21
+3.3V_WLAN on IN1 (solid shape): outline of 551 points within 243.15,47.75 262.05,51.82
+3.3V_WLAN_UZ3 on TOP (solid shape): 246.97,50.17 246.97,48.14 246.94,48.1 245.41,48.1 245.12,48.4 244.74,48.4 244.64,48.5 244.64,49.07 244.3,49.4 244.3,50.47 244.46,50.63 246.52,50.63
+3.3V_WWAN on TOP (solid shape): 271.36,90.94 272.5,90.94 272.57,90.87 272.57,87.27 272.38,87.08 270.04,87.08 269.78,87.33 269.78,90.61 270.11,90.94 271.36,90.94
+3.3V_WWAN on TOP (solid shape): 282.95,107.95 282.95,107.15 282.4,107.15 282.4,106.4 282.95,106.4 282.95,105.94 282.4,105.94 282.4,105.19 282.95,105.19 282.95,104.56 282.79,104.39 281.66,104.39 281.42,104.63 280.4,104.63 280.21,104.82 280.21,108.15 280.58,108.52 282.38,108.52
+3.3V_WWAN on BOTTOM (solid shape): 273.5,89.43 273.5,88.55 273.34,88.39 269.91,88.39 269.78,88.51 269.78,89.38 269.93,89.53 273.4,89.53
+3.3V_WWAN on BOTTOM (solid shape): outline of 250 points within 270.89,104.48 284.49,111.76
+3.3V_WWAN on IN1 (solid shape): outline of 591 points within 269.72,87.92 282.11,108.53
+3.3V_WWAN_UZ2 on TOP (solid shape): 285.22,109.76 285.22,109.24 286.03,108.42 286.03,103.98 285.55,103.5 283.71,103.5 283.12,104.1 283.12,105.33 282.58,105.33 282.56,105.36 282.56,105.79 283.12,105.79 283.12,106.55 282.56,106.55 282.56,106.99 283.12,106.99 283.12,107.78 283.12,107.79 283.12,109.12 283.84,109.84 285.14,109.84
+5V_ALW on TOP (solid shape): 101,126.84 101,124.37 100.75,124.11 99.86,124.11 97.64,126.34 97.64,126.72 98.08,127.16 100.68,127.16
+5V_ALW on TOP (solid shape): 256.14,100.43 256.14,100.07 255.88,99.81 254.67,99.81 254.54,99.93 254.54,100.78 254.71,100.95 255.63,100.95
+5V_ALW on TOP (solid shape): 269.17,103.07 269.17,102.29 269.09,102.21 267.32,102.21 267.13,102.4 267.13,103.09 267.24,103.21 269.03,103.21
+5V_ALW on TOP (solid shape): 278.79,100.31 278.79,98.64 278.69,98.54 276.68,98.54 276.54,98.67 276.54,98.93 277.58,99.97 277.58,100.73 277.64,100.8 278.31,100.8
+5V_ALW on TOP (solid shape): 248.16,89.76 248.16,89 247.63,88.48 246.31,88.48 246.15,88.64 246.15,88.95 246.71,88.95 246.71,89.43 246.15,89.43 246.15,89.86 246.34,90.05 247.86,90.05
+5V_ALW on TOP (solid shape): 88.99,85.83 89.19,85.83 90.02,85 90.02,83.88 89.85,83.71 89.2,83.71 88.99,83.93 88.99,84.33 88.4,84.91 88.4,85.81 88.48,85.88 88.94,85.88
+5V_ALW on TOP (solid shape): 80.11,126.4 80.11,122.91 79.86,122.65 78.71,122.65 78.52,122.84 78.52,124.37 78.2,124.68 77.63,124.68 77.38,124.94 77.38,126.27 77.63,126.53 79.98,126.53
+5V_ALW on TOP (solid shape): 274.46,106.87 274.46,105.93 276.39,104 276.39,102.56 276.33,102.5 275.27,102.5 275.2,102.57 274.65,102.57 274.41,102.81 273.59,102.81 273.37,103.02 273.37,104.54 273.02,104.89 273.02,107.07 273.16,107.21 274.11,107.21
+5V_ALW on TOP (solid shape): 273.05,101.44 273.52,101.44 273.8,101.16 274.3,101.16 274.58,100.88 275.56,100.88 276.08,100.36 276.08,99.51 275.65,99.08 274.64,99.08 274.34,99.39 274.33,99.4 274.24,99.54 274.1,99.63 274.09,99.64 274.05,99.67 273.04,99.67 271.27,101.44 271.27,101.71 271.85,102.29 272.2,102.29
+5V_ALW on BOTTOM (solid shape): 227.3,121.76 227.3,120.87 227.11,120.68 226.6,120.68 226.29,120.37 226.29,119.8 226.17,119.68 226.02,119.68 225.91,119.8 225.91,120.94 226.86,121.89 227.18,121.89
+5V_ALW on BOTTOM (solid shape): 213.78,102.54 213.78,100.31 213.54,100.07 212.71,100.07 212.71,100.57 212.01,100.57 212.01,100.06 211.51,100.06 211.51,100.57 210.81,100.57 210.81,100.06 209.56,100.06 209.12,100.5 209.12,102.42 209.39,102.69 213.62,102.69
+5V_ALW on BOTTOM (solid shape): 240.24,47.2 240.24,46.74 239.63,46.13 239.63,45.23 239.78,45.09 239.78,44.48 239.67,44.37 239.34,44.37 239.34,44.92 239.33,44.93 238.87,44.93 238.86,44.92 238.86,44.37 238.57,44.37 238.45,44.48 238.45,46.59 239.24,47.38 240.06,47.38
+5V_ALW on BOTTOM (solid shape): 89.96,122.09 89.96,121.04 89.95,121 89.92,120.96 89.59,120.86 89.46,120.53 89.43,120.45 89.36,120.42 89.1,119.81 89.71,120.05 89.75,120.13 89.82,120.15 89.87,120.15 89.91,120.15 89.94,120.12 89.95,120.07 89.95,115.79 89.7,115.54 89.06,115.54 88.87,115.73 88.87,115.96 89.02,116.11 89.02,116.94 87.81,118.15 87.79,118.15 87.64,118.3 86.28,118.3 86.21,118.36 86.21,118.44 86.27,118.5 86.95,118.5 87,118.54 87.06,118.57 87.13,118.55 87.68,118.81 87.12,119.03 87.08,119.02 87.04,119.03 86.98,119.1 86.26,119.1 86.21,119.14 86.21,120.08 88.08,121.95 88.08,122.37 88.38,122.67 89.39,122.67
+5V_ALW on BOTTOM (solid shape): outline of 159 points within 252.64,100.03 268.64,104.61
+5V_ALW on IN1 (solid shape): 240.92,47.16 240.92,46.41 240.76,46.25 240.26,46.25 239.93,46.36 239.67,46.13 239.66,46.12 239.07,46.12 238.92,46.27 238.92,46.98 239.22,47.28 240.8,47.28
+5V_ALW on IN1 (solid shape): 250.24,47.39 250.24,47.07 250.1,46.94 249.32,46.94 249.3,46.91 249.29,46.91 249.15,46.83 249.07,46.69 249.07,46.68 248.88,46.49 248.88,46.3 248.78,46.2 248.78,45.52 248.66,45.41 247.98,45.41 247.79,45.6 247.79,46.36 247.95,46.64 247.79,46.93 247.79,47.12 247.92,47.26 247.95,47.44 247.95,47.46 248,47.52 250.11,47.52
+5V_ALW on IN2 (solid shape): 278.33,99.59 278.33,97.86 278.14,97.67 276.81,97.67 276.55,97.93 276.55,99.13 277.12,99.7 278.22,99.7
+5V_ALW on IN2 (solid shape): 279.96,77.66 279.96,76.56 279.53,76.13 278.65,76.13 278.51,76.27 278.51,77.63 278.52,77.64 278.52,77.78 278.71,77.97 279.64,77.97
+5V_ALW on IN3 (solid shape): outline of 578 points within 249.17,46.02 270.28,51.82
+5V_ALW on IN4 (solid shape): outline of 779 points within 269.06,50.85 280.39,77.4
+5V_ALW on VCC: 274.65,98.46 273.66,99.45 273.66,105.42 255.09,123.99 206.24,123.99 204.32,122.06 204.32,115.63 214.22,105.72 214.22,101.51 213.83,101.12 209.77,101.12 187.78,123.1 172.95,123.1 171.42,124.62 162.15,124.62 160.25,122.72 157.45,122.72 155.55,124.62 148.46,124.62 147.31,123.48 120.39,123.48 117.72,120.81 79.33,120.81 78.08,122.06 78.08,126.67 78.56,127.16 104.87,127.16 111.95,126.83 116.62,132.16 116.84,133.24 116.92,134.35 116.92,137.08 122.95,137.08 124.2,137.6 124.72,138.85 124.72,140.58 125.97,140.58 178.98,140.58 180.78,140.58 180.78,138.85 181.3,137.6 182.55,137.08 188.58,137.08 188.58,134.35 189.01,131.74 190.25,129.4 196.19,126.2 202.51,128.56 226.64,128.56 228.04,129.96 244.42,129.96 245.06,130.59 254,130.59 256.03,128.56 265.17,128.56 265.66,128.07 265.66,120.07 266.95,118.78 281.3,118.78 281.91,118.17 281.91,101.49 278.89,98.46 ; 4 cut-outs
+5V_ALW2 on BOTTOM (solid shape): 206.73,88.47 207.25,88.47 207.75,87.97 207.75,87.7 207.94,87.51 207.94,87.28 207.87,87.21 206.84,87.21 206.37,87.69 205.81,87.69 205.76,87.73 205.76,88.71 205.83,88.78 206.42,88.78
+5V_ALWP on TOP (solid shape): 208.87,103.74 208.87,96.64 208.73,96.49 206.98,96.49 206.8,96.67 206.8,103.71 207.04,103.96 208.66,103.96
+5V_ALWP on BOTTOM (solid shape): 206.81,87.04 207.88,87.04 207.94,86.98 207.94,86.82 207.88,86.75 206.77,86.75 206.03,86.01 205.46,86.01 205.38,86.09 205.38,87.48 205.44,87.54 206.32,87.54
+5V_ALWP on BOTTOM (solid shape): 208.76,103.44 208.76,100.62 209.48,99.9 210.93,99.9 210.93,99.93 210.93,99.93 210.93,100.45 211.38,100.45 211.38,99.93 211.41,99.93 211.41,99.93 212.11,99.93 212.11,99.93 212.13,99.93 212.13,100.45 212.57,100.45 212.57,99.9 213.58,99.9 213.86,99.61 213.86,95.43 212.83,94.39 207.31,94.39 206.83,94.88 206.83,103.42 206.95,103.55 208.65,103.55
+5V_RUN on TOP (solid shape): 81.63,93.87 81.63,92.39 80.76,91.51 78.83,91.51 78.66,91.68 78.66,92.62 79.33,92.62 79.34,92.56 79.35,92.51 79.37,92.46 79.4,92.42 79.43,92.37 79.47,92.34 79.51,92.31 79.56,92.29 79.61,92.27 79.66,92.26 79.72,92.26 79.77,92.27 79.82,92.29 79.87,92.31 79.91,92.34 79.95,92.37 79.98,92.42 80.01,92.46 80.03,92.51 80.04,92.56 80.05,92.62 80.04,92.67 80.03,92.72 80.01,92.77 79.98,92.82 79.95,92.86 79.91,92.9 79.87,92.93 79.82,92.95 79.77,92.96 79.72,92.97 79.66,92.97 79.61,92.96 79.56,92.95 79.51,92.93 79.47,92.9 79.43,92.86 79.4,92.82 79.37,92.77 79.35,92.72 79.34,92.67 79.33,92.62 78.66,92.62 78.66,92.88 79.91,94.13 81.38,94.13
+5V_RUN on TOP (solid shape): outline of 247 points within 263.73,64.82 276.25,72.25
+5V_RUN on BOTTOM (solid shape): 247.08,128.02 247.08,126.39 246.94,126.25 245.04,126.25 244.83,126.46 244.83,127.97 245.08,128.23 246.87,128.23
+5V_RUN on BOTTOM (solid shape): 81.59,94.26 81.59,93.28 81.35,93.03 80.01,93.03 79.35,93.69 79.35,94.07 79.52,94.24 80.39,94.55 80.46,94.59 81.26,94.59
+5V_RUN on BOTTOM (solid shape): 94.78,119.8 94.78,118.14 93.63,117 91.03,117 90.59,117.45 90.59,118.78 90.84,119.03 92.24,119.03 92.75,119.54 92.75,119.99 92.87,120.11 94.46,120.11
+5V_RUN on BOTTOM (solid shape): 96.66,81.53 96.66,81 96.21,80.55 94.93,80.55 94.9,80.58 94.9,80.71 94.96,80.77 95.72,80.77 96.09,81.14 96.09,81.59 96.15,81.64 96.55,81.64
+5V_RUN on BOTTOM (solid shape): 107.92,104.75 107.92,104.05 107.35,103.48 105.83,103.48 105.76,103.54 105.76,103.67 105.83,103.73 106.84,103.73 107.29,104.17 107.29,104.75 107.35,104.81 107.86,104.81
+5V_RUN on BOTTOM (solid shape): 127.73,117.28 127.73,115.1 127.33,114.69 126.35,114.69 126.3,114.74 126.3,114.91 126.36,114.97 127.1,114.97 127.23,115.1 127.23,116.05 127.16,116.11 127.16,117.26 127.29,117.38 127.63,117.38
+5V_RUN on BOTTOM (solid shape): 87.6,124.75 87.6,123.16 87.03,122.59 85.35,122.59 84.88,122.12 84.04,122.12 84.04,122.64 83.58,122.64 83.58,122.12 83.24,122.12 83.24,122.64 82.78,122.64 82.78,122.12 82.36,122.12 82.08,122.4 82.08,124.71 82.31,124.94 87.41,124.94
+5V_RUN on IN2 (solid shape): 87.51,110.22 87.51,109 87.35,108.83 85.86,108.83 85.69,109 85.69,110.28 85.79,110.38 87.35,110.38
+5V_RUN on IN2 (solid shape): 82.18,94.37 82.18,93.86 81.44,93.13 80.68,93.13 80.49,93.32 80.49,94.19 81.13,94.83 81.72,94.83
+5V_RUN on IN2 (solid shape): 272.09,70.56 272.09,69.26 271.54,68.71 271.19,68.71 271.03,68.86 271.03,70.56 271.18,70.71 271.94,70.71
+5V_RUN on IN2 (solid shape): 276.87,112.25 276.87,110.85 276.72,110.7 275.98,110.7 275.82,110.87 275.82,111.57 275.89,111.78 275.82,111.99 275.82,112.31 275.89,112.39 276.73,112.39
+5V_RUN on IN3 (solid shape): outline of 417 points within 169.61,120.18 247.14,130.34
+5V_RUN on IN3 (solid shape): outline of 860 points within 85.06,109.88 129.98,124.69
+5V_RUN on IN4 (solid shape): 276.91,113.49 276.91,111.96 276.67,111.72 275.99,111.72 275.92,111.74 275.89,111.81 275.84,111.96 275.73,112.07 275.73,113.49 275.89,113.65 276.75,113.65
+5V_RUN on IN4 (solid shape): 247.15,127.28 247.15,126.37 246.52,125.74 246.49,125.75 246.19,125.71 246.05,125.45 246.02,125.39 245.95,125.36 245.13,125.36 244.87,125.62 244.87,126.49 245.14,126.49 246.06,127.42 247.01,127.42
+5V_RUN_AUDIO on TOP (solid shape): 280.04,74.04 280.04,72.01 279.87,71.84 279.37,71.84 279.36,71.85 279.36,72.4 278.88,72.4 278.88,71.85 278.86,71.84 277.04,71.84 276.48,72.4 274.99,72.4 274.94,72.45 274.94,72.86 274.97,72.94 275.06,72.96 275.3,73.01 275.45,73.21 275.45,73.23 275.54,73.31 275.56,73.31 275.8,73.41 275.89,73.65 275.89,73.67 276.49,74.27 279.82,74.27
+5V_RUN_AUDIO_UZ5 on TOP (solid shape): 279.73,71.59 279.73,70.61 279.5,70.38 279.5,69.9 279.32,69.72 278.9,69.72 278.75,69.57 277.14,69.57 277.09,69.62 277.09,70.99 277.78,71.69 279.63,71.69
+5V_RUN_PVDD on TOP (solid shape): 279.24,77.07 279.24,76.18 279.38,76.03 279.85,76.03 279.97,75.92 279.97,75.27 279.85,75.15 278.18,75.15 278.06,75.27 278.06,76.94 278.26,77.14 279.17,77.14
+5V_RUN_PVDD on TOP (solid shape): 288.27,79.54 288.27,76.53 288.47,76.34 289.59,76.34 289.98,75.94 289.98,73.85 289.76,73.63 289.76,72.74 289.7,72.68 289.64,72.68 289.57,72.74 289.57,73.73 289.59,73.78 289.64,73.82 289.64,75.19 289.29,75.54 287.4,75.54 287.14,75.28 287.14,74.15 287.79,73.5 287.79,72.68 287.73,72.61 287.67,72.61 287.54,72.74 287.54,73.5 286.48,74.56 286.48,79.6 286.75,79.87 287.94,79.87
+5V_RUN_UZ4 on BOTTOM (solid shape): 83.11,121.99 83.71,121.99 83.71,122.51 83.91,122.51 83.91,121.99 84.88,121.99 85.18,121.69 85.18,120.4 84.93,120.15 84.93,119.16 84.87,119.1 83.35,119.1 83.08,119.36 82.74,119.36 82.64,119.46 82.64,120.22 82.2,120.66 82.2,121.83 82.37,121.99 82.91,121.99 82.91,122.51 83.11,122.51
+5V_USB_CHG_PWR on TOP (solid shape): 281.52,104.23 282.68,104.23 283.27,103.64 283.27,102.1 282.98,101.81 280.7,101.81 280.01,102.51 278.64,102.51 278.57,102.57 278.57,102.85 281.07,102.85 281.07,102.8 281.08,102.75 281.09,102.7 281.12,102.65 281.15,102.61 281.19,102.58 281.23,102.55 281.27,102.52 281.32,102.51 281.37,102.5 281.43,102.5 281.48,102.51 281.53,102.52 281.57,102.55 281.62,102.58 281.65,102.61 281.68,102.65 281.71,102.7 281.72,102.75 281.73,102.8 281.73,102.85 281.72,102.91 281.71,102.95 281.68,103 281.65,103.04 281.62,103.08 281.57,103.11 281.53,103.13 281.48,103.15 281.43,103.16 281.37,103.16 281.32,103.15 281.27,103.13 281.23,103.11 281.19,103.08 281.15,103.04 281.12,103 281.09,102.95 281.08,102.91 281.07,102.85 278.57,102.85 278.57,103.89 279.09,104.42 281.34,104.42
+5V_USB_CHG_PWR on BOTTOM (solid shape): 288.08,96.11 288.08,95.52 288.62,94.98 290.21,94.98 290.61,94.58 290.61,93.41 290.6,93.41 290.6,92.93 290.1,92.43 288.28,92.43 287.83,92.87 287.83,93.34 287.6,93.57 284.07,93.57 283.96,93.68 283.96,96.26 284.26,96.57 287.63,96.57
+5V_USB_CHG_PWR on IN2 (solid shape): outline of 371 points within 280.96,93.22 287.52,103.7
+DV33_18 on TOP (solid shape): 271.63,79.47 271.63,79.22 271.43,79.03 271.18,79.03 270.8,79.41 269.97,79.41 269.91,79.47 269.91,79.6 269.97,79.66 271.43,79.66
+GND_CHASSIS on TOP (solid shape): 282.17,122.78 282.17,121.55 281.95,121.33 269.44,121.33 269.17,121.6 269.17,122.8 269.29,122.92 282.03,122.92
+GND_CHASSIS on BOTTOM (solid shape): 286.55,129.93 286.55,126.55 282.85,122.86 282.85,121.92 282.62,121.69 281.79,121.69 281.64,121.83 281.64,123.25 285.18,126.78 285.18,129.99 285.21,130.03 286.45,130.03
+VCC_1P8 on TOP (solid shape): 168.75,94.21 168.77,94.21 168.78,94.2 169.23,94.2 169.25,94.18 169.96,94.18 170.05,94.09 170.05,93.45 170.01,93.42 169.92,93.42 169.84,93.4 169.52,93.4 169.4,93.52 169.4,93.54 169.19,93.79 168.87,93.74 168.86,93.73 168.81,93.73 168.62,93.54 168.62,93.06 168.51,92.96 168,92.96 167.85,93.1 167.85,93.44 167.66,93.63 167.66,93.63 167.53,93.76 167.53,94.04 167.88,94.38 168.57,94.38
+VCC_CORE on TOP (solid shape): outline of 4820 points within 111.4,87.97 158.19,114.76
+VCC_CORE on BOTTOM (solid shape): outline of 446 points within 111.22,96.17 126.46,116.05
+VCC_CORE on BOTTOM (solid shape): outline of 429 points within 151.11,86.28 156.05,89.14
+VCC_CORE on BOTTOM (solid shape): outline of 671 points within 149.33,96.85 156.57,99.71
+VCC_CORE on IN1 (solid shape): outline of 671 points within 149.19,91.55 156.56,98.35
+VCC_CORE on IN2 (solid shape): outline of 6707 points within 111.44,86.28 155.68,114.95
+VCC_CORE on IN3 (solid shape): outline of 8443 points within 110.59,86.31 156.84,114.83
+VCC_CORE on IN4 (solid shape): outline of 1710 points within 148.79,86.21 157.43,99.89
+VCC_CORE on VCC: 150.32,86.27 149.45,87.13 149.45,98.31 148.79,98.97 141.88,98.97 141.71,98.8 140.41,98.8 140.25,98.97 121,98.97 118.08,96.05 108.79,96.05 108.3,96.53 108.3,111.43 111.71,114.84 122.8,114.84 128.14,109.51 152.77,109.51 155.67,106.61 155.67,86.88 155.06,86.27
+VCC_GT on TOP (solid shape): outline of 5147 points within 108.43,77.05 148.37,104.44
+VCC_GT on BOTTOM (solid shape): outline of 2430 points within 105.5,75.66 149.21,98.85
+VCC_GT on IN1 (solid shape): outline of 1274 points within 126.55,91.19 148.65,98.87
+VCC_GT on IN2 (solid shape): outline of 7510 points within 106.77,75.67 149.24,98.28
+VCC_GT on IN3 (solid shape): outline of 7508 points within 106.77,75.68 149.24,98.27
+VCC_GT on IN4 (solid shape): outline of 1253 points within 125.95,90.89 149.29,98.73
+VCC_GT on VCC: 100.53,76.49 100.05,76.97 100.05,79.56 106.02,85.53 106.02,93.4 108.15,95.54 116.79,95.54 116.8,95.55 118.35,95.55 121.26,98.46 140.04,98.46 140.2,98.29 141.92,98.29 142.09,98.46 148.58,98.46 148.94,98.1 148.94,91.33 148.33,90.71 123.31,90.71 109.09,76.49
+VCC_GTUS on BOTTOM (solid shape): outline of 92 points within 140.15,86.78 150.54,88.35
+VCC_SA on TOP (solid shape): 141.75,115.55 141.75,112.37 141.69,112.3 139.42,112.3 139.17,112.55 139.17,115.36 139.55,115.73 141.58,115.73
+VCC_SA on TOP (solid shape): outline of 169 points within 157.48,88.57 160.7,99.7
+VCC_SA on BOTTOM (solid shape): 141.83,115.48 141.83,112.43 141.7,112.3 136.29,112.3 136.11,112.48 136.11,115.5 136.34,115.73 141.58,115.73
+VCC_SA on BOTTOM (solid shape): 160.59,89.19 160.59,88.25 160.58,88.21 160.54,88.16 160.47,88.14 160.25,88.05 160.19,87.82 160.18,87.73 160.1,87.69 159.87,87.69 159.79,87.73 159.77,87.82 159.55,88.14 159.27,87.87 159.27,87.84 159.23,87.81 159.21,87.81 159.1,87.92 159.1,89.21 159.22,89.33 160.44,89.33
+VCC_SA on BOTTOM (solid shape): outline of 375 points within 156.58,96.82 161.1,99.7
+VCC_SA on IN2 (solid shape): outline of 489 points within 157.19,88.52 160.67,106.49
+VCC_SA on IN3 (solid shape): outline of 1594 points within 139.2,87.38 161.14,116.11
+VCC_SA on IN4 (solid shape): outline of 742 points within 157.57,87.38 161.62,99.76
+VCC_SA on VCC: 156.18,88.43 156.18,106.82 152.99,110.02 139.14,110.02 138.66,110.5 138.66,115.12 139.27,115.73 146.55,115.73 148.84,113.45 156.69,113.45 157.2,112.94 157.2,111.67 161.2,107.67 161.2,106.06 160.5,105.36 160.5,103.41 162.02,101.89 162.02,88.43
+VCC_SFR_OC on TOP (solid shape): 110.53,72.47 110.53,71.15 109.92,70.54 108.05,70.54 107.58,71.01 107.58,72.11 108.09,72.63 110.38,72.63
+VCC_SFR_OC on IN2 (solid shape): outline of 586 points within 156.69,81.71 161.17,88.35
+VDDA_PVDD on TOP (solid shape): 294.09,78.51 294.09,75.33 293.96,75.21 293.96,74.75 293.68,74.47 292.99,74.47 292.86,74.34 292.36,74.34 292.36,74.34 291.94,74.34 291.67,74.07 291.67,73.69 291.6,73.63 291.32,73.63 291.26,73.64 291.21,73.63 291.16,73.63 290.97,73.44 290.97,72.68 290.91,72.61 290.84,72.61 290.72,72.74 290.72,73.5 290.84,73.63 290.84,73.63 290.92,73.71 290.92,74.53 291.34,74.96 292.49,74.96 292.98,75.45 292.98,78.49 293.08,78.58 294.02,78.58
GND on TOP (solid shape): 41.37,42.77 41.37,41.75 41.12,41.5 39.91,41.5 39.85,41.56 39.85,42.96 39.91,43.02 41.12,43.02
GND on TOP (solid shape): 43.53,39.98 43.53,38.77 43.47,38.71 40.29,38.71 40.23,38.77 40.23,39.98 40.42,40.17 43.34,40.17
GND on TOP (solid shape): 94.29,114.2 94.29,113.45 94.22,113.38 92.05,113.38 91.54,113.89 91.54,115.73 91.67,115.86 92.64,115.86
GND on TOP (solid shape): 132.62,112.24 132.62,111.16 132.37,110.91 131.16,110.91 131.1,110.97 131.1,112.37 131.16,112.43 132.43,112.43
GND on TOP (solid shape): 141.83,117 141.83,115.99 141.7,115.86 138.92,115.86 138.75,116.02 138.75,116.88 139,117.13 141.7,117.13
GND on TOP (solid shape): 141.83,112.05 141.83,111.03 141.7,110.91 139.42,110.91 139.29,111.03 139.29,112.05 139.42,112.18 141.7,112.18
GND on TOP (solid shape): 147.99,89.51 147.99,87.16 147.93,87.09 147.29,87.09 146.78,87.6 146.78,89.32 147.04,89.57 147.93,89.57
GND on TOP (solid shape): 238.73,88.17 238.73,87.03 238.48,86.78 236.76,86.78 236.45,87.09 236.45,88.17 236.51,88.24 238.67,88.24
GND on TOP (solid shape): 241.21,51.28 241.21,49.18 241.08,49.06 240.07,49.06 239.88,49.25 239.88,51.15 240.07,51.34 241.15,51.34
GND on TOP (solid shape): 275.64,4.26 275.64,2.59 275.45,2.4 273.81,2.4 273.62,2.59 273.62,4.23 273.85,4.45 275.45,4.45
GND on TOP (solid shape): 99.67,116.37 99.67,116.18 98.08,113.89 97.76,113.45 97.44,113.45 97.13,113.76 97.13,114.91 98.84,116.62 99.41,116.62
GND on TOP (solid shape): 266.23,63.23 266.23,62.53 265.46,61.76 263.83,61.76 263.71,61.88 263.71,63.5 263.84,63.62 265.83,63.62
GND on TOP (solid shape): 77.44,77.44 77.44,75.6 77.12,75.28 75.03,75.28 74.78,75.54 74.78,77.44 74.9,77.57 77.32,77.57
GND on TOP (solid shape): 148.76,94.27 148.76,90.49 148.74,90.47 147.89,90.47 147.73,90.63 147.73,94.1 147.99,94.36 148.67,94.36
GND on TOP (solid shape): 173.35,88.69 173.35,88.38 173.28,88.3 172.69,88.3 172.49,88.1 171.51,88.1 171.37,88.24 171.37,88.71 171.54,88.87 173.17,88.87
GND on TOP (solid shape): 225.44,102.11 225.44,97.23 225.07,96.86 222.02,96.86 221.82,97.06 221.82,102.06 222.07,102.31 225.24,102.31
GND on TOP (solid shape): 286.94,42.05 286.94,40.44 287.61,39.77 287.61,39.23 287.38,38.99 286.38,38.99 285.39,39.99 285.39,41.98 285.67,42.27 286.73,42.27
GND on TOP (solid shape): 88.38,78.33 88.38,76.94 88.28,76.84 87.05,76.84 86.8,77.1 86.8,77.98 86.92,78.1 87.3,78.1 87.58,78.38 88.33,78.38
GND on TOP (solid shape): 241.59,94.46 241.59,92.87 241.78,92.68 242.54,92.68 242.54,90.97 240.83,90.97 240.83,92.93 240.38,93.38 240.38,95.09 240.45,95.16 240.89,95.16
GND on TOP (solid shape): 71.47,90.59 71.98,90.59 72.11,90.46 72.11,89.95 71.98,89.82 69.44,89.82 69.31,89.95 69.31,91.35 69.44,91.47 70.58,91.47
GND on TOP (solid shape): 71.35,113 71.35,111.16 70.97,110.78 69.44,110.78 69.44,111.35 67.41,111.35 67.41,110.78 66.08,110.78 65.76,111.1 65.76,113.06 66.14,113.45 70.9,113.45
GND on TOP (solid shape): 183.68,68.88 183.73,68.83 183.73,67.27 183.61,67.15 182.18,67.15 181.91,67.43 181.91,69.5 181.93,69.52 183.05,69.52
GND on TOP (solid shape): 247.5,94.46 247.5,90.59 247.37,90.46 246.29,90.46 246.19,90.56 246.19,94.48 246.29,94.59 247.37,94.59
GND on TOP (solid shape): 286.99,45.87 288.06,45.87 288.16,45.77 288.16,45.46 288.01,45.31 287.53,45.31 287.33,45.12 285.63,45.12 285.4,45.35 285.4,45.89 285.66,46.15 286.71,46.15
GND on TOP (solid shape): 287.35,52.15 288.11,52.15 288.2,52.07 288.2,51.72 288.11,51.63 287.55,51.63 287.3,51.38 285.68,51.38 285.43,51.63 285.43,52.17 285.7,52.43 287.07,52.43
GND on TOP (solid shape): 33.69,48.8 33.69,47.98 33.56,47.85 33.31,47.85 33.06,48.1 29.31,48.1 29.18,48.23 29.18,48.8 29.31,48.93 33.56,48.93
GND on TOP (solid shape): 181.86,63.26 181.86,62.19 181.69,62.02 177.78,62.02 177.52,62.28 177.52,63.06 177.69,63.23 178.81,63.23 179.31,63.73 179.31,64.21 179.55,64.45 180.67,64.45
GND on TOP (solid shape): 206.52,103.75 206.52,98.6 206.29,98.37 204.23,98.37 203.97,98.63 203.97,100.69 204.61,101.34 204.61,103.72 204.84,103.95 206.32,103.95
GND on TOP (solid shape): 272.54,106.98 272.54,105.07 273.22,104.38 273.22,103.09 273.12,102.99 272.18,102.99 269.83,105.33 269.83,106.35 270.62,107.13 272.38,107.13
GND on TOP (solid shape): 210.69,85.27 210.69,84.16 210.36,83.83 210.36,79.78 209.79,79.21 208.09,79.21 207.76,79.53 207.76,80.86 208.06,81.16 208.06,84.81 208.64,85.39 210.57,85.39
GND on TOP (solid shape): 222.13,92.14 222.13,91.04 222.39,90.77 222.69,90.77 222.88,90.58 222.88,87.25 222.72,87.09 221.61,87.09 221.28,87.43 221.28,89.77 220.96,90.08 220.96,92.1 221.14,92.29 221.98,92.29
GND on TOP (solid shape): 52.87,47.21 52.87,44.01 52.76,43.89 51.4,43.89 51.23,43.72 51.23,41.01 50.96,40.74 49.25,40.74 48.68,41.31 48.68,46.52 49.54,47.38 52.71,47.38
GND on TOP (solid shape): 95.32,81.07 95.32,78.82 95.5,78.64 96.93,78.64 97.08,78.5 97.08,77.34 96.96,77.22 92.57,77.22 92.4,77.39 92.4,81.09 92.77,81.45 94.94,81.45
GND on TOP (solid shape): 63.85,46.64 63.85,41.94 62.46,40.55 58.94,40.55 58.75,40.73 58.75,41.71 58.99,41.94 61.98,41.94 62.2,42.17 62.2,43.34 61.82,43.72 61.17,43.72 61.05,43.85 61.05,48.7 61.14,48.8 61.7,48.8
GND on TOP (solid shape): 105.19,106.14 105.19,105.19 105.64,104.75 105.64,97.82 104.96,97.15 103.68,97.15 103.41,97.42 103.41,104.75 104.05,105.38 104.05,106.14 104.18,106.27 105.06,106.27
GND on TOP (solid shape): 132.05,117.51 132.05,116.56 131.99,116.49 131.15,116.49 130.97,116.32 130.45,116.32 130.21,116.07 130.21,115.67 130.08,115.54 127.94,115.54 127.76,115.72 127.76,116.71 128.62,117.57 131.99,117.57
GND on TOP (solid shape): 302.74,78.11 302.74,76.32 302.56,76.15 302.02,76.15 301.05,77.11 297.89,77.11 297.89,77.66 297.88,77.67 297.33,77.67 297.33,77.11 297.09,77.11 297.09,77.67 296.53,77.67 296.53,77.11 296.09,77.11 295.93,77.26 295.93,79.6 296.38,80.04 300.81,80.04
GND on TOP (solid shape): 224.76,86.39 224.76,85.76 225.4,85.12 225.4,83.73 227.04,83.73 227.04,84.98 227.28,84.98 227.28,83.07 227.24,83.03 224.64,83.03 224.38,82.77 222.82,82.77 222.51,82.46 222.51,81.83 223.1,81.24 223.1,78.49 222.93,78.33 221.52,78.33 221.26,78.6 221.26,85.37 222.7,86.81 224.35,86.81
GND on TOP (solid shape): 241.02,46.39 241.02,45.85 240.92,45.75 240.79,45.75 240.5,45.71 240.34,45.45 240.34,45.43 240.09,45.18 238.73,45.18 238.54,44.99 238.54,44.29 236.83,44.29 236.83,46.01 239.11,46.01 239.62,46.52 240.89,46.52
GND on TOP (solid shape): 196.11,83.54 196.23,83.52 196.34,83.54 196.34,83.55 196.5,83.55 196.93,83.11 196.93,83.11 197.15,82.89 197.15,82.15 197.08,82.08 196.9,82.08 196.55,82.06 196.42,81.73 196.39,81.65 196.32,81.62 196.1,81.62 196.01,81.71 196.01,82.73 195.52,83.23 195.52,83.46 195.6,83.55 196.11,83.55
GND on TOP (solid shape): 251.98,42.2 251.98,41.87 252.08,41.77 252.08,40.79 251.93,40.65 250.68,40.65 250.6,40.69 250.58,40.78 250.46,41.13 250.08,41.14 249.97,41.13 249.92,41.22 249.92,42.4 250.02,42.5 251.68,42.5
GND on TOP (solid shape): 157.36,97.25 157.36,96.5 157.55,96.31 158.18,96.31 158.38,96.12 158.38,95.93 158.23,95.79 157.88,95.79 157.84,95.75 157.84,95.29 158.05,95.08 158.26,95.08 158.38,94.97 158.38,94.68 158.24,94.55 157.93,94.55 157.83,94.45 157.83,94.04 158.05,93.82 159.09,93.82 159.14,93.77 159.14,92.53 158.96,92.36 158.05,92.36 157.83,92.14 157.83,89.45 157.73,89.34 155.29,89.34 155.28,89.35 155.28,89.75 155.39,89.86 155.92,89.86 156.17,90.12 156.43,90.12 156.66,90.35 156.66,94.23 156.38,94.52 156.38,97.17 156.57,97.36 157.25,97.36
GND on TOP (solid shape): 79.09,69.76 79.09,62.26 76.68,59.85 69.95,59.85 69.82,59.98 69.82,60.32 74.04,60.32 74.04,60.27 74.05,60.22 74.07,60.17 74.1,60.12 74.13,60.08 74.17,60.04 74.22,60.01 74.26,59.99 74.31,59.97 74.37,59.97 74.42,59.97 74.47,59.97 74.52,59.99 74.57,60.01 74.62,60.04 74.66,60.08 74.69,60.12 74.71,60.17 74.73,60.22 74.75,60.27 74.75,60.32 74.75,60.37 74.73,60.43 74.71,60.48 74.69,60.52 74.66,60.56 74.62,60.6 74.57,60.63 74.52,60.65 74.47,60.67 74.42,60.68 74.37,60.68 74.31,60.67 74.26,60.65 74.22,60.63 74.17,60.6 74.13,60.56 74.1,60.52 74.07,60.48 74.05,60.43 74.04,60.37 74.04,60.32 69.82,60.32 69.82,61.25 70.08,61.5 75.16,61.5 75.66,62.01 75.66,66.46 75.79,66.58 77.19,66.58 77.82,67.22 77.82,69.88 77.89,69.95 78.9,69.95
GND on TOP (solid shape): 151.78,89.6 151.78,88.82 152.14,88.46 152.83,88.46 152.92,88.37 152.92,88.11 152.8,87.99 152.63,87.99 152.62,87.99 152.48,87.99 152.38,87.89 152.38,87.41 152.22,87.25 151.7,87.25 151.59,87.36 151.59,87.58 151.41,87.77 150.89,87.77 150.6,87.48 150.6,87.23 150.54,87.17 150.03,87.17 150,87.2 150,88.24 151.42,88.24 151.42,88.19 151.43,88.14 151.45,88.09 151.47,88.04 151.5,88 151.54,87.96 151.58,87.93 151.62,87.91 151.67,87.89 151.73,87.88 151.78,87.88 151.83,87.89 151.88,87.91 151.92,87.93 151.97,87.96 152,88 152.03,88.04 152.06,88.09 152.07,88.14 152.08,88.19 152.08,88.24 152.07,88.29 152.06,88.34 152.03,88.39 152,88.43 151.97,88.46 151.92,88.5 151.88,88.52 151.83,88.53 151.78,88.54 151.73,88.54 151.67,88.53 151.62,88.52 151.58,88.5 151.54,88.46 151.5,88.43 151.47,88.39 151.45,88.34 151.43,88.29 151.42,88.24 150,88.24 150,89.54 150.12,89.66 151.72,89.66
GND on TOP (solid shape): 234.5,38.04 236.75,40.29 239,38.04 239,37.03 238.75,36.91 238.75,36.49 238.67,36.32 238.5,36.24 235,36.24 234.83,36.32 234.75,36.49 234.75,36.91 234.5,37.03
GND on TOP (solid shape): outline of 85 points within 213.86,79.12 217.47,85.41
GND on TOP (solid shape): 260.17,47.56 260.37,47.44 260.59,47.48 260.63,47.5 260.96,47.18 260.96,46.43 260.91,46.38 260.91,46.01 260.7,45.81 260.52,45.81 260.37,45.96 260.3,45.96 260.3,46.04 260.32,46.05 260.43,46.56 259.91,46.63 259.85,46.61 259.79,46.63 259.3,46.61 259.29,46.13 259.3,46.02 259.21,45.96 258.81,45.96 258.73,46.03 258.73,47.52 258.77,47.56 259,47.56 259,47.56
GND on TOP (solid shape): 302.37,91 302.54,90.92 302.62,90.75 302.62,85.75 302.84,85.22 303.37,85 305,85 305.17,84.92 305.25,84.75 305.25,55.17 305.17,55 305,54.92 304.65,54.92 304.12,54.7 303.9,54.17 303.9,54.15 303.39,54.15 303.39,54.17 303.76,55.06 304.65,55.43 304.74,55.43 304.74,84.49 303.37,84.49 302.48,84.86 302.11,85.75 302.11,89.3 291.25,89.3 290.89,89.66 290.89,90.59 291.3,91
GND on TOP (solid shape): 77.3,141.85 77.47,141.77 77.55,141.6 77.55,138.35 77.77,137.82 78.3,137.6 81.2,137.6 81.73,137.82 81.95,138.35 81.95,141.6 82.03,141.77 82.2,141.85 82.3,141.85 82.47,141.77 82.55,141.6 82.55,141.25 82.77,140.72 83.3,140.5 83.8,140.5 83.97,140.42 84.05,140.25 84.05,131.8 84.05,131.7 84.07,131.61 84.07,130.49 83.73,130.15 75.79,130.15 75.45,130.48 75.45,140.25 75.53,140.42 75.7,140.5 76.2,140.5 76.73,140.72 76.95,141.25 76.95,141.6 77.03,141.77 77.2,141.85
GND on TOP (solid shape): outline of 444 points within 284,105 305.25,140.78
GND on TOP (solid shape): outline of 589 points within 214.22,39.94 220.42,55.76
GND on TOP (solid shape): outline of 119 points within 0.25,27.1 71.76,141.85
GND on TOP (solid shape): outline of 158 points within 98.45,126.72 266.9,142.2
GND on TOP (solid shape): outline of 167 points within 26.95,0.25 304.55,42.16
GND on TOP (solid shape): outline of 1197 points within 124.9,41.82 141.41,54.88
GND on TOP (solid shape): outline of 1256 points within 161.34,43.52 186.4,47.7
GND on TOP (solid shape): outline of 1314 points within 83.81,42.46 104.56,47.68
GND on BOTTOM (solid shape): 160.11,43.15 153.98,43.15 153.98,52.15 160.11,52.15
GND on BOTTOM (solid shape): 41.37,42.77 41.37,41.75 41.12,41.5 39.91,41.5 39.85,41.56 39.85,42.96 39.91,43.02 41.12,43.02
GND on BOTTOM (solid shape): 43.53,39.98 43.53,38.77 43.47,38.71 40.29,38.71 40.23,38.77 40.23,39.98 40.42,40.17 43.34,40.17
GND on BOTTOM (solid shape): 88.66,80.3 88.66,77.01 88.46,76.81 87.01,76.81 86.73,77.09 86.73,80.23 87.01,80.51 88.46,80.51
GND on BOTTOM (solid shape): 141.83,112.05 141.83,111.03 141.7,110.91 139.42,110.91 139.29,111.03 139.29,112.05 139.42,112.18 141.7,112.18
GND on BOTTOM (solid shape): 206.47,103.42 206.47,98.57 206.28,98.37 204.24,98.37 203.98,98.64 203.98,103.32 204.21,103.55 206.33,103.55
GND on BOTTOM (solid shape): 64.36,48 64.36,43.91 64.11,43.66 60.78,43.66 58.96,44.99 58.96,45.44 61.57,49.12 61.82,49.44 61.87,49.46 62.17,49.46
GND on BOTTOM (solid shape): 99.03,106.21 99.03,101.25 98.78,101 97.51,101 97.25,101.25 97.25,105.57 98.02,106.33 98.91,106.33
GND on BOTTOM (solid shape): 108.85,114.47 108.85,111.82 108.57,111.54 105,111.54 104.75,111.79 104.75,114.46 105,114.72 108.61,114.72
GND on BOTTOM (solid shape): 118.53,115.29 118.53,111.87 118.08,111.43 116.08,111.43 115.42,112.09 115.42,115.22 115.61,115.41 118.4,115.41
GND on BOTTOM (solid shape): 118.59,79.54 118.59,76.3 118.06,75.77 111.22,75.77 110.91,76.08 110.91,79.54 111.03,79.66 118.46,79.66
GND on BOTTOM (solid shape): 132.62,111.98 132.62,111.45 132.77,111.3 132.77,110.2 132.71,110.14 131.1,110.14 131.1,111.73 131.48,112.11 132.5,112.11
GND on BOTTOM (solid shape): 141.83,117 141.83,115.99 141.7,115.86 138.92,115.86 138.77,116.01 138.77,116.86 139,117.1 141.74,117.1
GND on BOTTOM (solid shape): 225.44,101.98 225.44,97.24 225.07,96.88 222.05,96.88 221.79,97.14 221.79,101.92 221.98,102.12 225.3,102.12
GND on BOTTOM (solid shape): 288.25,107.29 288.25,106.78 288.25,104.21 288.08,104.05 285.93,104.05 285.6,104.38 285.6,107.32 285.91,107.62 287.92,107.62
GND on BOTTOM (solid shape): 33.69,48.8 33.69,47.98 33.56,47.85 29.88,47.85 29.25,48.48 29.25,48.74 29.37,48.87 31.53,48.87 31.6,48.93 33.56,48.93
GND on BOTTOM (solid shape): 111.48,110.52 111.48,107.1 111.22,106.84 107.79,106.84 107.47,107.16 107.47,110.5 107.75,110.78 111.22,110.78
GND on BOTTOM (solid shape): 131.18,116.96 131.18,116.49 130.97,116.29 130.48,116.29 130.21,116.02 130.21,115.03 130.11,114.93 128.53,114.93 127.86,115.6 127.86,116.68 128.31,117.13 131.01,117.13
GND on BOTTOM (solid shape): 205.74,89.98 205.74,88.98 205.27,88.51 205.27,87.9 205.16,87.78 204.39,87.78 204.29,87.88 204.29,88.7 203.89,89.1 203.89,90.45 204.08,90.64 205.08,90.64
GND on BOTTOM (solid shape): 217.17,118.92 217.17,117.68 217.12,117.63 216.68,117.63 216.55,117.76 216.1,117.76 216.04,117.81 216.04,119.58 216.11,119.64 216.45,119.64
GND on BOTTOM (solid shape): 218.02,108.56 218.02,107.49 217.79,107.26 215.78,107.26 215.69,107.35 215.69,108.01 215.78,108.1 216.47,108.1 216.63,108.26 216.63,108.58 216.75,108.7 217.88,108.7
GND on BOTTOM (solid shape): 222.11,92.07 222.11,89.9 221.85,89.64 221.85,88.29 221.62,88.06 220.34,88.06 220.17,88.23 220.17,90.17 220.31,90.31 220.31,91.99 220.57,92.25 221.94,92.25
GND on BOTTOM (solid shape): 94.72,81.45 94.72,76.16 94.66,76.1 94.44,76.1 94.43,76.09 92.61,76.09 92.47,76.23 92.47,81.44 92.59,81.56 94.61,81.56
GND on BOTTOM (solid shape): 226.92,117.45 226.92,116.94 227.18,116.68 227.18,115.73 227.11,115.67 226.67,115.67 226.46,115.88 226.46,116.58 226.6,116.72 226.6,117.45 226.67,117.51 226.86,117.51
GND on BOTTOM (solid shape): 86.88,98.5 86.88,96.19 85.28,94.59 82.57,94.59 80.48,96.68 79.77,97.42 79.19,97.24 78.38,96.95 78.15,97.11 78.06,97.38 78.13,97.67 78.53,97.91 80.77,100.15 85.23,100.15
GND on BOTTOM (solid shape): 105.6,105.35 105.6,98.42 105.31,98.14 103.61,98.14 103.41,98.33 103.41,98.34 103.38,98.37 103.38,104.4 103.03,104.75 103.03,105.63 103.1,105.7 105.26,105.7
GND on BOTTOM (solid shape): 97.36,80.55 97.36,80.29 97.22,80.15 94.97,80.15 94.89,80.22 94.89,80.32 94.96,80.39 96.21,80.39 96.5,80.68 97.23,80.68
GND on BOTTOM (solid shape): 219.15,121.11 219.15,119.21 219.04,119.11 218.53,119.11 218.3,119.34 218.3,120.21 218.14,120.36 216.76,120.36 216.67,120.46 216.67,120.92 216.84,121.09 217.18,121.09 217.46,121.38 218.88,121.38
GND on BOTTOM (solid shape): 239.9,50.89 240.19,50.89 240.4,50.68 240.4,49.83 240.26,49.69 239.13,49.69 239.07,49.75 239.07,50.77 239.19,50.9 239.9,50.9
GND on BOTTOM (solid shape): 126.85,116.75 126.85,116.24 126.78,116.18 126.34,116.18 126.08,115.92 126.08,113.83 126.02,113.76 125.19,113.76 125.13,113.83 125.13,115.03 125,115.16 124.18,115.16 124.05,115.29 124.05,116.37 124.5,116.81 126.78,116.81
GND on BOTTOM (solid shape): 295.11,54.82 295.11,53.84 294.85,53.59 290.17,53.59 287.46,50.88 287.46,48.24 288.38,47.33 288.38,39.66 287.66,38.94 286.73,38.94 286.45,39.23 286.45,46.11 285.29,47.27 285.29,51.25 289.01,54.97 294.95,54.97
GND on BOTTOM (solid shape): 95.73,108.62 95.73,108.43 95.16,107.6 94.97,107.6 94.59,107.86 93.7,108.49 93.44,108.68 93.41,108.92 93.48,109.1 93.45,109.28 93.83,109.83 94.08,109.83
GND on BOTTOM (solid shape): 224.38,87.09 224.38,84.53 223.58,83.73 221.84,83.73 221.71,83.85 221.71,84.36 221.9,84.55 223.37,84.55 223.68,84.87 223.68,85.95 223.49,86.14 222.86,86.14 222.79,86.2 222.79,87.09 222.92,87.22 224.25,87.22
GND on BOTTOM (solid shape): 79.09,75.56 79.11,75.53 79.11,75.31 79.08,75.27 79,75.19 78.76,75.19 78.46,75.5 78.33,75.5 78.12,75.71 77.23,75.71 77.18,75.76 77.18,75.85 77.23,75.9 78.14,75.9 78.22,75.98 78.67,75.98
GND on BOTTOM (solid shape): 287.67,93.25 287.67,91.75 286.28,91.62 285.01,91.02 283.29,91.02 282.82,91.48 282.82,93.18 283.06,93.41 287.51,93.41
GND on BOTTOM (solid shape): 8.06,35.42 8.1,35.34 8.1,34.07 7.97,33.94 6.26,33.94 6.13,34.07 6.13,35.09 6.31,35.27 6.34,35.26 7.16,35.27 7.97,35.43
GND on BOTTOM (solid shape): 103.58,128.03 104.84,127.18 106.24,126.58 106.25,126.57 106.47,126.35 106.47,123.71 102,119.24 100,119.24 98.61,117.85 97.13,117.85 96.28,118.7 96.28,120.38 100.06,124.16 100.06,126.26 101.84,128.04 103.56,128.04
GND on BOTTOM (solid shape): 89,89.82 89,89.32 88.36,88.68 88.36,88.05 88.62,87.79 89.13,87.79 89.25,87.66 89.25,85.12 89,84.87 87.78,84.87 87.71,84.94 87.71,85.44 87.78,85.51 88.49,85.51 88.62,85.63 88.62,86.39 88.49,86.52 86.71,86.52 86.59,86.39 86.59,85.89 86.46,85.76 84.17,85.76 84.05,85.89 84.05,87.41 84.17,87.54 85.19,87.54 85.57,87.92 85.57,89.82 85.7,89.95 88.87,89.95
GND on BOTTOM (solid shape): 217.49,88.07 217.49,87.01 217.86,86.64 217.86,85.07 217.94,84.99 217.94,83.15 217.48,82.69 217.48,80.39 217.68,80.19 217.68,78.59 217.58,78.49 215.23,78.49 214.87,78.85 214.87,80.82 215.12,81.07 215.74,81.07 215.83,81.15 215.83,83.31 216.11,83.59 216.8,83.59 217.2,83.99 217.2,84.98 216.82,85.36 216.82,86.85 217.22,87.25 217.22,88.07 217.28,88.13 217.43,88.13
GND on BOTTOM (solid shape): 57.63,57.37 57.63,56.96 57.51,56.84 57.48,56.86 57.28,56.9 57.09,56.83 56.26,56.83 55.98,56.55 55.98,55.09 55.92,55.03 55.15,55.03 54.9,54.78 54.9,53.01 54.82,52.93 52.79,52.93 52.62,53.09 52.62,56.12 52.42,56.31 52.42,57.06 52.49,57.12 53.12,57.12 53.44,56.8 54.26,56.8 54.33,56.87 54.33,57.44 54.39,57.5 57.5,57.5
GND on BOTTOM (solid shape): 209.19,88.37 209.19,87.45 209.54,87.1 209.54,85.39 209.65,85.28 209.65,84.42 209.88,84.19 210.08,84.19 210.33,83.94 210.33,82.41 210.15,82.23 209.32,82.23 209.13,82.04 209.13,79.43 208.88,79.19 207.81,79.19 207.58,79.41 207.58,80.8 207.98,81.19 207.98,82.92 208.13,83.07 208.13,83.72 208.9,84.49 208.9,85.54 208.5,85.94 208.5,87.15 208.9,87.55 208.9,88.37 208.98,88.45 209.11,88.45
GND on BOTTOM (solid shape): 51.09,134.63 51.18,134.58 51.18,134.48 51.16,134.44 51.15,134.39 51.14,134.34 51.14,133.76 51.45,133.45 51.76,133.76 51.76,134.34 51.75,134.39 51.74,134.44 51.72,134.48 51.72,134.58 51.81,134.63 52.74,134.63 52.88,134.49 52.88,132.37 52.7,132.19 51.32,132.19 51.03,132.49 51.03,133.09 50.56,133.56 50.56,134.43 50.75,134.63
GND on BOTTOM (solid shape): 234.5,38.04 236.75,40.29 239,38.04 239,37.03 238.75,36.91 238.75,36.49 238.67,36.32 238.5,36.24 235,36.24 234.83,36.32 234.75,36.49 234.75,36.91 234.5,37.03
GND on BOTTOM (solid shape): 302.37,91 302.54,90.92 302.62,90.75 302.62,85.75 302.84,85.22 303.37,85 305,85 305.17,84.92 305.25,84.75 305.25,55.17 305.17,55 305,54.92 304.65,54.92 304.12,54.7 303.9,54.17 303.9,54.15 303.39,54.15 303.39,54.17 303.76,55.06 304.65,55.43 304.74,55.43 304.74,84.49 303.37,84.49 302.48,84.86 302.11,85.75 302.11,89.3 291.25,89.3 290.89,89.66 290.89,90.55 291.34,91
GND on BOTTOM (solid shape): 77.3,141.85 77.47,141.77 77.55,141.6 77.55,138.35 77.77,137.82 78.3,137.6 81.2,137.6 81.73,137.82 81.95,138.35 81.95,141.6 82.03,141.77 82.2,141.85 82.3,141.85 82.47,141.77 82.55,141.6 82.55,141.25 82.77,140.72 83.3,140.5 83.8,140.5 83.97,140.42 84.05,140.25 84.05,131.8 84.05,131.7 84.07,131.61 84.07,130.49 83.73,130.15 80.77,130.15 80.61,129.99 78.83,129.99 78.67,130.15 75.79,130.15 75.45,130.48 75.45,140.25 75.53,140.42 75.7,140.5 76.2,140.5 76.73,140.72 76.95,141.25 76.95,141.6 77.03,141.77 77.2,141.85
GND on BOTTOM (solid shape): 284.65,140.78 285.18,140.56 285.4,140.03 285.4,137.76 285.57,137.71 285.95,137.44 286.1,137 286.1,133.65 286.46,132.76 287.35,132.4 295.94,132.4 296.56,132.4 296.66,132.38 296.74,132.32 298.75,131.45 300.76,132.32 300.84,132.38 300.94,132.4 303.5,132.4 304.66,131.96 305.23,130.86 305.24,130.75 305.25,130.65 305.25,112.2 305.25,111.25 305.17,111.08 305,111 304.68,110.93 304.42,110.73 304.29,110.51 304.25,110.25 304.25,108.65 304.25,108.54 304.28,108.43 304.55,108.04 305,107.9 305.17,107.82 305.25,107.65 305.25,107.25 305.17,107.08 305,107 304.26,107 303.37,107 302.84,106.78 302.62,106.25 302.62,105.25 302.54,105.08 302.37,105 290.94,105 290.81,105.13 290.81,106.16 291.27,106.61 301.46,106.61 301.89,107.04 301.89,112.12 302.46,112.7 304.23,112.7 304.74,113.2 304.74,130.65 304.73,130.75 304.72,130.86 304.3,131.6 303.5,131.89 301.05,131.89 298.75,130.94 296.45,131.89 295.94,131.89 287.35,131.89 287.28,131.89 287.22,131.89 285.02,131.89 284,132.9 284,140.53 284.08,140.7 284.25,140.78
GND on BOTTOM (solid shape): outline of 123 points within 0.25,27.1 71.76,141.85
GND on BOTTOM (solid shape): outline of 167 points within 96.28,117.85 266.9,142.2
GND on BOTTOM (solid shape): outline of 183 points within 26.95,0.25 304.55,42.16
GND on BOTTOM (solid shape): outline of 3288 points within 126.36,39.68 148.47,52.53
GND on BOTTOM (solid shape): outline of 3356 points within 206.82,39.65 228.94,52.21
GND on BOTTOM (solid shape): outline of 3506 points within 82.51,39.95 110.04,52.01
GND on BOTTOM (solid shape): outline of 3770 points within 161.59,39.68 190.6,52.25
GND on IN1 (solid shape): 302.37,91 302.54,90.92 302.62,90.75 302.62,85.75 302.84,85.22 303.37,85 305,85 305.17,84.92 305.25,84.75 305.25,55.17 305.17,55 305,54.92 304.65,54.92 304.12,54.7 303.9,54.17 303.9,54.15 303.39,54.15 303.39,54.17 303.76,55.06 304.65,55.43 304.74,55.43 304.74,84.49 303.37,84.49 302.48,84.86 302.11,85.75 302.11,89.3 291.25,89.3 290.89,89.66 290.89,90.59 291.3,91
GND on IN1 (solid shape): 77.3,141.85 77.47,141.77 77.55,141.6 77.55,138.35 77.77,137.82 78.3,137.6 81.2,137.6 81.73,137.82 81.95,138.35 81.95,141.6 82.03,141.77 82.2,141.85 82.3,141.85 82.47,141.77 82.55,141.6 82.55,141.25 82.77,140.72 83.3,140.5 83.8,140.5 83.97,140.42 84.05,140.25 84.05,131.8 84.05,131.7 84.07,131.61 84.07,130.49 83.73,130.15 75.79,130.15 75.45,130.48 75.45,140.25 75.53,140.42 75.7,140.5 76.2,140.5 76.73,140.72 76.95,141.25 76.95,141.6 77.03,141.77 77.2,141.85
GND on IN1 (solid shape): 284.65,140.78 285.18,140.56 285.4,140.03 285.4,137.76 285.57,137.71 285.95,137.44 286.1,137 286.1,133.65 286.46,132.76 287.35,132.4 295.94,132.4 296.56,132.4 296.66,132.38 296.74,132.32 298.75,131.45 300.76,132.32 300.84,132.38 300.94,132.4 303.5,132.4 304.66,131.96 305.23,130.86 305.24,130.75 305.25,130.65 305.25,111.25 305.17,111.08 304.47,110.78 304.25,110.25 304.25,108.65 304.47,108.12 305.17,107.82 305.25,107.65 305.25,107.25 305.17,107.08 305,107 303.37,107 302.84,106.78 302.62,106.25 302.62,105.25 302.54,105.08 302.37,105 292.87,105 292.82,105 290.94,105 290.81,105.13 290.81,106.16 291.27,106.61 302.06,106.61 302.22,106.78 302.69,107.31 303.37,107.51 304.45,107.51 303.93,107.98 303.74,108.65 303.74,110.25 304.02,111.04 304.74,111.48 304.74,130.65 304.73,130.75 304.72,130.86 304.3,131.6 303.5,131.89 301.05,131.89 298.75,130.94 296.45,131.89 295.94,131.89 287.35,131.89 287.28,131.89 287.22,131.89 285.02,131.89 284,132.9 284,140.53 284.08,140.7 284.25,140.78
GND on IN1 (solid shape): outline of 594 points within 139.79,42.88 148.23,48.18
GND on IN1 (solid shape): outline of 122 points within 0.25,27.1 71.76,141.85
GND on IN1 (solid shape): outline of 158 points within 98.45,126.72 266.9,142.2
GND on IN1 (solid shape): outline of 200 points within 26.95,0.25 304.55,42.16
GND on IN1 (solid shape): outline of 3053 points within 185.48,43.29 229.08,51.55
GND on IN2 (solid shape): 302.37,91 302.54,90.92 302.62,90.75 302.62,85.75 302.84,85.22 303.37,85 305,85 305.17,84.92 305.25,84.75 305.25,55.17 305.17,55 305,54.92 304.65,54.92 304.12,54.7 303.9,54.17 303.9,54.15 303.39,54.15 303.39,54.17 303.76,55.06 304.65,55.43 304.74,55.43 304.74,84.49 303.37,84.49 302.48,84.86 302.11,85.75 302.11,89.3 291.25,89.3 290.89,89.66 290.89,90.59 291.3,91
GND on IN2 (solid shape): 77.3,141.85 77.47,141.77 77.55,141.6 77.55,138.35 77.77,137.82 78.3,137.6 81.2,137.6 81.73,137.82 81.95,138.35 81.95,141.6 82.03,141.77 82.2,141.85 82.3,141.85 82.47,141.77 82.55,141.6 82.55,141.25 82.77,140.72 83.3,140.5 83.8,140.5 83.97,140.42 84.05,140.25 84.05,131.8 84.05,131.7 84.07,131.61 84.07,130.49 83.73,130.15 75.79,130.15 75.45,130.48 75.45,140.25 75.53,140.42 75.7,140.5 76.2,140.5 76.73,140.72 76.95,141.25 76.95,141.6 77.03,141.77 77.2,141.85
GND on IN2 (solid shape): 284.65,140.78 285.18,140.56 285.4,140.03 285.4,137.76 285.57,137.71 285.95,137.44 286.1,137 286.1,133.65 286.46,132.76 287.35,132.4 295.94,132.4 296.56,132.4 296.66,132.38 296.74,132.32 298.75,131.45 300.76,132.32 300.84,132.38 300.94,132.4 303.5,132.4 304.66,131.96 305.23,130.86 305.24,130.75 305.25,130.65 305.25,111.25 305.17,111.08 304.47,110.78 304.25,110.25 304.25,108.65 304.47,108.12 305.17,107.82 305.25,107.65 305.25,107.25 305.17,107.08 305,107 303.37,107 302.84,106.78 302.62,106.25 302.62,105.25 302.54,105.08 302.37,105 292.87,105 292.86,105.01 290.93,105.01 290.81,105.13 290.81,106.16 291.27,106.61 302.06,106.61 302.22,106.78 302.69,107.31 303.37,107.51 304.45,107.51 303.93,107.98 303.74,108.65 303.74,110.25 304.02,111.04 304.74,111.48 304.74,130.65 304.73,130.75 304.72,130.86 304.3,131.6 303.5,131.89 301.05,131.89 298.75,130.94 296.45,131.89 295.94,131.89 287.35,131.89 287.28,131.89 287.22,131.89 285.02,131.89 284,132.9 284,140.53 284.08,140.7 284.25,140.78
GND on IN2 (solid shape): outline of 122 points within 0.25,27.1 71.76,141.85
GND on IN2 (solid shape): outline of 160 points within 98.45,126.72 266.9,142.2
GND on IN2 (solid shape): outline of 200 points within 26.95,0.25 304.55,42.16
GND on IN2 (solid shape): outline of 4294 points within 160.01,43.33 228.19,48.89
GND on IN2 (solid shape): outline of 5164 points within 81.05,39.88 147.65,48.89
GND on IN3 (solid shape): 55.47,56.71 55.47,54.15 55.38,54.06 52.73,54.06 52.61,54.17 52.61,56.73 52.74,56.85 55.33,56.85
GND on IN3 (solid shape): 302.37,91 302.54,90.92 302.62,90.75 302.62,85.75 302.84,85.22 303.37,85 305,85 305.17,84.92 305.25,84.75 305.25,55.17 305.17,55 305,54.92 304.65,54.92 304.12,54.7 303.9,54.17 303.9,54.15 303.39,54.15 303.39,54.17 303.76,55.06 304.65,55.43 304.74,55.43 304.74,84.49 303.37,84.49 302.48,84.86 302.11,85.75 302.11,89.3 291.25,89.3 290.89,89.66 290.89,90.59 291.3,91
GND on IN3 (solid shape): 77.3,141.85 77.47,141.77 77.55,141.6 77.55,138.35 77.77,137.82 78.3,137.6 81.2,137.6 81.73,137.82 81.95,138.35 81.95,141.6 82.03,141.77 82.2,141.85 82.3,141.85 82.47,141.77 82.55,141.6 82.55,141.25 82.77,140.72 83.3,140.5 83.8,140.5 83.97,140.42 84.05,140.25 84.05,131.8 84.05,131.7 84.07,131.61 84.07,130.49 83.73,130.15 75.79,130.15 75.45,130.48 75.45,140.25 75.53,140.42 75.7,140.5 76.2,140.5 76.73,140.72 76.95,141.25 76.95,141.6 77.03,141.77 77.2,141.85
GND on IN3 (solid shape): 284.65,140.78 285.18,140.56 285.4,140.03 285.4,137.76 285.57,137.71 285.95,137.44 286.1,137 286.1,133.65 286.46,132.76 287.35,132.4 295.94,132.4 296.56,132.4 296.66,132.38 296.74,132.32 298.75,131.45 300.76,132.32 300.84,132.38 300.94,132.4 303.5,132.4 304.66,131.96 305.23,130.86 305.24,130.75 305.25,130.65 305.25,111.25 305.17,111.08 304.47,110.78 304.25,110.25 304.25,108.65 304.47,108.12 305.17,107.82 305.25,107.65 305.25,107.25 305.17,107.08 305,107 303.37,107 302.84,106.78 302.62,106.25 302.62,105.25 302.54,105.08 302.37,105 290.94,105 290.81,105.13 290.81,106.16 291.27,106.61 302.06,106.61 302.22,106.78 302.69,107.31 303.37,107.51 304.45,107.51 303.93,107.98 303.74,108.65 303.74,110.25 304.02,111.04 304.74,111.48 304.74,130.65 304.73,130.75 304.72,130.86 304.3,131.6 303.5,131.89 301.05,131.89 298.75,130.94 296.45,131.89 295.94,131.89 287.35,131.89 287.28,131.89 287.22,131.89 285.02,131.89 284,132.9 284,140.53 284.08,140.7 284.25,140.78
GND on IN3 (solid shape): outline of 122 points within 0.25,27.1 71.76,141.85
GND on IN3 (solid shape): outline of 158 points within 98.45,126.72 266.9,142.2
GND on IN3 (solid shape): outline of 200 points within 26.95,0.25 304.55,42.16
GND on IN3 (solid shape): outline of 4922 points within 161.11,41.08 228.62,49.98
GND on IN3 (solid shape): outline of 5376 points within 81.13,43.35 151.39,52.97
GND on IN4 (solid shape): 302.37,91 302.54,90.92 302.62,90.75 302.62,85.75 302.84,85.22 303.37,85 305,85 305.17,84.92 305.25,84.75 305.25,55.17 305.17,55 305,54.92 304.65,54.92 304.12,54.7 303.9,54.17 303.9,54.15 303.39,54.15 303.39,54.17 303.76,55.06 304.65,55.43 304.74,55.43 304.74,84.49 303.37,84.49 302.48,84.86 302.11,85.75 302.11,89.3 291.25,89.3 290.89,89.66 290.89,90.57 291.31,91

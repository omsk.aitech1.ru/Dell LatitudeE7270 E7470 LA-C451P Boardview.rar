# Allegro board LAC451PR10-0923B.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR_A_DQS1: length 75.9
  IN1 w0.091: v1(91.35,44.51) 91.35,44.72 91.25,44.83 90.92,44.83 90.71,45.04 90.71,46.4 91.29,46.99 91.29,48.66 93.25,50.62 93.25,51.05 93.63,51.43 93.63,51.56 93.37,51.82 93.37,52.09 93.69,52.42 93.97,52.42 94.23,52.16 94.36,52.16 94.58,52.38 94.58,52.51 94.32,52.77 94.32,53.04 94.64,53.37 94.92,53.37 95.18,53.11 95.31,53.11 95.58,53.38 95.58,53.51 95.33,53.76 95.33,54.04 95.65,54.36 95.92,54.36 96.18,54.11 96.31,54.11 96.58,54.38 96.58,54.51 96.32,54.77 96.32,55.04 96.64,55.37 96.92,55.37 97.18,55.11 97.31,55.11 97.58,55.38 97.58,55.51 97.3,55.79 97.3,56.06 97.62,56.39 97.9,56.39 98.18,56.11 98.31,56.11 98.53,56.33 98.53,56.46 98.25,56.74 98.25,57.01 98.57,57.33 98.85,57.33 99.13,57.05 99.26,57.05 102.24,60.04 102.8,60.04 116.18,73.43 118.15,73.43 120.05,75.33 126.03,75.33 129.4,78.7 129.4,81.42 v1(129.15,81.68)
  BOTTOM w0.076: v1(129.15,81.68) 129.37,81.9 129.37,82.33 130.02,82.98 130.97,82.98 131.94,83.94 131.95,83.94 131.99,83.99 132.92,83.99 133.09,84.16 133.58,84.16 133.71,84.1 133.82,84.1 133.95,84.16 134.23,84.16 134.31,84.12 134.53,84.12 134.65,84.18 134.67,84.2 134.67,84.35 134.63,84.39 UC1.AT70
  BOTTOM w0.102: JDIMM1.34 91.62,42.49 91.5,42.62 91.5,42.63 91.5,42.94 90.93,43.51 90.93,44.7 91,44.78 91.09,44.78 v1(91.35,44.51)
DDR_A_DQS2: length 58.4
  IN4 w0.076: 130.59,81.17 130.6,81.17 130.61,81.17 130.66,81.17 130.67,81.18 130.76,81.18 131.02,81.44 131.02,82.14 132.33,83.46 133.37,83.46 134.17,84.26 134.17,86.03 136.15,88.01 137.29,88.01 v1(137.66,88.38)
  IN4 w0.091: v1(135.54,45.35) 135.36,45.16 135.08,45.16 134.99,45.26 134.99,48.14 135.11,48.27 135.35,48.27 135.58,48.5 135.58,48.9 135.35,49.13 135.11,49.13 134.99,49.26 134.99,49.79 133.97,50.81 133.97,52.26 129.42,56.81 129.42,57.65 128.17,58.9 128.17,79.06 130.28,81.17 130.59,81.17
  BOTTOM w0.076: UC1.AH65 v1(137.66,88.38)
  BOTTOM w0.102: v1(135.54,45.35) 135.84,45.06 136.01,45.06 136.21,44.86 136.21,43.56 135.57,42.92 135.08,42.92 134.97,42.81 134.97,42.64 135.12,42.49 JDIMM1.200
DDR_A_DQS3: length 69
  IN4 w0.076: v1(130.35,88.87) 130.29,88.93 130.18,88.93 130.08,88.83 130.08,88.02 129.73,87.67 123.51,87.67 122.56,86.72 122.56,86.71 122.55,86.7
  IN4 w0.091: v1(130.46,46.87) 130.46,46.62 130.32,46.48 130.07,46.48 129.91,46.65 129.91,47.95 130.01,48.05 130.29,48.05 130.5,48.26 130.5,48.75 130.29,48.95 129.19,48.95 129.09,49.06 129.09,49.37 129.19,49.48 129.61,49.48 129.81,49.68 129.81,50.09 129.61,50.29 128.23,50.29 128.09,50.43 128.09,51.76 124.47,55.38 124.47,75.64 119.68,80.43 119.68,83.83 122.55,86.7
  BOTTOM w0.076: UC1.AG70 134.63,89.4 134.68,89.4 134.72,89.35 134.72,89.25 134.65,89.19 134.53,89.13 134.31,89.13 134.23,89.16 133.95,89.16 133.82,89.11 133.71,89.11 133.58,89.16 131.92,89.16 131.91,89.17 131.9,89.17 131.09,88.36 130.24,88.36 130.08,88.53 130.08,88.83 130.18,88.93 130.29,88.93 v1(130.35,88.87)
  BOTTOM w0.102: v1(130.46,46.87) 130.46,46.59 130.35,46.48 130.17,46.48 130.01,46.64 130.01,48.48 129.72,48.78 129.72,48.92 129.88,49.08 JDIMM1.179
DDR_A_DQS4: length 66.7
  IN1 w0.091: v1(97,46.11) 97,46.16 96.83,46.33 96.65,46.33 96.37,46.61 96.37,48.23 99.2,51.06 99.2,52.12 103.44,56.36 104.03,56.36 117.64,69.98 119.58,69.98 120.34,70.74 128.55,70.74 131,73.19 131,74.39 131.59,74.98 131.76,74.98 v1(132,75.22)
  BOTTOM w0.076: UC1.AY64 137.76,82.14 137.52,81.89 137.43,81.7 137.43,81.42 137.47,81.33 137.47,81.13 137.41,81.02 137.41,80.8 137.47,80.69 137.47,80.43 137.31,80.27 137.31,79.38 136.58,78.66 135.25,78.66
  BOTTOM w0.102: JDIMM1.55 96.88,48.59 97.65,47.82 97.65,46.63 97.32,46.3 97.18,46.3 v1(97,46.11) ; 135.25,78.66 135.24,78.65 133.61,78.65 132.74,77.78 132.74,75.29 132.51,75.06 132.17,75.06 v1(132,75.22)
DDR_A_DQS5: length 65.7
  IN1 w0.076: 133.72,70.76 133.79,70.84 133.8,70.84 133.84,70.87 136.4,73.44 136.4,75.66 137.32,76.58 137.71,76.58 137.75,76.63 v1(137.91,76.78)
  IN1 w0.091: 133.72,70.76 129.48,66.53 119.21,66.53 104.34,51.65 104.34,50.89 101.35,47.9 101.35,45.01 101.62,44.74 101.98,44.74 102.08,44.64 v1(102.08,44.51)
  BOTTOM w0.076: UC1.BA60 140.21,81.77 140.21,81.87 140.25,81.91 140.31,81.91 140.42,81.8 140.48,81.67 140.48,81.45 140.45,81.37 140.45,81.09 140.47,81.04 140.49,80.95 140.49,80.84 140.46,80.76 140.45,80.73 140.45,80.31 140.61,80.15 140.61,79.89 140.29,79.58 140.29,79.17 138.4,77.28 138.4,76.52 138.29,76.41 138.18,76.41 137.91,76.69 v1(137.91,76.78)
  BOTTOM w0.102: JDIMM1.76 102.13,42.65 101.97,42.8 101.97,43 101.62,43.35 101.62,44.72 101.7,44.8 101.79,44.8 v1(102.08,44.51)
DDR_A_DQS6: length 51.6
  IN4 w0.076: 134.51,81.23 134.51,81.3 134.94,81.73 135.73,81.73 136.59,82.59 136.59,84.86 136.78,85.05 136.9,85.05 v1(137.12,85.27)
  IN4 w0.091: 134.51,81.23 134.51,80.7 133.08,79.28 132.57,79.28 131.45,78.15 131.45,61.79 136.08,57.15 136.08,55.74 139.39,52.43 139.39,48.68 139.93,48.14 139.93,46.53 140.16,46.31 140.43,46.31 v1(140.62,46.11)
  BOTTOM w0.076: UC1.AR65 137.39,85 v1(137.12,85.27)
  BOTTOM w0.102: JDIMM1.221 140.37,48.65 140.54,48.49 140.9,48.49 141.27,48.12 141.27,46.56 141,46.3 140.81,46.3 v1(140.62,46.11)
DDR_A_DQS7: length 52.2
  IN4 w0.076: 139.55,82.45 139.55,82.46 139.56,82.47 139.56,82.52 139.57,82.53 139.57,82.83 139.33,83.07 139.33,84.87 139.48,85.02 139.59,85.02 139.84,85.27 v1(139.86,85.27)
  IN4 w0.091: v1(146.04,44.59) 146.04,44.59 145.84,44.79 145.66,44.79 145.3,45.15 145.3,48.19 144.4,49.09 144.4,50.32 144.25,50.47 144.25,53.94 135.36,62.83 135.36,77.41 135.77,77.82 136.45,77.82 138.36,79.73 138.36,80.92 139.55,82.11 139.55,82.45
  BOTTOM w0.076: UC1.AR60 140.14,85 v1(139.86,85.27)
  BOTTOM w0.102: JDIMM1.242 145.63,42.47 145.48,42.62 145.48,42.79 145.5,42.82 145.5,44.68 145.69,44.87 145.77,44.87 v1(146.04,44.59)
DDR_A_DQS#0: length 76.9
  IN1 w0.091: v1(86.02,46.87) 86.02,46.58 85.91,46.47 85.68,46.47 85.53,46.62 85.53,47.91 87.46,49.84 87.46,51.26 104.82,68.63 104.95,68.63 105.12,68.46 105.39,68.46 105.72,68.78 105.72,69.06 105.55,69.23 105.55,69.35 105.77,69.58 105.9,69.58 106.07,69.41 106.34,69.41 106.67,69.73 106.67,70.01 106.5,70.17 106.5,70.3 106.85,70.65 107.65,70.65 112.89,75.9 112.89,76.7 123.1,86.9 126.66,86.9 126.78,86.79 126.78,86.58 126.59,86.39 v1(126.45,86.39)
  BOTTOM w0.076: UC1.AM70 134.58,86.74 134.67,86.83 134.67,86.94 134.53,87.01 134.31,87.01 134.23,86.97 133.95,86.97 133.82,87.03 133.71,87.03 133.58,86.97 133.22,86.97 133.14,87.05 132.18,87.05 131.62,86.5 131.32,86.5 130.62,85.8 126.99,85.8 126.76,86.04 126.76,86.27 126.63,86.39 v1(126.45,86.39)
  BOTTOM w0.102: v1(86.02,46.87) 86.02,46.58 86.1,46.49 86.4,46.49 86.48,46.57 86.48,47.8 86.18,48.1 86.18,48.63 85.88,48.94 JDIMM1.11
DDR_A_DQS#1: length 75.9
  IN1 w0.091: v1(91.35,45.27) 91.35,45.19 91.24,45.07 91.17,45 90.99,45 90.88,45.11 90.88,46.33 91.47,46.91 91.47,48.59 93.42,50.55 93.42,50.98 93.81,51.36 93.81,51.63 93.54,51.89 93.54,52.02 93.77,52.25 93.9,52.25 94.16,51.98 94.43,51.98 94.75,52.31 94.75,52.58 94.49,52.84 94.49,52.97 94.72,53.19 94.84,53.19 95.11,52.93 95.38,52.93 95.75,53.31 95.75,53.58 95.5,53.84 95.5,53.97 95.72,54.19 95.85,54.19 96.11,53.93 96.38,53.93 96.75,54.31 96.75,54.58 96.49,54.84 96.49,54.97 96.71,55.19 96.84,55.19 97.11,54.93 97.38,54.93 97.75,55.31 97.75,55.58 97.47,55.86 97.47,55.99 97.7,56.21 97.83,56.21 98.11,55.93 98.38,55.93 98.7,56.26 98.7,56.53 98.42,56.81 98.42,56.94 98.64,57.16 98.77,57.16 99.05,56.88 99.33,56.88 102.31,59.87 102.87,59.87 116.26,73.25 118.22,73.25 120.13,75.15 126.1,75.15 129.58,78.63 129.58,81.46 v1(129.8,81.68)
  BOTTOM w0.076: UC1.AT69 134.89,84.39 134.84,84.33 134.84,84.13 134.75,84.05 134.56,83.96 134.27,83.96 134.19,83.99 133.99,83.99 133.88,83.94 133.66,83.94 133.54,83.99 133.16,83.99 132.99,83.83 132.06,83.83 131.04,82.81 130.09,82.81 129.54,82.26 129.54,81.86 129.72,81.68 v1(129.8,81.68)
  BOTTOM w0.102: v1(91.35,45.27) 91.35,45.21 91.11,44.97 90.92,44.97 90.73,44.78 90.73,43.43 91.31,42.86 91.31,42.71 91.13,42.52 JDIMM1.32
DDR_A_DQS#2: length 58.2
  IN4 w0.076: 130.59,81.34 130.69,81.34 130.86,81.5 130.86,82.21 132.27,83.62 133.31,83.62 134.02,84.33 134.02,86.1 136.09,88.17 136.94,88.17 137.02,88.25 v1(137.02,88.38)
  IN4 w0.091: 130.59,81.34 130.2,81.34 127.99,79.13 127.99,58.83 129.25,57.57 129.25,56.74 133.8,52.19 133.8,50.74 134.81,49.72 134.81,49.19 135.04,48.96 135.28,48.96 135.4,48.83 135.4,48.57 135.28,48.44 135.04,48.44 134.81,48.21 134.81,45.19 135.01,44.99 135.43,44.99 135.54,44.88 v1(135.54,44.59)
  BOTTOM w0.076: UC1.AH66 v1(137.02,88.38)
  BOTTOM w0.102: JDIMM1.198 134.63,42.49 134.78,42.64 134.78,42.89 135,43.11 135.49,43.11 136.01,43.64 136.01,44.78 135.93,44.87 135.82,44.87 v1(135.54,44.59)
DDR_A_DQS#3: length 69
  IN4 w0.076: v1(129.7,88.87) 129.92,88.65 129.92,88.09 129.66,87.83 123.45,87.83 122.45,86.83 122.44,86.83 122.42,86.82
  IN4 w0.091: v1(130.46,46.11) 130.27,46.31 130,46.31 129.73,46.57 129.73,48.02 129.94,48.23 130.22,48.23 130.32,48.33 130.32,48.68 130.22,48.78 129.12,48.78 128.92,48.98 128.92,49.45 129.12,49.65 129.54,49.65 129.64,49.75 129.64,50.01 129.54,50.12 128.16,50.12 127.92,50.36 127.92,51.69 124.3,55.31 124.3,75.57 119.51,80.36 119.51,83.9 122.42,86.82
  BOTTOM w0.076: UC1.AG69 134.95,89.3 134.89,89.23 134.89,89.19 134.8,89.1 134.75,89.05 134.56,88.96 134.27,88.96 134.19,89 133.99,89 133.85,88.94 133.68,88.94 133.54,89 131.96,89 131.16,88.2 130.18,88.2 129.91,88.46 129.91,88.66 v1(129.7,88.87)
  BOTTOM w0.102: v1(130.46,46.11) 130.46,46.11 130.29,46.28 130.09,46.28 129.81,46.56 129.81,48.4 129.52,48.7 129.52,48.91 129.37,49.05 JDIMM1.177
DDR_A_DQS#4: length 66.7
  IN1 w0.091: v1(132,74.57) 132,74.71 131.9,74.81 131.66,74.81 131.17,74.32 131.17,73.11 128.62,70.56 120.41,70.56 119.65,69.8 117.71,69.8 104.1,56.19 103.52,56.19 99.37,52.05 99.37,50.99 96.54,48.15 96.54,46.68 96.72,46.5 96.8,46.5 97,46.7 v1(97,46.87)
  BOTTOM w0.076: 135.32,78.45 136.63,78.45 137.47,79.29 137.47,80.2 137.63,80.36 137.63,80.73 137.58,80.84 137.58,80.85 137.58,80.96 137.63,81.09 137.63,81.37 137.6,81.45 137.6,81.67 137.66,81.8 137.67,81.81 137.82,81.81 137.86,81.77 UC1.BA64
  BOTTOM w0.102: v1(97,46.87) 97,46.66 97.17,46.49 97.24,46.49 97.45,46.71 97.45,47.74 96.68,48.51 96.68,48.65 96.37,48.96 JDIMM1.53 ; v1(132,74.57) 132,74.68 132.13,74.82 132.17,74.86 132.59,74.86 132.93,75.21 132.93,77.7 133.69,78.45 135.32,78.45
DDR_A_DQS#5: length 65.7
  IN1 w0.076: v1(137.91,76.13) 137.91,76.25 137.74,76.42 137.39,76.42 136.56,75.6 136.56,73.37 133.91,70.72 133.91,70.71 133.78,70.58
  IN1 w0.091: 133.78,70.58 129.55,66.35 119.29,66.35 104.51,51.58 104.51,50.82 101.52,47.83 101.52,45.08 101.69,44.91 101.92,44.91 102.08,45.07 v1(102.08,45.27)
  BOTTOM w0.076: UC1.AY60 140.32,82.14 140.56,81.89 140.65,81.7 140.65,81.42 140.61,81.33 140.61,81.13 140.63,81.08 140.65,81.03 140.67,80.95 140.67,80.81 140.61,80.69 140.61,80.43 140.77,80.27 140.77,79.82 140.46,79.51 140.46,79.1 138.57,77.22 138.57,76.45 138.36,76.24 138.02,76.24 v1(137.91,76.13)
  BOTTOM w0.102: JDIMM1.74 101.62,42.65 101.78,42.8 101.78,42.92 101.43,43.27 101.43,44.8 101.62,44.99 101.8,44.99 v1(102.08,45.27)
DDR_A_DQS#6: length 51.5
  IN4 w0.076: v1(137.12,84.64) 137.12,84.81 137.04,84.9 136.85,84.9 136.75,84.79 136.75,82.53 135.79,81.57 135,81.57 134.68,81.25 134.68,81.05
  IN4 w0.091: v1(140.62,46.87) 140.62,46.59 140.51,46.48 140.23,46.48 140.1,46.6 140.1,48.21 139.56,48.75 139.56,52.5 136.25,55.81 136.25,57.23 131.62,61.86 131.62,78.08 132.64,79.1 133.15,79.1 134.68,80.63 134.68,81.05
  BOTTOM w0.076: v1(137.12,84.64) 136.76,85 UC1.AR66
  BOTTOM w0.102: v1(140.62,46.87) 140.62,46.62 140.75,46.49 140.92,46.49 141.07,46.64 141.07,48.04 140.82,48.29 140.46,48.29 140.18,48.57 140.18,48.66 139.88,48.97 JDIMM1.219
DDR_A_DQS#7: length 52.2
  IN4 w0.076: 139.72,82.45 139.72,82.9 139.49,83.13 139.49,84.8 139.55,84.86 139.64,84.86 v1(139.86,84.64)
  IN4 w0.091: v1(146.04,45.35) 146.04,45.09 145.92,44.97 145.73,44.97 145.48,45.22 145.48,48.26 144.57,49.17 144.57,50.39 144.42,50.54 144.42,54.01 135.53,62.9 135.53,77.34 135.84,77.64 136.52,77.64 138.53,79.66 138.53,80.84 139.72,82.04 139.72,82.45
  BOTTOM w0.076: UC1.AR61 139.5,85 v1(139.86,84.64)
  BOTTOM w0.102: JDIMM1.240 145.12,42.51 145.28,42.67 145.28,42.87 145.31,42.9 145.31,44.76 145.61,45.06 145.75,45.06 v1(146.04,45.35)
DDR_A_MA0: length 61.9
  IN1 w0.076: 146.01,69.3 146.01,70.81 146.8,71.6 146.8,78.63 v1(146.21,79.22)
  IN1 w0.132: v1(120.01,45.73) 119.61,46.13 119.61,49.04 121.27,50.71 121.27,51.93 123.62,54.28 134.93,54.28 140.56,59.91 140.75,59.91 141.14,59.51 141.37,59.51 141.53,59.67 141.53,59.89 141.13,60.29 141.13,60.48 141.32,60.67 141.51,60.67 141.91,60.28 142.13,60.28 142.29,60.43 142.29,60.66 141.89,61.05 141.89,61.24 146.01,65.35 146.01,69.3
  BOTTOM w0.076: UC1.AY50 145.95,81.88 146.11,81.72 146.11,81.39 146.33,81.17 146.33,79.33 v1(146.21,79.22)
  BOTTOM w0.17: JDIMM1.144 119.12,44.85 v1(120.01,45.73)
DDR_A_MA1: length 62.2
  IN1 w0.076: 143.51,69.3 143.51,70.22 144.57,71.28 144.57,75.6 144.3,75.87 v1(143.88,75.87)
  IN1 w0.132: v1(116.73,47.26) 116.3,47.69 116.3,48.46 116.36,48.53 116.55,48.53 116.69,48.66 116.69,48.93 116.55,49.06 116.39,49.06 116.3,49.15 116.3,49.45 117.9,51.05 117.9,51.24 117.68,51.46 117.68,51.67 117.84,51.83 118.06,51.83 118.27,51.61 118.46,51.61 118.54,51.69 118.54,52.72 122.59,56.77 133.9,56.77 141.25,64.13 141.25,64.31 140.9,64.66 140.9,64.88 141.06,65.03 141.28,65.03 141.62,64.69 141.81,64.69 142,64.87 142,65.06 141.65,65.41 141.65,65.63 141.8,65.78 142.02,65.78 142.37,65.43 142.56,65.43 142.74,65.62 142.74,65.81 142.4,66.15 142.4,66.37 142.55,66.53 142.77,66.53 143.12,66.18 143.31,66.18 143.51,66.39 143.51,66.63 143.18,66.97 143.18,67.15 143.51,67.49 143.51,69.3
  BOTTOM w0.076: v1(143.88,75.87) 144.09,75.66 144.5,75.66 144.96,76.12 144.96,77.69 145.31,78.04 145.31,79.08 145.93,79.71 145.93,80.49 UC1.BB50
  BOTTOM w0.17: v1(116.73,47.26) 116.48,47.26 116.31,47.42 116.31,48.31 116.37,48.37 JDIMM1.133
DDR_A_MA2: length 65.7
  IN1 w0.076: 143.92,69.3 143.92,70.33 144.79,71.2 144.79,77.23 v1(144.36,77.65)
  IN1 w0.132: v1(116.73,44.97) 116.29,44.53 116.29,42.99 116.55,42.72 116.85,42.72 117.12,42.99 117.12,49.69 118.96,51.53 118.96,52.56 119.31,52.91 122.76,56.36 134.07,56.36 143.92,66.22 143.92,69.3
  BOTTOM w0.076: v1(144.36,77.65) 144.22,77.8 144.22,78.05 144.91,78.74 144.91,79.16 145.58,79.83 145.58,80.18 145.4,80.36 145.4,80.72 145.45,80.84 145.45,80.95 145.39,81.17 145.39,81.32 145.44,81.47 145.44,81.6 arc(145.42,81.71) 145.36,81.8 145.26,81.9 145.06,81.9 144.9,82.05 144.9,82.19 145,82.29 145.14,82.29 145.21,82.21 UC1.AY51
  BOTTOM w0.17: v1(116.73,44.97) 116.12,44.37 JDIMM1.132
DDR_A_MA3: length 63.5
  IN1 w0.076: v1(143.88,74.57) 144.22,74.57 144.37,74.42 144.37,71.36 143.1,70.1 143.1,69.3
  IN1 w0.132: 143.1,69.3 143.1,67.66 140.45,65.01 140.45,63.91 133.73,57.18 122.42,57.18 120.1,54.87 117.27,52.04 117.27,51 115.88,49.62 115.88,47.48 116.33,47.03 116.33,45.16 116.08,44.9 115.69,44.9 115.41,45.19 115.41,45.63 115.31,45.73 v1(115.08,45.73)
  BOTTOM w0.076: UC1.BA50 146.14,80.93 146.14,79.68 145.55,79.09 145.55,78.05 145.13,77.64 145.13,74.79 144.92,74.57 v1(143.88,74.57)
  BOTTOM w0.17: JDIMM1.131 115.88,48.51 115.86,48.5 115.86,45.97 115.62,45.73 v1(115.08,45.73)
DDR_A_MA4: length 63.5
  IN1 w0.076: 142.28,69.3 142.28,69.89 143.39,71 143.39,72.61 143.35,72.65 143.35,75.74 143.22,75.87 v1(142.66,75.87)
  IN1 w0.132: v1(115.08,44.21) 115.37,44.21 115.59,43.99 115.59,43.04 115.34,42.78 114.84,42.78 114.68,42.95 114.68,49.58 116.07,50.97 116.07,52 116.22,52.15 122.08,58.01 133.39,58.01 137.11,61.73 137.11,62.91 142.28,68.09 142.28,69.3
  BOTTOM w0.076: v1(142.66,75.87) 143.02,75.87 143.11,75.97 143.11,77.68 144.41,78.98 144.41,80.49 UC1.BB52
  BOTTOM w0.17: JDIMM1.128 115.12,42.62 115.53,43.02 115.53,44 115.32,44.21 v1(115.08,44.21)
DDR_A_MA5: length 65.8
  IN1 w0.076: v1(142.69,71.38) 142.69,71.31 141.04,69.67 141.04,69.3
  IN1 w0.132: 141.04,69.3 141.04,68.6 131.69,59.24 121.48,59.24 114.42,52.18 114.42,51.12 113.05,49.75 113.05,43.09 113.43,42.71 114.03,42.71 114.27,42.94 114.27,43.79 113.85,44.21 v1(113.44,44.21)
  BOTTOM w0.076: UC1.BA51 144.95,81.34 144.95,81.11 144.94,81.1 144.94,81.1 144.94,81.09 144.91,81.01 144.91,80.81 144.94,80.72 144.94,80.36 144.74,80.16 144.74,78.84 143.52,77.62 143.52,71.81 143.08,71.38 v1(142.69,71.38)
  BOTTOM w0.17: JDIMM1.126 114.62,42.88 114.45,43.05 114.18,43.05 113.98,43.25 113.98,43.53 114.18,43.73 114.39,43.73 114.56,43.9 114.56,44.15 114.39,44.32 113.55,44.32 v1(113.44,44.21)
DDR_A_MA6: length 62.2
  IN1 w0.076: 142.69,69.3 142.69,70.04 144.2,71.56 144.2,72.43 143.52,73.12 143.52,76.3 143.29,76.52 v1(142.66,76.52)
  IN1 w0.132: v1(115.08,47.26) 115.23,47.1 115.39,47.1 115.47,47.18 115.47,48.62 115.4,48.69 115.25,48.69 115.09,48.84 115.09,49.06 115.25,49.22 115.4,49.22 115.47,49.29 115.47,49.79 116.48,50.79 116.48,51.65 116.74,51.91 116.74,52.09 117.05,52.4 122.25,57.6 133.56,57.6 137.92,61.96 137.92,62.15 137.52,62.55 137.52,62.74 137.7,62.93 137.89,62.93 138.29,62.52 138.48,62.52 138.67,62.71 138.67,62.9 138.26,63.3 138.26,63.49 138.45,63.67 138.64,63.67 139.04,63.27 139.23,63.27 139.41,63.45 139.41,63.67 139.02,64.06 139.02,64.25 139.21,64.44 139.4,64.44 139.66,64.17 139.88,64.17 140.04,64.33 140.04,64.54 139.77,64.81 139.77,65 142.69,67.92 142.69,69.3
  BOTTOM w0.076: v1(142.66,76.52) 142.66,77.47 144.24,79.05 144.24,80.75 144.51,81.01 UC1.BA52
  BOTTOM w0.17: JDIMM1.127 114.88,48.44 114.66,48.23 114.66,47.67 v1(115.08,47.26)
DDR_A_MA7: length 66.1
  IN1 w0.076: v1(142.66,74.57) 143.04,74.57 143.18,74.43 143.18,72.44 143.22,72.4 143.22,71.06 141.87,69.71 141.87,69.3
  IN1 w0.132: 141.87,69.3 141.87,68.26 136.69,63.08 136.69,61.9 136.52,61.72 136.33,61.72 135.93,62.12 135.75,62.12 135.56,61.94 135.56,61.75 135.96,61.35 135.96,61.16 133.22,58.42 121.91,58.42 115.93,52.44 115.93,52.44 115.66,52.17 115.66,51.14 114.27,49.75 114.27,46.92 114.18,46.83 113.99,46.83 113.84,46.67 113.84,46.45 113.99,46.3 114.2,46.3 114.27,46.23 114.27,45.12 114.15,44.99 113.97,44.99 113.85,45.12 113.85,45.6 113.72,45.73 v1(113.44,45.73)
  BOTTOM w0.076: v1(142.66,74.57) 142.42,74.57 142.3,74.69 142.3,77.33 144.08,79.12 144.08,81.26 144.29,81.47 144.29,81.98 144.61,82.3 UC1.AW52
  BOTTOM w0.17: JDIMM1.122 113.62,42.67 113.02,43.27 113.02,44.02 112.85,44.19 112.75,44.19 112.57,44.36 112.57,44.69 112.75,44.87 112.85,44.87 113.02,45.04 113.02,45.31 v1(113.44,45.73)
DDR_A_MA8: length 64.2
  IN1 w0.076: v1(142.66,71.97) 143.06,71.58 143.06,71.13 141.46,69.53 141.46,69.3
  IN1 w0.132: v1(113.44,47.26) 113.68,47.26 113.84,47.42 113.84,48.6 113.78,48.66 113.61,48.66 113.46,48.82 113.46,49.04 113.61,49.19 113.78,49.19 113.84,49.25 113.84,49.96 114.83,50.95 114.83,51.61 115.06,51.84 115.06,52.15 115.28,52.38 115.28,52.38 115.64,52.73 121.73,58.83 132.86,58.83 133.02,58.99 133.02,59.2 132.72,59.5 132.72,59.69 132.9,59.88 133.09,59.88 133.48,59.49 133.7,59.49 133.85,59.64 133.85,59.86 133.46,60.25 133.46,60.44 133.65,60.62 133.84,60.62 134.23,60.23 134.45,60.23 134.6,60.39 134.6,60.61 134.21,61 134.21,61.18 134.4,61.37 134.59,61.37 134.98,60.98 135.19,60.98 135.35,61.14 135.35,61.35 134.96,61.74 134.96,61.93 141.46,68.43 141.46,69.3
  BOTTOM w0.076: UC1.AY52 144.79,81.88 144.84,81.83 144.84,81.66 144.71,81.53 144.71,81.46 144.75,81.42 144.78,81.33 144.78,81.13 144.74,81.04 144.74,80.78 144.78,80.69 144.78,80.43 144.58,80.23 144.58,78.91 143.31,77.65 143.31,72.07 143.22,71.97 v1(142.66,71.97)
  BOTTOM w0.17: JDIMM1.125 114.37,48.84 114.21,48.68 114.21,48.34 113.95,48.08 113.95,47.66 114.21,47.4 114.21,47.06 114.01,46.86 113.65,46.86 113.44,47.06 v1(113.44,47.26)
DDR_A_MA9: length 62.7
  IN1 w0.076: v1(142.66,72.55) 142.27,72.55 142.11,72.39 142.11,71.05 140.63,69.57 140.63,69.3
  IN1 w0.132: v1(111.82,45.73) 112.09,45.73 112.21,45.6 112.21,44.96 112.34,44.83 112.51,44.83 112.64,44.95 112.64,49.92 113.6,50.89 113.6,51.16 113.48,51.29 113.48,51.65 113.66,51.83 113.85,51.83 114.01,51.98 114.01,52.35 114.5,52.84 118.69,57.03 121.31,59.65 131.52,59.65 140.63,68.77 140.63,69.3
  BOTTOM w0.076: v1(142.66,72.55) 141.91,72.55 141.8,72.66 141.8,77.54 143.58,79.32 143.58,80.48 UC1.BB54
  BOTTOM w0.17: JDIMM1.121 113.37,48.67 112.99,48.29 112.99,47.45 112.82,47.28 112.47,47.28 112.28,47.08 112.28,46.19 v1(111.82,45.73)
DDR_A_MA10: length 63.9
  IN1 w0.076: v1(145.35,84) 144.94,83.59 144.94,83.18 145.16,82.97 145.16,81.36 147.2,79.32 147.2,71.45 146.83,71.07 146.83,69.3
  IN1 w0.132: 146.83,69.3 146.83,64.7 145.58,63.44 145.58,63.25 145.81,63.02 145.81,62.79 145.65,62.64 145.43,62.64 145.19,62.87 145.01,62.87 144.81,62.68 144.81,62.49 145.05,62.25 145.05,62.03 141.71,58.69 140.51,58.69 135.27,53.46 124.3,53.46 122.57,51.72 122.57,50.84 120.81,49.08 120.81,45.02 v1(121.62,44.21)
  BOTTOM w0.076: UC1.AT50 v1(145.35,84)
  BOTTOM w0.17: v1(121.62,44.21) 121.16,43.74 121.16,43.02 121.63,42.55 JDIMM1.146
DDR_A_MA11: length 65.2
  IN1 w0.076: v1(142.65,73.32) 142.08,73.32 141.65,72.89 141.65,71.33 139.8,69.47 139.8,69.3
  IN1 w0.132: v1(111.82,44.21) 112.25,43.77 112.25,42.87 112.05,42.67 111.58,42.67 111.38,42.87 111.38,48.46 110.86,48.98 110.86,49.64 111.94,50.71 111.94,51.62 120.79,60.48 131.18,60.48 139.8,69.1 139.8,69.3
  BOTTOM w0.076: v1(142.65,73.32) 142.17,73.32 141.97,73.53 141.97,77.47 143.75,79.25 143.75,80.76 143.48,81.02 UC1.BA54
  BOTTOM w0.17: JDIMM1.120 113.12,42.52 112.45,43.19 112.45,43.57 v1(111.82,44.21)
DDR_A_MA12: length 64.6
  IN1 w0.076: 140.22,69.3 140.22,69.51 141.87,71.15 141.87,72.84 141.95,72.92 142.82,72.92 143.02,73.12 143.02,73.92 142.88,74.06 142.8,74.06 v1(142.66,73.92)
  IN1 w0.132: 140.22,69.3 140.22,68.94 131.35,60.07 121.14,60.07 113.07,51.99 113.07,51.85 112.94,51.72 112.65,51.72 112.52,51.6 112.52,51.38 112.65,51.25 112.94,51.25 113.07,51.13 113.07,50.95 112.94,50.82 112.47,50.82 112.35,50.69 112.35,50.22 112.22,50.09 112.22,49.68 112.1,49.55 111.4,49.55 111.27,49.42 111.27,49.15 111.59,48.83 111.74,48.83 111.95,49.04 112.1,49.04 112.22,48.92 112.22,47.13 112.16,47.06 112.01,47.06 v1(111.82,47.26)
  BOTTOM w0.076: v1(142.66,73.92) 142.66,73.81 142.52,73.67 142.25,73.67 142.13,73.79 142.13,77.4 143.91,79.19 143.91,81.24 143.69,81.46 143.69,82.12 143.63,82.18 143.11,82.18 143,82.29 143,82.34 142.85,82.49 142.85,82.58 142.9,82.63 143.34,82.63 143.38,82.59 UC1.AW54
  BOTTOM w0.17: v1(111.82,47.26) 112.23,47.67 112.23,47.86 112.54,48.18 112.54,48.73 112.88,49.06 JDIMM1.119
DDR_A_MA13: length 67.4
  IN1 w0.076: 150.17,69.3 150.17,71.17 149.77,71.57 149.77,77.08 149.59,77.27 149.59,80.72 148.42,81.89 148.42,83.99 148.32,84.1 v1(148.09,84.1)
  IN1 w0.132: 150.17,69.3 150.17,60.44 148.45,58.73 148.26,58.73 147.95,59.04 147.76,59.04 147.58,58.85 147.58,58.66 147.89,58.35 147.89,58.16 147.7,57.98 147.52,57.98 147.2,58.29 147,58.29 146.75,58.05 146.75,57.86 147.06,57.55 147.06,57.33 146.9,57.18 146.68,57.18 146.38,57.49 146.19,57.49 141.55,52.85 140.59,52.85 139.24,51.5 139.24,50.53 138.18,49.48 125.93,49.48 124.68,48.23 124.68,46.18 v1(125.13,45.73)
  BOTTOM w0.076: v1(148.09,84.1) 147.7,83.7 UC1.AU46
  BOTTOM w0.17: JDIMM1.158 124.63,42.61 124.95,42.93 125.34,42.93 125.58,43.17 125.58,44.04 125.75,44.21 126.08,44.21 126.25,44.38 126.25,44.62 126.08,44.79 125.75,44.79 125.58,44.96 125.58,45.28 v1(125.13,45.73)
DDR_A_MA14: length 64.3
  IN1 w0.076: v1(147.18,84.64) 146.71,84.17 146.71,83.19 147.4,82.51 147.4,81.61 148.72,80.28 148.72,77.02 149,76.75 149,71.59 148.48,71.07 148.48,69.3
  IN1 w0.132: v1(123.24,47.26) 122.84,47.65 122.84,48.78 125.33,51.27 125.33,51.41 125.71,51.78 135.93,51.78 137.57,53.43 138.77,53.43 140.09,54.74 140.27,54.74 140.47,54.54 140.69,54.54 140.85,54.69 140.85,54.91 140.65,55.11 140.65,55.3 140.83,55.49 141.02,55.49 141.3,55.2 141.52,55.2 141.71,55.4 141.71,55.59 141.48,55.82 141.48,56.04 141.63,56.19 141.85,56.19 142.09,55.96 142.27,55.96 144.35,58.04 144.35,58.23 144.07,58.51 144.07,58.72 144.23,58.88 144.41,58.88 144.69,58.6 144.91,58.6 145.07,58.75 145.07,58.97 144.79,59.25 144.79,59.44 144.97,59.63 145.16,59.63 145.44,59.35 145.66,59.35 145.81,59.5 145.81,59.72 145.53,60 145.53,60.19 148.48,63.13 148.48,69.3
  BOTTOM w0.076: UC1.AT46 v1(147.18,84.64)
  BOTTOM w0.17: JDIMM1.151 122.88,48.43 122.82,48.38 122.82,47.67 v1(123.24,47.26)
DDR_A_MA15: length 65.4
  IN1 w0.076: v1(147.18,84) 148.19,82.99 148.19,81.57 149.25,80.51 149.25,77.14 149.44,76.95 149.44,71.08 149.76,70.77 149.76,69.3
  IN1 w0.132: 149.76,69.3 149.76,61.63 149.12,61 149.12,60.81 149.43,60.5 149.43,60.29 149.27,60.13 149.06,60.13 148.75,60.44 148.56,60.44 148.37,60.25 148.37,60.06 148.68,59.76 148.68,59.54 148.53,59.38 148.31,59.38 148,59.69 147.81,59.69 146.79,58.67 146.79,58.67 141.38,53.26 140.42,53.26 138.89,51.73 138.48,51.73 138.05,51.3 138.05,50.11 137.84,49.89 125.76,49.89 124.27,48.4 124.27,45.07 v1(125.13,44.21)
  BOTTOM w0.076: UC1.AU48 v1(147.18,84)
  BOTTOM w0.17: JDIMM1.156 124.12,43.2 v1(125.13,44.21)
DDR_A_MA16: length 63.2
  IN1 w0.076: 148.06,69.3 148.06,76.65 147.87,76.84 147.87,78.8 148.06,78.99 148.06,80.23 146.96,81.34 146.96,82.66 v1(146.26,83.35)
  IN1 w0.132: v1(123.24,44.21) 122.43,45.02 122.43,48.95 124.48,51 124.48,51.55 125.15,52.22 135.79,52.22 137.4,53.84 138.6,53.84 141.37,56.61 142.34,56.61 142.96,57.23 142.96,57.42 142.67,57.71 142.67,57.88 142.87,58.08 143.04,58.08 143.33,57.79 143.52,57.79 143.71,57.98 143.71,58.16 143.42,58.46 143.42,58.65 148.06,63.3 148.06,69.3
  BOTTOM w0.076: UC1.AU50 145.91,83.7 v1(146.26,83.35)
  BOTTOM w0.17: JDIMM1.152 123.12,42.86 122.82,43.17 122.82,43.79 v1(123.24,44.21)
DDR_A_ODT0: length 67.4
  IN1 w0.076: 150.81,69.3 150.81,69.67 150.55,69.94 150.55,78.16 150.39,78.32 150.39,81.43 148.59,83.23 148.59,83.52 v1(149.01,83.94)
  IN1 w0.132: v1(125.13,47.26) 125.53,47.65 125.53,48.03 126.33,48.84 138.45,48.84 139.88,50.27 139.88,51.24 140.85,52.21 141.82,52.21 142.97,53.36 143.16,53.36 143.45,53.07 143.66,53.07 143.82,53.22 143.82,53.44 143.53,53.73 143.53,53.92 143.71,54.1 143.93,54.1 144.24,53.79 144.42,53.79 144.61,53.98 144.61,54.17 144.3,54.48 144.3,54.66 144.49,54.85 144.68,54.85 144.98,54.54 145.17,54.54 145.36,54.73 145.36,54.91 145.05,55.22 145.05,55.41 145.24,55.6 145.42,55.6 145.73,55.29 145.92,55.29 146.11,55.48 146.11,55.66 145.8,55.97 145.8,56.16 145.98,56.34 146.17,56.34 146.48,56.04 146.67,56.04 147.01,56.38 147.2,56.38 147.54,56.05 147.73,56.05 147.91,56.23 147.91,56.42 147.58,56.76 147.58,56.95 147.76,57.13 147.95,57.13 148.29,56.79 148.48,56.79 148.66,56.98 148.66,57.17 148.32,57.51 148.32,57.69 150.81,60.18 150.81,69.3
  BOTTOM w0.076: v1(149.01,83.94) 148.6,84.35 UC1.AT45
  BOTTOM w0.17: JDIMM1.155 123.88,48.51 v1(125.13,47.26)
DDR_A_ODT1: length 67.9
  IN1 w0.076: 151.63,69.3 151.63,69.65 151.04,70.24 151.04,78.56 150.83,78.78 150.83,81.46 149.39,82.89 149.39,84.14 v1(149.01,84.51)
  IN1 w0.132: v1(126.65,47.26) 127.7,46.21 127.7,43.13 128.44,42.38 136.31,42.38 138.36,44.44 138.36,47.59 143.02,52.24 144.04,52.24 147.02,55.22 148.07,55.22 149.49,56.64 149.49,57.69 151.63,59.84 151.63,69.3
  BOTTOM w0.076: v1(149.01,84.51) 149.17,84.35 UC1.AT43
  BOTTOM w0.17: JDIMM1.161 125.37,49 126.1,48.27 126.1,47.81 v1(126.65,47.26)
DDR_A_PARITY: length 62.5
  IN1 w0.076: 146.42,69.3 146.42,70.92 147.01,71.51 147.01,79.19 144.93,81.27 144.93,82.83 144.44,83.32 v1(144.44,84)
  IN1 w0.132: 146.42,69.3 146.42,64.87 144.21,62.65 144.21,62.47 144.46,62.22 144.46,62.03 144.26,61.84 144.08,61.84 143.83,62.09 143.64,62.09 143.44,61.89 143.44,61.71 143.69,61.46 143.69,61.27 143.5,61.08 143.31,61.08 143.06,61.33 142.89,61.33 142.68,61.12 142.68,60.94 142.93,60.69 142.93,60.5 141.54,59.1 140.34,59.1 135.1,53.87 123.79,53.87 121.68,51.76 121.68,50.54 120.4,49.25 120.4,47.65 v1(120.01,47.26)
  BOTTOM w0.076: UC1.AT52 v1(144.44,84)
  BOTTOM w0.17: v1(120.01,47.26) 119.25,47.26 118.88,47.63 JDIMM1.143
DDR_B_ACT#: length 94.8
  IN4 w0.076: 139.42,76.83 139.42,77.74 140.93,79.24 140.93,80.32 142.33,81.72 142.33,82.6 141.9,83.03 141.9,85.82 142.33,86.24 142.91,86.24 143.24,85.91 v1(143.52,85.91)
  IN4 w0.132: v1(191.04,44.21) 190.75,44.21 190.62,44.07 190.62,42.97 190.04,42.38 187.41,42.38 187.28,42.26 187.28,41.36 187.16,41.23 186.95,41.23 186.83,41.36 186.83,42.18 186.7,42.31 186.48,42.31 186.36,42.18 186.36,41.36 186.23,41.23 163.18,41.23 159.17,45.24 157.52,45.24 139.19,63.57 139.19,71.38 139.42,71.61 139.42,76.83
  BOTTOM w0.076: UC1.AN53 v1(143.52,85.91)
  BOTTOM w0.17: JDIMM2.114 192.22,42.49 191.63,43.09 191.63,43.75 191.17,44.21 v1(191.04,44.21)
DDR_B_ALERT#: length 109
  IN4 w0.076: 138.37,76.83 138.37,77.15 140.6,79.38 140.6,80.46 141.13,80.99 141.13,83.02 141.36,83.24 141.36,86.3 142.32,87.26 143.76,87.26 143.99,87.03 149.13,87.03 149.43,86.74 149.43,86.09 149.61,85.91 v1(149.92,85.91)
  IN4 w0.132: 138.37,76.83 138.37,72.08 138.1,71.81 138.1,63.18 151.98,49.3 151.98,48.99 153,47.97 153.31,47.97 157.09,44.19 158.73,44.19 162.74,40.18 166.05,40.18 166.67,39.56 190.61,39.56 192.14,41.08 192.14,45.31 v1(192.56,45.73)
  BOTTOM w0.076: UC1.AN43 149.53,86.3 v1(149.92,85.91)
  BOTTOM w0.17: v1(192.56,45.73) 192.1,45.27 192.1,43.25 192.73,42.63 JDIMM2.116
DDR_B_BA0: length 96.6
  IN4 w0.076: 149.28,68.94 149.28,70.01 148.23,71.06 148.23,72.73 v1(148.6,73.1)
  IN4 w0.132: v1(201.91,45.73) 202.59,45.73 202.72,45.6 202.72,42.39 202.84,42.26 203.93,42.26 204.06,42.13 204.06,41.52 204.19,41.4 204.52,41.4 204.65,41.52 204.65,42.67 204.52,42.79 203.27,42.79 203.15,42.92 203.15,45.87 202.72,46.3 202.72,48.98 200.46,51.24 200.46,51.86 195.68,56.64 184.84,56.64 184.71,56.77 184.71,57.86 184.58,57.98 164.24,57.98 163.73,58.49 161.6,58.49 160.68,59.42 159.48,59.42 159.31,59.58 157.37,59.58 149.28,67.67 149.28,68.94
  BOTTOM w0.076: v1(148.6,73.1) 149.2,73.7 149.2,77.01 149.12,77.08 149.12,79.14 149.22,79.24 149.22,80.48 UC1.BB44
  BOTTOM w0.17: v1(201.91,45.73) 202.08,45.73 202.33,45.48 202.33,44.42 203.1,43.65 203.1,43.2 203.23,43.07 JDIMM2.150
DDR_B_BA1: length 95.9
  IN4 w0.076: v1(148.6,74.47) 148.05,73.92 148.05,70.93 148.86,70.11 148.86,68.94
  IN4 w0.132: 148.86,68.94 148.86,67.5 157.2,59.17 159.14,59.17 159.31,59.01 160.51,59.01 161.43,58.08 163.56,58.08 164.07,57.57 178.44,57.57 178.56,57.45 178.56,56.35 178.69,56.23 178.9,56.23 179.03,56.35 179.03,57.45 179.16,57.57 179.36,57.57 179.49,57.45 179.49,56.35 179.61,56.23 179.83,56.23 179.96,56.35 179.96,57.45 180.08,57.57 180.31,57.57 180.44,57.45 180.44,56.35 180.57,56.23 180.79,56.23 180.92,56.35 180.92,57.45 181.05,57.57 181.29,57.57 181.42,57.45 181.42,56.35 181.54,56.23 181.75,56.23 181.87,56.35 181.87,57.45 182,57.57 182.2,57.57 182.33,57.45 182.33,56.35 182.46,56.23 182.7,56.23 182.83,56.35 182.83,57.45 182.95,57.57 183.18,57.57 183.31,57.45 183.31,56.35 183.44,56.23 183.69,56.23 183.82,56.35 183.82,57.45 183.94,57.57 184.17,57.57 184.3,57.45 184.3,56.35 184.43,56.23 195.51,56.23 200.05,51.69 200.05,51.07 202.3,48.81 202.3,47.65 v1(201.91,47.26)
  BOTTOM w0.076: v1(148.6,74.47) 149.01,74.88 149.01,76.91 148.96,76.96 148.96,79.21 149.06,79.31 149.06,80.97 UC1.BA44
  BOTTOM w0.17: v1(201.91,47.26) 201.44,47.72 201.44,48.37 201.97,48.9 JDIMM2.145
DDR_B_BG0: length 98.2
  IN4 w0.076: 139.01,76.83 139.01,77.56 140.76,79.31 140.76,80.39 141.89,81.52 141.89,82.8 141.62,83.08 141.62,85.76 142.26,86.41 143.01,86.41 143.14,86.28 144.11,86.28 v1(144.45,85.95)
  IN4 w0.132: v1(191.04,47.26) 191.46,46.83 191.46,43.12 189.16,40.82 163.01,40.82 159,44.83 157.35,44.83 138.78,63.4 138.78,71.55 139.01,71.78 139.01,76.83
  BOTTOM w0.076: v1(144.45,85.95) 144.74,85.65 UC1.AP52
  BOTTOM w0.17: JDIMM2.115 192.48,48.75 191.82,48.09 191.82,47.91 191.17,47.26 v1(191.04,47.26)
DDR_B_BG1: length 98.2
  IN4 w0.076: 141.82,76.83 141.82,77.92 143.6,79.7 143.6,81.31 144.82,82.52 144.82,86.21 v1(144.43,86.6)
  IN4 w0.132: 141.82,76.83 141.82,71.61 140.88,70.68 140.88,64.27 158.22,46.93 161.24,46.93 161.74,46.43 161.74,45.06 163.8,43 164.89,43 165.02,43.13 165.02,44.83 165.14,44.95 166.96,44.95 167.09,44.83 167.09,43.14 167.22,43.01 168.15,43.01 168.28,43.14 168.28,45.42 168.41,45.55 168.65,45.55 168.78,45.42 168.78,43.14 168.91,43.01 184.79,43.01 186.99,45.21 188.99,45.21 v1(189.51,45.73)
  BOTTOM w0.076: UC1.AN52 144.89,86.34 144.64,86.6 v1(144.43,86.6)
  BOTTOM w0.17: JDIMM2.113 191.97,48.88 191.65,48.55 190.99,48.55 190.55,48.12 190.55,46.38 189.9,45.73 v1(189.51,45.73)
DDR_B_CKE0: length 91.6
  IN4 w0.076: v1(142.59,85.86) 142.09,85.35 142.09,83.19 142.81,82.47 142.81,81.44 141.81,80.44 141.81,79.14 140.06,77.4 140.06,76.83
  IN4 w0.132: 140.06,76.83 140.06,71.34 139.83,71.12 139.83,63.84 157.79,45.88 159.43,45.88 163.43,41.88 185.15,41.88 186.29,43.02 189.71,43.02 189.98,43.29 189.98,46.79 v1(189.51,47.26)
  BOTTOM w0.076: v1(142.59,85.86) 142.59,85.86 142.15,86.3 UC1.AN56
  BOTTOM w0.17: JDIMM2.109 190.97,49.05 189.99,48.07 189.99,47.73 v1(189.51,47.26)
DDR_B_CKE1: length 90.9
  IN4 w0.076: 140.54,76.83 140.54,77.36 142.15,78.98 142.15,80.41 143.02,81.29 143.02,84.79 v1(142.61,85.21)
  IN4 w0.132: 140.54,76.83 140.54,76.25 141.18,75.6 141.18,71.88 140.24,70.95 140.24,64.01 157.96,46.29 160.98,46.29 161.1,46.17 161.1,44.79 163.53,42.36 165.53,42.36 165.66,42.49 165.66,44.19 165.78,44.31 166.28,44.31 166.41,44.19 166.41,42.49 166.53,42.36 185.05,42.36 187.26,44.57 189.15,44.57 v1(189.51,44.21)
  BOTTOM w0.076: UC1.AP55 143.06,85.59 v1(142.61,85.21)
  BOTTOM w0.17: v1(189.51,44.21) 189.9,44.21 190.55,43.56 190.55,43.16 191.22,42.49 JDIMM2.110
DDR_B_CKE2: length 1.2
  TOP w0.17: T5.1 143.17,87 v1(143.52,86.66)
  BOTTOM w0.076: v1(143.52,86.66) 143.16,86.3 UC1.AN55
DDR_B_CKE3: length 1.1
  TOP w0.17: v1(143.52,85.27) 143.34,85.45 T6.1
  BOTTOM w0.076: UC1.AP53 v1(143.52,85.27)
DDR_B_CLK0: length 94.9
  IN4 w0.076: 146.96,68.94 146.96,69.14 146.95,69.15 146.95,71.82 147.14,72.01 147.14,77.28 148.22,78.35 148.22,82.65 148.64,83.08 148.64,83.21 148.64,85.54 v1(149.01,85.91)
  IN4 w0.091: 146.96,68.94 146.96,66.72 156.36,57.32 156.98,57.32 157.21,57.09 157.21,56.46 157.33,56.33 157.62,56.33 157.75,56.46 157.75,57.09 157.98,57.32 158.37,57.32 158.6,57.09 158.6,55.78 158.73,55.66 159.02,55.66 159.15,55.78 159.15,56.92 159.37,57.15 159.74,57.15 159.97,56.92 159.97,55.83 160.12,55.67 160.46,55.67 160.59,55.79 160.59,56 160.82,56.23 161.28,56.23 161.5,56 161.5,55.79 161.63,55.67 161.88,55.67 162.01,55.79 162.01,56 162.24,56.23 162.72,56.23 162.95,56 162.95,55.79 163.08,55.67 170.55,55.67 171.85,54.37 194.63,54.37 197.56,51.45 197.56,50.94 199.73,48.76 199.73,46.63 199.51,46.41 199.29,46.41 199.16,46.28 v1(199.16,46.11)
  BOTTOM w0.076: UC1.AP45 148.81,85.91 v1(149.01,85.91)
  BOTTOM w0.102: JDIMM2.137 197.97,48.85 198.12,48.71 198.12,46.71 198.47,46.36 198.91,46.36 v1(199.16,46.11)
DDR_B_CLK1: length 93.7
  IN4 w0.076: v1(148.09,85.27) 147.92,85.44 147.7,85.44 147.56,85.3 147.56,85.05 147.73,84.88 147.73,82.61 146.81,81.7 146.81,78.26 146.64,78.09 146.64,72.34 146.25,71.95 146.25,69.12 146.26,69.11 146.26,68.94
  IN4 w0.091: v1(199.16,44.59) 199.16,44.39 199.07,44.29 198.75,44.29 198.56,44.1 198.56,42.76 198.43,42.63 198.18,42.63 198.05,42.76 198.05,45.05 198.13,45.12 198.44,45.12 198.66,45.35 198.66,48.88 196.54,51.01 196.54,51.5 194.34,53.7 171.57,53.7 170.29,54.99 157.73,54.99 146.26,66.46 146.26,68.94
  BOTTOM w0.076: UC1.AP46 v1(148.09,85.27)
  BOTTOM w0.102: v1(199.16,44.59) 198.89,44.32 198.59,44.32 198.37,44.09 198.37,42.79 198.23,42.65 JDIMM2.138
DDR_B_CLK#0: length 94.8
  IN4 w0.076: v1(148.09,85.91) 148.22,86.04 148.49,86.04 148.58,85.94 148.58,85.7 148.48,85.6 148.48,83.14 148.06,82.72 148.06,78.42 146.98,77.34 146.98,72.08 146.79,71.89 146.79,69.14 146.78,69.13 146.78,68.94
  IN4 w0.091: 146.78,68.94 146.78,66.65 156.28,57.15 156.91,57.15 157.03,57.02 157.03,56.39 157.26,56.16 157.69,56.16 157.92,56.39 157.92,57.02 158.05,57.15 158.3,57.15 158.43,57.02 158.43,55.71 158.66,55.48 159.09,55.48 159.32,55.71 159.32,56.85 159.45,56.98 159.67,56.98 159.79,56.85 159.79,55.75 160.05,55.49 160.53,55.49 160.76,55.72 160.76,55.93 160.89,56.05 161.2,56.05 161.33,55.93 161.33,55.72 161.56,55.49 161.96,55.49 162.18,55.72 162.18,55.93 162.31,56.05 162.65,56.05 162.78,55.93 162.78,55.72 163.01,55.49 170.48,55.49 171.78,54.2 194.56,54.2 197.39,51.38 197.39,50.86 199.56,48.69 199.56,46.7 199.44,46.58 199.28,46.58 199.16,46.7 v1(199.16,46.87)
  BOTTOM w0.076: UC1.AN45 148.16,85.91 v1(148.09,85.91)
  BOTTOM w0.102: JDIMM2.139 198.48,48.85 198.33,48.71 198.33,46.8 198.56,46.58 198.87,46.58 v1(199.16,46.87)
DDR_B_CLK#1: length 93.8
  IN4 w0.076: v1(147.18,85.91) 147.25,85.91 147.5,85.66 147.5,85.46 147.4,85.37 147.4,84.98 147.57,84.82 147.57,82.68 146.65,81.76 146.65,78.32 146.49,78.16 146.49,72.41 146.1,72.01 146.1,69.12 146.09,69.11 146.09,68.94
  IN4 w0.091: 146.09,68.94 146.09,66.39 157.66,54.81 170.21,54.81 171.5,53.53 194.27,53.53 196.36,51.43 196.36,50.94 198.49,48.81 198.49,45.42 198.36,45.3 198.05,45.3 197.88,45.12 197.88,42.69 198.11,42.46 198.51,42.46 198.73,42.69 198.73,44.03 198.82,44.12 199.05,44.12 199.16,44.01 v1(199.16,43.83)
  BOTTOM w0.076: UC1.AN46 v1(147.18,85.91)
  BOTTOM w0.102: JDIMM2.140 198.73,42.65 198.58,42.79 198.58,44 198.68,44.1 198.89,44.1 v1(199.16,43.83)
DDR_B_CS#0: length 92.3
  IN4 w0.076: v1(150.06,78.06) 149.6,77.6 149.6,76.07 149.88,75.8 150.75,75.8 151.14,75.41 151.14,70.7 151.99,69.85 151.99,68.94
  IN4 w0.132: 151.99,68.94 151.99,68.78 157.71,63.06 163,63.06 164.87,61.19 170.72,61.19 171.23,60.68 194.68,60.68 196.02,59.34 196.81,59.34 203.41,52.74 203.41,52.14 205.64,49.9 205.92,49.9 206.65,49.17 206.65,43.62 205.93,42.9 205.33,42.9 204.72,43.51 204.25,43.51 v1(203.55,44.21)
  BOTTOM w0.076: UC1.BB42 150.69,80.55 150.69,79.57 150.55,79.43 150.55,79.2 150.42,79.08 150.42,78.42 v1(150.06,78.06)
  BOTTOM w0.17: v1(203.55,44.21) 203.55,44.22 202.97,44.79 JDIMM2.149
DDR_B_CS#1: length 94.4
  IN4 w0.076: v1(149.76,83.28) 149.76,83.28 149.76,81.72 150.49,80.98 150.49,79.62 150.37,79.5 150.37,78.76 151.64,77.49 151.64,70.77 152.89,69.52 152.89,69.04 152.99,68.94
  IN4 w0.132: v1(207.08,45.73) 207.38,45.73 207.5,45.6 207.5,44.53 207.63,44.41 207.9,44.41 208.03,44.53 208.03,50.83 206.85,52.01 205.3,52.01 197.15,60.16 196.36,60.16 195.02,61.5 171.57,61.5 171.07,62.01 165.21,62.01 163.34,63.88 158.05,63.88 152.99,68.94
  BOTTOM w0.076: v1(149.76,83.28) 150.07,83.28 150.38,82.98 150.38,82.74 150.35,82.71 150.35,82.35 150.65,82.06 UC1.AY42
  BOTTOM w0.17: v1(207.08,45.73) 206.31,45.73 205.78,46.26 205.78,48.33 205.59,48.52 205.19,48.52 204.97,48.74 JDIMM2.157
DDR_B_D0: length 48.6
  IN1 w0.076: 153.15,69.3 153.15,69.8 152.2,70.75
  IN1 w0.084: v1(152.63,72.03) 152.2,71.59 152.2,70.75 ; 153.15,69.3 153.15,59.28 161.59,50.84 161.71,50.84 162.23,51.37 162.35,51.37 165.33,48.39 165.33,44.16 v1(164.62,43.45)
  BOTTOM w0.076: UC1.AY39 151.92,81.68 151.66,81.41 151.66,81.13 151.55,80.88 151.55,80.86 151.49,80.73 151.49,80.41 151.49,80.41 151.49,80.24 151.54,80.19 151.54,79.47 151.7,79.31 151.7,78.92 151.43,78.65 151.43,73.99 151.93,73.49 151.93,72.73 v1(152.63,72.03)
  BOTTOM w0.102: v1(164.62,43.45) 165.73,42.34 JDIMM2.8
DDR_B_D1: length 46.8
  IN1 w0.076: 152.25,69.3 152.25,69.62 152.04,69.82
  IN1 w0.084: v1(152.63,77.99) 151.3,76.66 151.3,70.56 152.04,69.82 ; v1(164.62,46.49) 152.25,58.87 152.25,69.3
  BOTTOM w0.076: v1(152.63,77.99) 153.02,78.38 153.02,80.15 152.82,80.35 152.82,80.72 152.86,80.84 152.86,80.95 152.8,81.17 152.8,81.32 152.86,81.47 152.86,81.66 152.84,81.7 152.84,82.27 152.58,82.53 UC1.AW39
  BOTTOM w0.102: v1(164.62,46.49) 164.21,46.91 164.21,48.71 164.48,48.97 JDIMM2.3
DDR_B_D2: length 49
  IN1 w0.076: 154.31,69.3 154.31,69.6 153.47,70.45 153.47,76.51 v1(152.63,77.34)
  IN1 w0.084: v1(167.89,43.45) 167.12,44.21 167.12,48.24 162.14,53.22 162.02,53.22 161.68,52.87 161.53,52.87 161.34,53.07 161.34,53.21 161.58,53.45 161.58,53.59 161.48,53.69 161.34,53.69 160.94,53.29 160.83,53.29 154.31,59.81 154.31,69.3
  BOTTOM w0.076: UC1.AY37 153.05,81.78 153.05,81.53 152.97,81.31 152.97,81.18 153.04,80.95 153.04,80.81 152.98,80.69 152.98,80.42 153.18,80.22 153.18,77.89 v1(152.63,77.34)
  BOTTOM w0.102: JDIMM2.16 167.73,43.29 v1(167.89,43.45)
DDR_B_D3: length 50
  IN1 w0.076: v1(154.41,74.09) 153.67,73.35 153.67,70.47 154.61,69.54 154.61,69.3
  IN1 w0.084: 154.61,69.3 154.61,59.95 160.26,54.3 160.37,54.3 160.64,54.57 160.78,54.57 160.88,54.47 160.88,54.33 160.61,54.07 160.61,53.95 160.73,53.83 160.85,53.83 161.34,54.32 161.46,54.32 167.42,48.36 167.42,45.43 v1(167.89,44.97)
  BOTTOM w0.076: UC1.AW37 153.15,82.32 153.46,82.01 153.46,81.46 153.68,81.24 153.68,80.22 153.68,80.22 153.68,74.82 v1(154.41,74.09)
  BOTTOM w0.102: v1(167.89,44.97) 168.73,44.13 JDIMM2.20
DDR_B_D4: length 46.8
  IN1 w0.084: v1(164.62,48.02) 163.82,48.82 163.7,48.82 163.28,48.39 163.16,48.39 163.04,48.51 163.04,48.63 163.51,49.1 163.51,49.24 163.41,49.33 163.27,49.33 162.8,48.87 162.68,48.87 162.56,48.99 162.56,49.1 163.03,49.57 163.03,49.71 162.93,49.81 162.79,49.81 162.33,49.34 162.21,49.34 162.1,49.45 162.1,49.57 162.56,50.04 162.56,50.18 162.46,50.28 162.32,50.28 161.86,49.81 161.74,49.81 152.55,59 152.55,69.68 151.6,70.63 151.6,73.61 152.08,74.09 v1(152.63,74.09)
  BOTTOM w0.076: v1(152.63,74.09) 151.78,74.94 151.78,78.36 152.03,78.62 152.03,79.44 151.87,79.61 151.87,80.29 151.92,80.34 UC1.BB39
  BOTTOM w0.102: JDIMM2.7 165.48,48.87 v1(164.62,48.02)
DDR_B_D5: length 47.9
  IN1 w0.084: v1(152.63,73.44) 152.23,73.44 151.9,73.11 151.9,70.68 152.85,69.74 152.85,59.15 161.66,50.34 161.78,50.34 162.24,50.8 162.36,50.8 165.03,48.13 165.03,45.38 v1(164.62,44.97)
  BOTTOM w0.076: UC1.BA39 151.92,81.08 151.78,80.94 151.78,80.94 151.78,80.94 151.66,80.69 151.66,80.31 151.71,80.26 151.71,79.54 151.87,79.38 151.87,78.83 151.59,78.56 151.59,74.48 v1(152.63,73.44)
  BOTTOM w0.102: v1(164.62,44.97) 164.2,44.54 164.2,43.25 164.73,42.72 JDIMM2.4
DDR_B_D6: length 48.8
  IN1 w0.076: v1(154.41,71.95) 154.04,71.58 154.04,70.69 155.21,69.53 155.21,69.3
  IN1 w0.084: 155.21,69.3 155.21,61.43 157.96,58.67 157.96,58.55 157.49,58.09 157.49,57.97 157.61,57.85 157.73,57.85 158.2,58.32 158.32,58.32 158.44,58.2 158.44,58.08 157.97,57.61 157.97,57.49 158.09,57.37 158.21,57.37 158.67,57.84 158.79,57.84 168.29,48.35 168.29,46.89 v1(167.89,46.49)
  BOTTOM w0.076: v1(154.41,71.95) 154.8,72.34 154.8,72.81 154.57,73.03 154.09,73.03 153.52,73.61 153.52,80.29 153.52,80.29 153.52,80.76 153.25,81.02 UC1.BA37
  BOTTOM w0.102: JDIMM2.21 168.98,47.58 v1(167.89,46.49)
DDR_B_D7: length 47.9
  IN1 w0.076: 154.91,69.3 154.91,69.47 153.87,70.51 153.87,72.12 v1(154.41,72.66)
  IN1 w0.084: 154.91,69.3 154.91,60.11 158.2,56.82 158.32,56.82 158.79,57.29 158.91,57.29 159.03,57.17 159.03,57.05 158.55,56.58 158.55,56.46 158.7,56.32 158.82,56.32 159.26,56.76 159.4,56.76 159.5,56.66 159.5,56.52 159.05,56.08 159.05,55.96 159.22,55.8 159.34,55.8 159.78,56.24 159.92,56.24 160.02,56.14 160.02,56.01 159.57,55.56 159.57,55.44 159.69,55.33 159.81,55.33 160.29,55.8 160.41,55.8 160.52,55.68 160.52,55.57 160.05,55.09 160.05,54.97 160.17,54.85 160.28,54.85 160.76,55.33 160.88,55.33 167.89,48.32 v1(167.89,48.02)
  BOTTOM w0.076: UC1.BB37 153.25,80.39 153.35,80.29 153.35,73.54 154.23,72.66 v1(154.41,72.66)
  BOTTOM w0.102: JDIMM2.17 167.98,48.11 v1(167.89,48.02)
DDR_B_D8: length 50.6
  IN1 w0.076: 155.7,69.3 155.7,69.39 154.78,70.31 154.78,74.37 v1(154.41,74.74)
  IN1 w0.084: 155.7,69.3 155.7,62.84 156.53,62 156.53,61.89 156.25,61.61 156.25,61.49 156.37,61.37 156.49,61.37 156.77,61.65 156.89,61.65 157.01,61.53 157.01,61.41 156.73,61.13 156.73,61.01 156.85,60.9 156.96,60.9 157.24,61.17 157.36,61.17 157.48,61.06 157.48,60.94 157.2,60.66 157.2,60.54 157.32,60.42 157.44,60.42 157.72,60.7 157.84,60.7 157.95,60.58 157.95,60.46 157.68,60.18 157.68,60.07 166.52,51.22 166.52,50.81 168.78,48.55 168.78,45.36 v1(170.69,43.45)
  BOTTOM w0.076: UC1.AY35 154.48,81.78 154.48,81.52 154.51,81.42 154.51,81.42 154.54,81.33 154.54,81.13 154.51,81.04 154.51,80.79 154.51,80.78 154.54,80.69 154.54,80.12 154.34,79.91 154.34,78.87 154.97,78.24 154.97,75.3 v1(154.41,74.74)
  BOTTOM w0.102: v1(170.69,43.45) 170.73,43.41 JDIMM2.28
DDR_B_D9: length 51.5
  IN1 w0.076: 156,69.3 156,69.47 154.94,70.52 154.94,75.9 154.8,76.04 v1(154.41,76.04)
  IN1 w0.084: v1(170.69,44.97) 169.08,46.59 169.08,48.67 166.82,50.93 166.82,51.35 159.55,58.62 159.55,58.74 159.77,58.97 159.77,59.1 159.68,59.2 159.54,59.2 159.31,58.98 159.19,58.98 159.07,59.09 159.07,59.21 159.3,59.44 159.3,59.58 159.2,59.68 159.06,59.68 158.83,59.45 158.72,59.45 158.6,59.57 158.6,59.69 158.89,59.98 158.89,60.1 158.77,60.21 158.65,60.21 158.36,59.92 158.24,59.92 158.12,60.04 158.12,60.16 158.41,60.45 158.41,60.57 156,62.99 156,69.3
  BOTTOM w0.076: UC1.AW35 154.38,82.34 154.06,82.02 154.06,81.47 153.85,81.26 153.85,80.15 153.85,80.15 153.85,76.61 v1(154.41,76.04)
  BOTTOM w0.102: JDIMM2.24 169.73,44 v1(170.69,44.97)
DDR_B_D10: length 51.2
  IN1 w0.076: v1(156.19,72.14) 156.81,71.52 156.81,71.1 158.06,69.85 158.06,69.3
  IN1 w0.084: v1(173.23,44.97) 172.76,45.44 172.76,46.41 172.42,46.75 172.42,48.36 171.52,49.26 171.52,49.38 171.67,49.52 171.67,49.66 171.57,49.76 171.43,49.76 171.28,49.61 171.16,49.61 171.05,49.73 171.05,49.85 171.38,50.18 171.38,50.3 171.26,50.42 171.14,50.42 170.81,50.09 170.69,50.09 170.57,50.21 170.57,50.32 170.91,50.66 170.91,50.78 170.79,50.9 170.67,50.9 170.33,50.56 170.22,50.56 169.9,50.88 169.9,52.14 158.06,63.98 158.06,69.3
  BOTTOM w0.076: UC1.AY33 155.6,81.68 155.88,81.41 155.88,81.06 155.92,80.96 155.99,80.82 156.04,80.73 156.04,80.36 155.91,80.24 155.91,80.23 155.86,80.18 155.86,79.89 156.08,79.66 156.08,76.71 156.58,76.2 156.58,76.2 156.7,76.08 156.7,72.65 v1(156.19,72.14)
  BOTTOM w0.102: JDIMM2.42 174.22,43.98 v1(173.23,44.97)
DDR_B_D11: length 49.5
  IN1 w0.076: 157.76,69.3 157.76,69.92 156.59,71.08 156.59,71.08 v1(156.19,71.49)
  IN1 w0.084: 157.76,69.3 157.76,63.86 169.6,52.01 169.6,50.75 172.12,48.23 172.12,46.63 172.46,46.29 172.46,44.22 v1(173.23,43.45)
  BOTTOM w0.076: UC1.AW33 154.95,82.53 154.75,82.33 154.75,81.81 154.67,81.71 154.67,81.46 154.72,81.34 154.72,81.11 154.71,81.1 154.71,81.1 154.71,81.09 154.67,81.01 154.67,80.81 154.71,80.72 154.71,80.05 154.51,79.84 154.51,78.94 155.19,78.25
  BOTTOM w0.102: v1(173.23,43.45) 173.22,43.44 JDIMM2.38 ; 155.19,78.25 155.19,72.49 v1(156.19,71.49)
DDR_B_D12: length 49
  IN1 w0.076: v1(154.41,76.69) 155.11,75.99 155.11,70.65 156.3,69.47 156.3,69.3
  IN1 w0.084: v1(170.69,46.49) 169.37,47.81 169.37,48.8 167.12,51.06 167.12,51.49 161.88,56.73 161.88,56.85 162.16,57.13 162.16,57.25 162.04,57.37 161.92,57.37 161.64,57.09 161.5,57.09 161.4,57.18 161.4,57.32 161.68,57.6 161.68,57.72 161.57,57.84 161.45,57.84 161.17,57.56 161.03,57.56 160.93,57.66 160.93,57.8 161.21,58.08 161.21,58.2 161.09,58.32 160.97,58.32 160.69,58.04 160.55,58.04 160.46,58.13 160.46,58.27 160.74,58.55 160.74,58.67 160.62,58.79 160.5,58.79 160.22,58.51 160.1,58.51 159.98,58.63 159.98,58.75 160.26,59.03 160.26,59.15 156.3,63.11 156.3,69.3
  BOTTOM w0.076: v1(154.41,76.69) 154.8,77.08 154.8,78.17 154.18,78.8 154.18,80.01 154.18,80.48 UC1.BB35
  BOTTOM w0.102: v1(170.69,46.49) 171.27,47.07 171.27,48.27 170.98,48.56 JDIMM2.29
DDR_B_D13: length 49.7
  IN1 w0.076: v1(154.41,77.99) 155.27,77.13 155.27,70.86 156.6,69.54 156.6,69.3
  IN1 w0.084: 156.6,69.3 156.6,63.23 162.66,57.17 162.66,57.05 162.39,56.78 162.39,56.66 162.5,56.54 162.62,56.54 162.9,56.81 163.02,56.81 163.14,56.69 163.14,56.58 162.86,56.3 162.86,56.18 162.98,56.06 163.1,56.06 163.37,56.34 163.49,56.34 163.61,56.22 163.61,56.1 163.33,55.83 163.33,55.71 163.47,55.57 163.59,55.57 163.86,55.84 163.98,55.84 164.1,55.72 164.1,55.6 163.83,55.33 163.83,55.21 163.95,55.1 164.07,55.1 164.34,55.36 164.45,55.36 164.57,55.25 164.57,55.13 164.3,54.86 164.3,54.74 164.42,54.62 164.54,54.62 164.81,54.89 164.93,54.89 165.05,54.77 165.05,54.65 164.78,54.38 164.78,54.27 164.93,54.11 165.05,54.11 165.3,54.36 165.42,54.36 165.54,54.24 165.54,54.12 165.29,53.87 165.29,53.75 165.41,53.63 165.53,53.63 165.78,53.88 165.89,53.88 166.01,53.77 166.01,53.65 165.76,53.4 165.76,53.28 165.88,53.16 166,53.16 166.25,53.41 166.37,53.41 166.49,53.29 166.49,53.17 166.24,52.92 166.24,52.8 167.42,51.63 167.42,51.3 v1(170.69,48.02)
  BOTTOM w0.076: v1(154.41,77.99) 154.01,78.39 154.01,80.08 154.01,80.08 154.01,80.75 154.28,81.01 UC1.BA35
  BOTTOM w0.102: v1(170.69,48.02) 169.98,48.74 JDIMM2.25
DDR_B_D14: length 49.4
  IN1 w0.076: 158.66,69.3 158.66,69.84 157.14,71.35 157.14,75.09 v1(156.19,76.04)
  IN1 w0.084: v1(173.23,48.02) 173.23,48.72 173.15,48.81 172.82,48.81 172.72,48.91 172.72,49.05 172.82,49.14 173.15,49.14 173.23,49.23 173.23,49.4 173.15,49.48 172.37,49.48 172.28,49.58 172.28,49.72 172.37,49.81 173.15,49.81 173.23,49.9 173.23,50.07 173.13,50.17 172.19,50.17 172.09,50.27 172.09,50.41 172.19,50.5 173.14,50.5 173.24,50.61 173.24,50.76 173.14,50.86 172.47,50.86 172.37,50.96 172.37,51.13 172.47,51.23 172.96,51.23 173.06,51.33 173.06,51.5 172.96,51.6 172.23,51.6 170.42,53.41 169.47,53.41 158.66,64.23 158.66,69.3
  BOTTOM w0.076: UC1.BA33 155.6,81.08 155.75,80.94 155.75,80.94 155.75,80.94 155.87,80.69 155.87,80.43 155.69,80.25 155.69,79.81 155.9,79.61 155.9,76.33 v1(156.19,76.04)
  BOTTOM w0.102: v1(173.23,48.02) 172.98,48.28 JDIMM2.37
DDR_B_D15: length 49.1
  IN1 w0.076: 158.36,69.3 158.36,69.87 156.97,71.25 156.97,74.61 v1(156.19,75.39)
  IN1 w0.084: 158.36,69.3 158.36,64.1 169.53,52.93 169.65,52.93 169.84,53.11 169.98,53.11 170.08,53.01 170.08,52.88 169.89,52.69 169.89,52.57 170.01,52.45 170.13,52.45 170.47,52.8 170.61,52.8 170.71,52.7 170.71,52.56 170.36,52.21 170.36,52.1 170.48,51.98 170.6,51.98 170.94,52.32 171.08,52.32 171.18,52.22 171.18,52.08 170.84,51.74 170.84,51.62 170.96,51.5 171.08,51.5 171.4,51.82 171.54,51.82 171.64,51.73 171.64,51.59 171.31,51.27 171.31,51.15 171.79,50.67 171.79,49.96 171.98,49.78 171.98,49.22 172.32,48.88 172.72,48.48 172.72,47.01 v1(173.23,46.49)
  BOTTOM w0.076: UC1.BB33 155.6,80.45 155.53,80.37 155.53,79.74 155.73,79.54 155.73,75.85 v1(156.19,75.39)
  BOTTOM w0.102: JDIMM2.41 173.98,47.24 v1(173.23,46.49)

# Allegro board LAC451PR10-0923B.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PCIE_PTX_DRX_P3: length 138.7
  IN4 w0.102: v1(285.52,101.52) 285.34,101.33 284.88,101.33 284.52,101.69 284.52,103.48 282.75,105.25 280.44,105.25 279.97,105.72 274.67,105.72 274.19,105.24 245.07,105.24 241.35,108.95 238.67,108.95 237.66,109.96 228.61,109.96 227.91,109.27 227.37,109.27 226.77,109.86 224.97,109.86 224.19,109.09 221.03,109.09 219.3,107.36 212.8,107.36 212.42,106.98 206.05,106.98 204.52,108.51 187.03,108.51 186.18,109.37 181.5,109.37 180,107.87 178.76,107.87 178.09,107.2 172.65,107.2 172.33,107.52 170.92,107.52 169.79,108.65 169.54,108.65 v1(169.38,108.82)
  BOTTOM w0.076: v1(169.38,108.82) 169.17,108.61 168.59,108.61 168.31,108.33 166.75,108.33 165.67,107.25 165.67,106.49 164.58,105.4 164.58,103.98 164.03,103.44 164.03,103.07 164.07,102.98 164.07,102.79 164.03,102.69 164.03,102.45 164.05,102.4 164.09,102.25 164.11,102.17 164.17,101.97 164.17,101.63 164.25,101.56 164.4,101.56 164.47,101.62 UC1.C17
  BOTTOM w0.094: v1(285.52,101.52) 285.36,101.35 285.28,101.27 284.93,101.27 284.78,101.42 284.34,101.42 CZ59.1
PCIE_PTX_DRX_P5: length 167.7
  TOP w0.094: CZ13.1 253.78,53.26 253.78,53.47 v1(253.59,53.66)
  IN2 w0.122: v1(250.69,105.8) 251.06,105.43 251.06,103.87 250.25,103.07 250.25,97.27 251.55,95.97 251.55,85.54 252.28,84.8 252.28,83.22 255.8,79.7 255.8,77.15 254.11,75.46 248.89,75.46 248.31,74.88 247.09,74.88 246.21,74 246.21,70.67 246.35,70.53 246.35,65.53 246.67,65.21 247.3,65.21 247.56,64.96 247.56,64.22 248.16,63.62 248.16,61.04 251.69,57.51 251.69,57.18 253.78,55.08 253.78,53.84 v1(253.59,53.66)
  IN4 w0.102: v1(163.69,104.46) 163.87,104.64 165.51,104.64 166.35,105.48 166.35,107.61 166.81,108.07 167.88,108.07 169.02,109.21 169.81,109.21 171.08,107.95 172.54,107.95 172.88,107.61 177.85,107.61 178.7,108.46 180.02,108.46 181.33,109.77 186.35,109.77 187.2,108.92 204.69,108.92 206.08,107.53 210.81,107.53 211.05,107.77 219.11,107.77 220.95,109.61 223.04,109.61 224.19,110.75 229.78,110.75 230.27,111.24 237.4,111.24 238.85,109.8 241.08,109.8 244.62,106.26 250.76,106.26 250.87,106.15 250.87,105.99 v1(250.69,105.8)
  BOTTOM w0.076: v1(163.69,104.46) 163.56,104.46 163.42,104.31 163.42,103.68 163.55,103.55 163.55,103.07 163.51,102.98 163.51,102.79 163.55,102.69 163.55,102.45 163.53,102.4 163.49,102.25 163.49,102.14 163.33,101.59 UC1.D19
PCIE_PTX_DRX_P6: length 163.7
  TOP w0.094: v1(260.89,56.08) 261.06,55.92 261.06,55.61 CZ21.1
  IN2 w0.122: v1(253.9,106.55) 254.19,106.26 254.19,105.81 253.17,104.79 253.17,101.76 253.47,101.45 253.47,92.96 253.98,92.46 253.98,88.32 253.47,87.81 253.47,86.36 254.21,85.62 254.21,84.36 255.46,83.11 256.16,83.11 257.77,81.5 257.77,74.23 258.09,73.9 258.09,73.1 256.77,71.78 256.77,70.24 256.61,70.08 256.61,64.19 256.79,64 256.79,62.47 257.2,62.06 257.69,62.06 258.96,60.79 258.96,59.45 260.77,57.64 260.77,57.2 261.08,56.88 261.08,56.27 v1(260.89,56.08)
  IN4 w0.102: v1(163.7,106.16) 163.86,106 164.65,106 165.04,106.38 165.04,109 165.55,109.52 168.15,109.52 168.67,110.05 170.64,110.05 171.18,109.51 172.49,109.51 172.95,109.05 172.95,108.73 173.23,108.45 177.38,108.45 178.27,109.34 179.72,109.34 180.99,110.61 186.69,110.61 187.55,109.75 205.03,109.75 205.65,109.13 209.43,109.13 209.95,108.6 214.97,108.6 215.46,109.1 219.19,109.1 220.53,110.44 221.57,110.44 222.72,111.59 229,111.59 229.49,112.08 239.98,112.08 244.96,107.1 251.41,107.1 252.48,106.03 254.12,106.03 254.22,106.12 254.22,106.24 v1(253.9,106.55)
  BOTTOM w0.076: UC1.C20 162.53,102.22 162.34,102.22 162.25,102.3 162.25,102.41 162.65,102.81 162.65,103.53 162.71,103.58 162.71,105.51 163.12,105.91 163.45,105.91 v1(163.7,106.16)
PCIE_PTX_DRX_P9: length 136.2
  TOP w0.094: v1(259.85,87.13) 260.05,87.33 260.05,87.48 CL5.1
  IN2 w0.122: v1(197.4,111.39) 197.77,111.02 197.77,110.47 198.65,109.58 214.08,109.58 214.63,110.13 219.45,110.13 220.72,111.4 221.04,111.4 222.3,112.66 239.23,112.66 239.75,113.18 243.06,113.18 243.8,112.44 255.34,112.44 257.74,110.04 257.74,106.7 258.1,106.35 258.1,103.7 259.29,102.51 259.29,97.15 258.32,96.17 258.32,90.55 260.02,88.85 260.02,87.3 v1(259.85,87.13)
  IN4 w0.102: v1(159.96,104.75) 159.96,104.79 160.35,105.18 160.35,105.52 160.82,105.99 160.82,106.64 162.14,107.96 162.14,108.72 165.09,111.67 167.97,111.67 167.99,111.69 172.03,111.69 172.41,111.31 174.73,111.31 175.67,112.25 193.95,112.25 194.36,111.84 197.47,111.84 197.57,111.74 197.57,111.56 v1(197.4,111.39)
  BOTTOM w0.076: v1(159.96,104.75) 159.96,104.86 159.85,104.97 159.81,104.97 159.73,105.05 159.65,105.05 159.56,104.96 159.56,104.62 160.37,103.81 160.37,102.99 160.49,102.87 160.61,102.87 160.68,102.94 160.68,103.17 UC1.A23
PCIE_PTX_DRX_P10: length 151.9
  TOP w0.094: CR24.1 263.32,81.34 263.2,81.34 v1(263,81.54)
  IN2 w0.122: v1(263,81.54) 263.18,81.36 263.32,81.36 263.43,81.47 263.43,82.2 263.08,82.56 263.08,96.3 264.18,97.41 264.18,102.09 267.45,105.36 267.45,106.78 267.71,107.04 268.05,107.04 v1(268.23,107.23)
  IN4 w0.102: v1(268.23,107.23) 268.08,107.07 267.31,107.07 265.5,108.87 255.61,108.87 255.15,108.41 246.67,108.41 240.47,114.61 226.78,114.61 226.41,114.24 223.62,114.24 221.06,111.68 220.02,111.68 218.68,110.34 214.95,110.34 214.46,109.85 210.63,109.85 210.1,110.37 206.28,110.37 205.66,110.99 194.51,110.99 193.66,111.84 178.54,111.84 177.52,110.83 172.16,110.83 171.7,111.29 168.16,111.29 167.64,110.77 164.76,110.77 162.55,108.55 162.55,107.21 162.34,107.01 162.34,105 162.11,104.77 161.56,104.77 v1(161.34,104.99)
  BOTTOM w0.076: UC1.C23 160.64,102.13 160.72,102.22 160.79,102.22 160.85,102.32 160.9,102.47 160.9,102.66 160.88,102.72 160.87,102.75 160.87,103.01 160.9,103.1 160.9,103.37 160.74,103.53 160.74,104.11 160.97,104.34 160.97,104.51 161.34,104.88 v1(161.34,104.99)
PCIE_PTX_DRX_P11: length 193.6
  TOP w0.094: CN21.1 28.07,59.9 28.07,60.35 v4(28.32,60.6)
  IN1 w0.102: v4(28.32,60.6) 28.08,60.36 28.08,60.14 28.23,59.99 28.88,59.99 29.87,60.98 49.87,60.98 52.74,63.85 54.23,63.85 65.91,75.54 65.91,77.83 73.71,85.63 73.71,95.77 77.57,99.63 77.57,104.2 79.47,106.1 79.47,115.2 81.52,117.24 86.15,117.24 86.57,117.66 92.93,117.66 94.2,118.92 109.5,118.92 109.8,118.63 116.52,118.63 119.97,122.08 125.32,122.08 125.75,122.51 132.03,122.51 132.47,122.95 135.78,122.95 135.91,123.08 139.98,123.08 140.32,122.74 142.98,122.74 143.62,122.09 146.58,122.09 148.6,120.07 148.6,116.94 150.69,114.84 150.69,112.65 151.42,111.92 151.42,111.43 152.04,110.8 158,110.8 159.09,109.71 159.09,107.6 158.8,107.31 158.53,107.31 v4(158.29,107.08)
  BOTTOM w0.076: UC1.C24 160.07,102.14 159.96,102.03 159.84,102.03 159.71,102.15 159.71,102.34 159.93,102.56 159.93,102.65 159.87,102.71 159.87,103.61 158.86,104.62 158.86,107.29 158.82,107.34 158.54,107.34 158.29,107.08 v4(158.29,107.08)
PCIE_PTX_DRX_P12: length 172.9
  TOP w0.094: CN32.1 42.24,59.32 42.24,59.5 v4(42.42,59.67)
  IN1 w0.102: v4(42.42,59.67) 42.27,59.67 42.14,59.54 42.14,59.28 42.27,59.15 46.17,59.15 46.75,59.74 50.38,59.74 53.26,62.61 54.74,62.61 67.15,75.02 67.15,77.32 74.95,85.12 74.95,95.26 80.71,101.03 80.71,113.61 82.18,115.08 88.98,115.08 90.32,116.42 93.53,116.42 94.37,117.25 103.3,117.25 103.73,117.68 108.99,117.68 109.29,117.39 117.03,117.39 120.48,120.84 125.87,120.84 126.3,121.27 132.55,121.27 132.99,121.71 136.17,121.71 136.63,121.24 139.14,121.24 139.35,121.46 140.38,121.46 140.83,121.01 142.6,121.01 143.19,120.41 145.4,120.41 147.36,118.46 147.36,116.14 149.1,114.4 149.1,112.11 152.08,109.12 153.05,109.12 154.87,107.31 154.87,106.24 155.31,105.8 157.85,105.8 158.62,105.03 158.62,104.36 158.38,104.13 158.11,104.13 v4(157.95,103.96)
  BOTTOM w0.076: v4(157.95,103.96) 157.97,103.99 158.15,103.99 159.51,102.63 UC1.B25
PCIE_PTX_RD_DRX_N11: length 2.3
  TOP w0.094: CN26.2 27.82,51.23 27.82,51.35 27.7,51.48 v5(27.7,51.86) 27.7,52.42 27.58,52.54 UN4.17
PCIE_PTX_RD_DRX_N12: length 1.8
  TOP w0.094: UN5.17 41.62,52.18 41.77,52.02 41.77,51.77 41.95,51.6 41.95,51.35 CN36.2
PCIE_PTX_RD_DRX_P11: length 2.4
  TOP w0.094: CN25.2 28,51.23 28,51.43 27.91,51.52 27.91,52.19 27.88,52.23 27.88,52.34 28.08,52.54 UN4.18
PCIE_PTX_RD_DRX_P12: length 1.9
  TOP w0.094: UN5.18 42.12,52.17 41.96,52.01 41.96,51.84 42.13,51.67 42.13,51.43 CN35.2
PCIE_RCOMPN: length 2.3
  TOP w0.127: v2(172.67,99.7) 172.46,99.91 RC45.1
  TOP w0.381: RC45.1 171.23,99.91 171.14,100 v1(170.95,100)
  BOTTOM w0.254: v1(170.95,100) UC1.F5
PCIE_RCOMPP: length 2
  TOP w0.127: v2(170.29,100.86) 170.44,100.71 v1(170.95,100.71)
  TOP w0.381: v1(170.95,100.71) 171.06,100.82 RC45.2
  BOTTOM w0.254: UC1.E5 v1(170.95,100.71)
PCIE_WAKE#: length 355.3
  TOP w0.102: v1(257.35,46.16) 257.53,46.34 258.28,46.34 258.52,46.58 258.52,47.66 258.68,47.82 259.05,47.82 260.03,48.8 261.8,48.8 262.13,48.47 265.61,48.47 268.23,51.1 268.23,51.84 269.43,53.03 269.43,53.74 267.82,55.36 RE274.1 268.36,56.19 268.36,58.64 v2(267.93,59.07) v1(265.88,61.12) ; v1(263.71,75.32) 264.34,74.7 RE275.1
  IN1 w0.084: v1(257.35,46.16) 257.35,45.21 254.8,42.66 239.8,42.66 239.54,42.92 234.12,42.92 232.64,41.44 228.89,41.44 228.74,41.58 174.2,41.58 173.62,42.16 162.12,42.16 159.43,44.84 154.2,44.84 153.49,44.13 151.62,44.13 151.35,43.86 148.75,43.86 148.36,43.46 148.36,42.93 146.65,41.22 140.99,41.22 140.85,41.08 79.87,41.08 77.84,43.1 75.38,43.1 73.66,41.38 73.66,39.47 72.96,38.77 61.21,38.77 59.93,40.05 56.53,40.05 55.31,38.83 40.01,38.83 36,42.83 33.61,42.83 29.73,38.95 28.45,38.95 26.95,37.44 26.95,35.38 25.68,34.11 12.46,34.11 v1(12.04,33.69)
  IN2 w0.102: JNGFF3.54 12.2,33.53 12.16,33.56
  IN2 w0.122: 12.16,33.56 v1(12.04,33.69)
  BOTTOM w0.102: JNGFF1.62 260.85,51.81 257.35,48.31 v1(257.35,46.16) 257.1,45.91 JNGFF1.47 ; v1(265.88,61.12) 266.43,61.67 266.43,64.43 264.53,66.33 264.53,70.12 263.71,70.93 v1(263.71,75.32) 263.71,84.85 262.56,86.01 262.56,90.47 263.94,91.86 265.7,91.86 266.67,92.83 266.67,94.92 263.94,97.65 263.94,100.75 265.05,101.85 JNGFF2.46
PCIE_WAKE#_R: length 34.9
  TOP w0.102: RE275.2 RE35.2 262.82,73.1 v1(262.37,73.1) ; v1(237.02,67.34) 237.15,67.48 UE1.B10
  IN4 w0.084: v1(262.37,73.1) 262.71,72.75 262.71,69.21 262.3,68.8 262.3,68.3 262.15,68.16 261.55,68.16 261.03,67.64 260.07,67.64 259.51,67.08 257.13,67.08 256.09,68.13 249.95,68.13 249.66,68.42 238.85,68.42 237.91,67.48 237.15,67.48 v1(237.02,67.34)
PECI_EC: length 189.2
  TOP w0.102: RE60.2 262,75.93 v1(262.07,76.01) ; v1(249.27,109.51) 249.27,109.32 243.77,103.82 v2(219.2,103.82) 218.77,103.39 210.92,103.39 201.98,112.33 199.12,112.33 196.01,115.44 193.86,115.44 v1(193.3,116)
  IN1 w0.084: v1(193.3,116) 191.89,117.41 191.13,117.41 188.5,120.03 188.5,120.95 187.51,121.94 v1(187.51,124.53)
  IN2 w0.122: v1(262.07,76.01) 262.07,79.01 261.67,79.42 261.67,83.71 258.81,86.57 257.17,86.57 256.78,86.96 256.78,100.17 256.04,100.91 256.04,104.91 256.58,105.44 256.58,110.39 255.1,111.86 251.63,111.86 v1(249.27,109.51)
  IN4 w0.076: 145.07,111.9 144.73,111.55 144.34,111.55 142.98,110.19 142.98,108.36 v1(142.39,107.77)
  IN4 w0.084: v1(187.51,124.53) 183.33,124.53 181.83,123.03 172.77,123.03 171.31,124.49 162.89,124.49 159.98,121.57 157.86,121.57 154.95,124.48 149.65,124.48 147.37,122.2 147.37,114.71 146.43,113.76 146.43,113.25 145.07,111.9
  BOTTOM w0.076: v1(142.39,107.77) 142.39,107.11 142.97,106.52 142.97,105.84 143.08,105.74 143.08,104.55 143.29,104.34 UC1.A54
PECI_EC_R: length 5.1
  TOP w0.102: RE60.1 v2(261.47,73.83) 260.47,72.84 260.47,71.15 260.11,70.79 UE2.A48
PGOOD_3V: length 15.1
  TOP w0.254: PU101.1 206.01,80.2 206.31,79.9 v1(206.59,79.9) 206.59,79.31 PR120.1
  IN1 w0.254: v1(206.59,79.9) 206.75,79.9 208.24,81.39 v1(214.64,81.39)
  BOTTOM w0.254: PU100.9 216.91,84.09 216.66,83.84 215.87,83.84 PR107.2 214.69,82.66 214.69,81.44 v1(214.64,81.39)
PGOOD_5V: length 7.6
  TOP w0.254: v1(206.86,81.39) 206.66,81.2 PU101.2 206.66,80.48 207.39,79.75 PR119.1
  BOTTOM w0.102: v1(206.86,81.39) 206.86,80.86 v2(207.01,80.7)
  BOTTOM w0.254: v1(206.86,81.39) 206.86,82.15 PR113.2 207.83,83.13 207.83,83.75 208.59,84.51 PU102.9
PLTRST_5048#: length 59.6
  TOP w0.102: v1(234.67,70.16) 235.17,70.66 UE1.B22
  IN1 w0.084: v1(194.03,89.59) 194.45,90.02 198.43,90.02 200.96,87.49 200.96,85.69 203.07,83.59 203.07,80.75 206.29,77.53 213.66,77.53 214.1,77.1 234.86,77.1 v1(235,77.24)
  IN2 w0.122: v1(235,77.24) 235,77.01 235.48,76.52 235.48,75.23 234.97,74.71 234.97,71.92 235.13,71.76 235.13,70.62 v1(234.67,70.16)
  BOTTOM w0.102: RC64.1 v1(194.03,89.59)
PLTRST_LAN#: length 84.2
  TOP w0.102: UL1.36 v1(257.22,91.23)
  IN1 w0.084: v1(213.04,76.75) 212.55,76.26 205.9,76.26 201.9,80.27 201.9,82.25 200.3,83.85 200.3,84.68 199.25,85.72 199.25,87.55 198.91,87.89 197.51,87.89 196.97,88.43 193.22,88.43 v1(192.02,89.63)
  IN4 w0.084: v1(257.22,91.23) 256.91,91.23 255.72,90.05 255.72,86.75 254.84,85.86 254.84,84.46 252.02,81.64 250.59,81.64 249.54,80.59 247.28,80.59 246.68,80 245.91,80 243.94,78.02 241.86,78.02 240.58,76.75 235.96,76.75 235.93,76.78 233.75,76.78 233.74,76.78 213.06,76.78 v1(213.04,76.75)
  BOTTOM w0.102: RC62.1 192.02,89.29 v1(192.02,89.63)
PLTRST_TPM#: length 39.7
  TOP w0.102: v1(212.46,76.77) 212.46,76.68 213.4,75.74 v2(213.4,75.22) 213.4,74.57 213.19,74.37 UZ12.17
  IN1 w0.084: v1(212.46,76.77) 212.34,76.65 206.06,76.65 202.29,80.43 202.29,82.41 200.69,84.01 200.69,84.84 199.64,85.89 199.64,87.71 199.07,88.28 197.69,88.28 197.15,88.82 193.39,88.82 v1(192.58,89.63)
  IN4 w0.084: v1(192.58,89.63) 191.87,88.91 191.87,86.41 v1(191.65,86.2)
  BOTTOM w0.102: v1(192.58,89.63) 192.58,88.96 RC60.1 ; RC325.1 190.47,86.2 v1(191.65,86.2)
PLTRST_VMM2320#: length 57.2
  TOP w0.089: UV8.A13 213.36,120.59 212.31,121.65
  TOP w0.102: 212.31,121.65 212.29,121.66 v1(212.2,121.66)
  IN1 w0.084: v1(190.65,119.11) 191.62,120.07 201.91,120.07 203.37,121.53 212.07,121.53 v1(212.2,121.66)
  IN2 w0.122: v1(190.65,119.11) 190.09,118.55 190.09,101.34 191.31,100.12 191.31,95.76 192.46,94.61 192.46,93.54 194.59,91.42 v1(194.59,89.59)
  BOTTOM w0.102: v1(194.59,89.59) 194.92,89.26 RC61.1
PM_LANPHY_ENABLE: length 135.7
  TOP w0.102: RL7.1 268.89,87.02 v1(268.73,86.85)
  IN3 w0.102: v1(268.73,86.85) 268.73,83.49 266.48,81.24 266.48,80.31 264.22,78.05 262.48,78.05 262.35,78.18 258.7,78.18 257.99,78.89 257.99,79.94 258.18,80.14 258.18,81.14 257.7,81.61 257.01,81.61 256.69,81.29 255.96,81.29 255.32,81.93 251.38,81.93 250.56,81.11 244.99,81.11 244.75,80.87 241.9,80.87 239.07,78.04 234.37,78.04 232.73,76.4 230.43,76.4 230.16,76.13 227.31,76.13 226.04,74.87 226.04,73.31 225.45,72.72 224.9,72.72 v1(224.53,72.35)
  BOTTOM w0.076: UC1.AW17 164.33,82.43 164.15,82.26 164.15,82.26 163.94,81.56 163.94,81.47 163.88,81.32 163.88,81.17 163.95,80.95 163.95,80.84 163.9,80.72 163.9,80.36 164.09,80.17 164.09,78.64 164.92,77.82 164.92,77.14 165.13,76.93
  BOTTOM w0.102: v1(224.53,72.35) 224.32,72.56 223.73,72.56 222.91,71.74 221.52,71.74 221,72.26 214.08,72.26 212.77,70.95 212.77,70.24 211.85,69.31 210.62,69.31 208.09,66.79 177.49,66.79 176.13,68.15 169.22,68.15 168.52,68.85 168.52,71.67 165.13,75.06 165.13,76.93
PME#: length 2.8
  TOP w0.102: T115.1 166.85,83.83 v1(167.31,83.37)
  BOTTOM w0.076: UC1.AU11 167.64,83.7 v1(167.31,83.37)
POA_WAKE#: length 104.6
  TOP w0.102: RPE5.3 246.49,74.07 246.61,74.19 248.33,74.19 248.54,73.99 248.93,73.99 v1(249.68,73.24) 249.68,72.75 250.37,72.06 UE2.B68 ; v2(286.41,11.02) v1(286.41,9.98)
  IN1 w0.102: v1(269.72,69.82) 269.22,69.82 265.56,73.48 263.75,73.48 262.96,72.68 262.14,72.68 261.83,73 258.41,73 257.93,72.52 251.94,72.52 251.61,72.84 250.07,72.84 v1(249.68,73.24)
  IN2 w0.102: v1(269.72,69.82) 270.15,69.39 270.15,69.2 270.86,68.49 270.86,66.79 271.41,66.24 271.41,63.96 270.88,63.42 270.88,59.74 270.25,59.12 270.25,54.37 270.13,54.25 270.13,53.27 268.74,51.89 268.74,44.18 275.3,37.62 275.3,16.36 279.23,12.43 279.23,11.41 281.82,8.82 285.57,8.82 285.93,9.18 285.93,9.5 v1(286.41,9.98)
  BOTTOM w0.102: JUSH1.23 285.9,9.01 286,9.11 286,9.57 v1(286.41,9.98)
POWER_SW#_MB: length 171.2
  TOP w0.102: v1(245.82,79.03) 245.49,79.36 CE10.1 RE33.2 ; v1(291.74,114.85) SW3.2 SW3.4 ; v1(246.49,56.54) 246.1,56.14 v3(246.1,55.89) ; v1(188.55,64.13) 188.55,63.69 188.56,63.69 JAPS1.11
  IN1 w0.102: v1(188.55,64.13) 189.73,62.95 199.34,62.95 205,57.29 223.94,57.29 224.69,58.03 226.9,58.03 227.52,57.42 232.48,57.42 233.09,58.03 234.63,58.03 235.21,57.45 237.54,57.45 237.95,57.86 241.98,57.86 243.02,58.91 243.58,58.91 243.81,58.68 243.81,57.51 244.08,57.25 245.55,57.25 246.26,56.54 v1(246.49,56.54)
  IN2 w0.102: v1(246.49,56.54) 247.74,57.78 247.74,58.49 246.42,59.81 246.42,64.7 245.94,65.18 245.94,70.36 245.77,70.53 245.77,74.47 245.88,74.58 245.88,75.38 245.46,75.8 245.46,78.67 v1(245.82,79.03)
  IN4 w0.102: v1(245.82,79.03) 245.82,79.35 246.07,79.6 249.41,79.6 251.06,81.24 252.18,81.24 255.24,84.31 255.24,85.71 256.59,87.05 256.59,90.35 256.97,90.73 257.37,90.73 257.74,91.11 269.8,91.11 271.12,92.43 274.86,92.43 275.77,91.52 276.98,91.52 277.39,91.93 279.66,91.93 280.07,91.52 283.51,91.52 287.03,95.04 287.03,98.87 289.07,100.91 289.07,109.5 291.74,112.16 v1(291.74,114.85)
POWER_SW_IN#: length 17.1
  TOP w0.102: v1(251.72,70.51) 251.24,70.51 250.87,70.87 UE2.B67 ; v2(241.44,78.44) RE31.2 CE12.1 RE33.1 244.6,78.04 245.64,78.04 v1(245.84,77.83)
  BOTTOM w0.102: v1(251.72,70.51) 251.79,70.58 251.79,71.18 251,71.97 251,73.97 248.03,76.95 246.59,76.95 246.07,77.47 246.07,77.61 v1(245.84,77.83)
PS_ID: length 294.1
  TOP w0.102: UE2.B24 v1(253.37,63.08)
  TOP w0.254: PU1.4 v1(74.44,115.87)
  IN1 w0.102: v1(56.93,61.18) 56.93,59.66 58.6,57.99 58.6,53.02 64.92,46.69 66.49,46.69 66.71,46.91 67.68,46.91 v1(68.23,47.47)
  IN2 w0.102: v1(78.98,50.07) 79.3,49.75 80.82,49.75 84.24,53.17 85.97,53.17 86.38,53.58 215.68,53.58 224.42,62.32 v1(224.42,65.69)
  IN4 w0.102: v1(78.98,50.07) 78.05,49.14 77.28,49.14 74.11,45.98 69.72,45.98 v1(68.23,47.47) ; v1(224.42,65.69) 224.42,65.55 225.05,64.92 225.35,64.92 225.87,64.41 225.87,63.76 228.15,61.48 238.56,61.48 238.77,61.27 244.83,61.27 246.41,59.69 247.2,59.69 249.79,62.28 252.58,62.28 v1(253.37,63.08) ; v1(72.49,89.12) 73.29,89.92 73.29,94.4 72.81,94.88 72.81,101.19 76.11,104.49 78.84,104.49 79.89,105.55 79.89,112.73 78.01,114.61 75.43,114.61 74.44,115.6 v1(74.44,115.87)
  BOTTOM w0.102: v1(56.93,61.18) 56.93,66.58 73.33,82.97 73.33,88.29 v1(72.49,89.12)
PSID_DISABLE#: length 268.3
  TOP w0.102: UE1.A37 v1(227.01,68.73)
  TOP w0.254: v1(69.54,114.51) PR11.2
  IN1 w0.102: v1(65.66,48.61) 63.29,48.61 58.8,53.1 58.8,58.08 57.22,59.65 57.22,60.91 v1(57.5,61.18)
  IN2 w0.102: v1(227.01,68.73) 226.54,68.26 222.81,68.26 222.5,67.95 222.5,63.61 221.92,63.03 221.92,61.83 215.09,55 87.94,55 87.34,55.6 84.95,55.6 82.01,52.66 79.05,52.66 77.88,51.49 76.92,51.49 76.04,52.37 71.3,52.37 68.85,49.92 68,49.92 67.4,49.32 66.37,49.32 v1(65.66,48.61)
  IN4 w0.102: v1(69.54,114.51) 70,114.97 74.79,114.97 75.35,114.41 77.93,114.41 79.69,112.65 79.69,105.63 78.75,104.69 76.02,104.69 72.6,101.27 72.6,94.79 73.08,94.31 73.08,90.29 v1(72.49,89.7)
  BOTTOM w0.102: v1(57.5,61.18) 57.38,61.31 57.38,66.73 73.53,82.89 73.53,88.65 v1(72.49,89.7)
PWM1_GT: length 6.4
  BOTTOM w0.203: PR680.1 90.56,81.82 91.32,81.06 PU605.8
  BOTTOM w0.254: v1(91.09,86.01) 90.15,85.07 v2(90.15,83.54) 90.56,83.13 PR680.1
PWM_IA: length 24.6
  TOP w0.102: v2(100.95,104.52) 101.1,104.36 v1(101.7,104.36)
  TOP w0.203: PU602.22 88.52,90.8 88.82,91.11 v1(88.82,91.42)
  IN3 w0.254: v1(101.7,104.36) 101.45,104.36 97.08,100 97.08,96.76 94.14,93.82 91.22,93.82 v1(88.82,91.42)
  BOTTOM w0.203: PR662.1 101.7,104.63 v1(101.7,104.36) 102.07,104 PU603.8
PWM_VSA: length 61.7
  TOP w0.203: 85.07,90.99 85.32,90.75 PU602.30
  TOP w0.254: 85.07,90.99 85.07,91.36 84.78,91.65 84.16,91.65 82.32,93.49 82.32,94.4 83.42,95.5 93.06,95.5 v2(94.15,96.59) 98.53,100.96 98.53,107.09 101.05,109.61 105.74,109.61 110.96,114.83 118.96,114.83 119.48,115.35 122.01,115.35 122.6,115.93 123.44,115.93 v1(123.68,116.18)
  BOTTOM w0.254: v1(123.68,116.18) 123.68,115.08 123.94,114.83 PU606.3
RD1_A_DE0: length 4.2
  TOP w0.102: UN4.6 25.58,57.55 24.86,58.26 RN25.2 24.5,58.89 24.24,58.63 v2(23.94,58.63) 23.81,58.76 23.81,59.43 RN38.1
RD1_A_DE1: length 5.6
  TOP w0.102: v2(21.55,59.11) 22.13,59.11 RN39.1 23.1,58.15 RN26.2 23.47,57.31 23.59,57.18 23.59,56.42 24.24,55.78 UN4.8
RD1_A_EQ0: length 5.1
  TOP w0.102: UN4.23 29.36,55.78 29.88,56.3 30.97,56.3 RN42.2 RN45.1 v2(32.47,57.88)
RD1_A_EQ1: length 6
  TOP w0.102: v2(34.29,54.87) 33.87,55.29 33.08,55.29 32.59,55.79 RN46.1 RN43.2 30.97,55.27 UN4.22
RD1_A_EQ2: length 5
  TOP w0.102: UN4.19 29.35,53.78 v2(30.87,52.26) 31.15,51.98 RN44.2 RN47.1
RD1_B_DE0: length 3.4
  TOP w0.102: RN27.2 RN40.1 24.67,51.7 v2(24.87,51.89) 25.58,52.61 UN4.13
RD1_B_DE1: length 4.9
  TOP w0.102: UN4.9 24.11,55.27 23.85,55.53 RN41.1 RN28.2 22.67,55.99 v2(21.07,55.99)
RD1_B_EQ0: length 5.1
  TOP w0.102: v2(21.1,53.04) 21.38,53.32 22.64,53.32 RN52.1 RN49.2 23.59,53.76 24.11,54.27 UN4.11
RD1_B_EQ1: length 5.1
  TOP w0.102: v2(32.47,53.68) RN53.1 RN50.2 31.04,54.33 29.81,54.33 29.37,54.78 UN4.21
RD1_B_EQ2: length 6
  TOP w0.102: v1(27.11,52.1) 27.08,52.13 UN4.16 ; v1(29.39,52.1) 29.37,52.09 RN54.1 RN51.2
  IN1 w0.102: v1(27.11,52.1) 27.18,52.17 29.32,52.17 v1(29.39,52.1)
  BOTTOM w0.102: v2(27.08,52.76) 27.08,52.13 v1(27.11,52.1)
RD1_REXT: length 4
  TOP w0.102: v2(21.13,54.39) 21.31,54.21 22.67,54.21 RN30.1 23.85,54.64 23.98,54.78 UN4.10
RD2_A_DE0: length 4.9
  TOP w0.102: UN5.6 39.62,57.16 38.96,57.82 RN55.2 RN59.1 37.63,58.57 v2(37.63,60.21)
RD2_A_DE1: length 5
  TOP w0.102: UN5.8 38.21,55.39 37.56,56.04 37.56,56.8 37.44,56.93 RN56.2 RN60.1 37.01,58.19 v2(36.4,58.8)
RD2_A_EQ0: length 5.2
  TOP w0.102: UN5.23 43.33,55.39 43.85,55.91 44.94,55.91 RN63.2 RN66.1 46.94,57.04 v2(46.94,57.53)
RD2_A_EQ1: length 5.9
  TOP w0.102: UN5.22 44.94,54.89 RN64.2 RN67.1 46.31,55.39 46.84,54.87 v2(48.35,54.87)
RD2_A_EQ2: length 5.2
  TOP w0.102: UN5.19 43.36,53.39 43.52,53.23 43.52,52.5 43.79,52.23 v2(45.06,52.23) 45.45,52.62 RN65.2 RN68.1
RD2_B_DE0: length 5.1
  TOP w0.102: v2(39.2,48.05) 39.2,49.59 RN61.1 38.77,50.95 RN57.2 38.78,51.42 39.62,52.25 UN5.13
RD2_B_DE1: length 5.1
  TOP w0.102: UN5.9 38.08,54.89 37.82,55.15 RN62.1 RN58.2 36.88,56.04 36.42,55.58 35.39,55.58 v2(35.07,55.9)
RD2_B_EQ0: length 5.2
  TOP w0.102: v2(35.07,52.51) 35.48,52.92 36.57,52.92 RN72.1 RN69.2 37.56,53.37 38.08,53.89 UN5.11
RD2_B_EQ1: length 6.1
  TOP w0.102: UN5.21 43.27,54.39 43.71,53.96 45.02,53.96 RN70.2 RN73.1 46.31,54.38 46.86,53.83 47.97,53.83 v2(48.26,53.54)
RD2_B_EQ2: length 5.6
  TOP w0.102: RN71.2 RN74.1 43.53,51.41 v1(43.79,51.66) ; v1(41.18,51.75) 41.12,51.82 UN5.16
  IN1 w0.102: v1(43.79,51.66) 41.27,51.66 v1(41.18,51.75)
  BOTTOM w0.102: v2(40.7,51.74) 40.73,51.74 40.74,51.75 v1(41.18,51.75)
RD2_REXT: length 4
  TOP w0.102: UN5.10 37.82,54.39 37.69,54.26 RN31.1 36.87,54.26 36.42,53.82 v2(35.09,53.82)
REM_DIODE1_N: length 135.7
  TOP w0.254: v1(250.93,64.9) 250.78,65.04 UE2.B13 ; QE3.3 142.21,90.6 CE35.1 142.58,90.23 143.32,90.23 v1(143.36,90.27) ; CE24.1 v1(246.86,62.82)
  IN1 w0.254: v1(243.58,72.22) 243.57,72.21 242.44,72.21 238.67,75.97 236.37,75.97 235.6,75.21 234.74,75.21 233.97,75.97 217.92,75.97 217.54,75.59 206.63,75.59 206.24,75.21 206,75.21 201.22,79.99 201.22,80.65 199.48,82.4 199.48,84.52 198.55,85.45 198.55,85.85 196.64,87.76 188.16,87.76 187.75,87.34 185.64,87.34 185.16,87.82 182.39,87.82 180.44,85.87 179.3,85.87 178.72,86.46 174.08,86.46 173.62,86.91 173.62,87.31 173.03,87.89 169.39,87.89 168.92,88.36 168.92,88.62 168.14,89.4 166.64,89.4 166,90.04 164.56,90.04 163.84,89.32 163.48,89.32 162.78,90.02 156.44,90.02 155.98,90.48 150.68,90.48 150.15,89.96 148.82,89.96 148.52,90.25 145.55,90.25 145.52,90.23 143.4,90.23 v1(143.36,90.27)
  IN4 w0.254: v1(250.93,64.9) 250.78,65.05 249.08,65.05 v1(246.86,62.82)
  BOTTOM w0.254: v1(246.86,62.82) 246.61,63.08 245.13,63.08 243.04,65.15 243.04,71.9 243.35,72.22 v1(243.58,72.22)
REM_DIODE1_P: length 132.3
  TOP w0.254: CE24.2 v1(246.85,63.74) 247.29,63.74 v2(247.64,64.09) 248.34,64.79 UE2.A13 ; v1(143.36,89.68) 142.59,89.68 CE35.2 142.21,89.3 QE3.2 140.58,89.3 139.93,89.95 QE3.1
  IN1 w0.254: v1(143.36,89.68) 143.4,89.72 145.31,89.72 145.34,89.75 148.31,89.75 148.61,89.45 150.37,89.45 150.89,89.98 155.77,89.98 156.23,89.51 162.57,89.51 163.27,88.81 164.05,88.81 164.77,89.53 165.79,89.53 166.43,88.89 167.93,88.89 168.41,88.41 168.41,88.15 169.18,87.38 172.82,87.38 173.11,87.1 173.11,86.7 173.87,85.95 178.51,85.95 179.09,85.37 180.65,85.37 182.6,87.31 184.95,87.31 185.43,86.84 187.96,86.84 188.37,87.25 196.43,87.25 198.04,85.64 198.04,85.24 198.97,84.31 198.97,82.19 200.72,80.44 200.72,79.78 205.79,74.7 206.46,74.7 206.84,75.08 217.75,75.08 218.13,75.47 233.76,75.47 234.53,74.7 235.81,74.7 236.58,75.47 238.46,75.47 242.22,71.7 243.52,71.7 v1(243.58,71.64)
  BOTTOM w0.254: v1(246.85,63.74) 246.69,63.58 245.34,63.58 243.55,65.36 243.55,71.6 v1(243.58,71.64)
REM_DIODE2_N: length 81.8
  TOP w0.254: v1(250.42,64.54) 250.42,64.52 250.4,64.54 UE2.B14 ; v1(231.45,54.61) 231.49,54.57 231.49,54.22 231.28,54.01 v2(227.29,54.01) 225.35,54.01 CE37.2 224.13,54.21 QE5.3 ; CE26.1 v1(246.89,60.92)
  IN4 w0.254: v1(250.42,64.54) 249.77,63.9 249.6,63.9 246.89,61.18 v1(246.89,60.92) ; v1(269.39,67.28) 269.47,67.2 269.47,67 267.14,64.68 267.14,63.39 266.58,62.83 266.58,62.58 266.2,62.2 265.58,62.2 264.86,61.48 264.86,58.83 263.95,57.92 262.75,57.92 261.86,58.81 258.62,58.81 257.53,57.72 v1(257.27,57.72)
  BOTTOM w0.254: v1(231.45,54.61) 231.49,54.57 231.49,53.67 232.81,52.36 239.37,52.36 240.36,53.35 240.36,59.61 240.97,60.22 240.97,61.02 241.49,61.54 244.93,61.54 245.35,61.12 246.68,61.12 v1(246.89,60.92) 247.06,61.1 247.3,61.1 247.48,60.91 247.48,60.44 247.11,60.07 247.11,59.2 248.51,57.8 248.51,56.86 249.99,55.38 251.89,55.38 253.08,54.2 255.47,54.2 256.54,55.27 256.54,55.68 257.77,56.91 257.77,57.36 257.41,57.72 v1(257.27,57.72) ; v1(269.39,67.28) CE46.2 269.2,66.39 QE7.2 269.85,64.72 QE7.1
REM_DIODE2_P: length 78.9
  TOP w0.254: CE26.2 v1(246.89,61.83) 247.16,61.83 248.1,62.77 248.1,63.74 248.66,64.29 UE2.A14 ; QE5.1 222.68,53.11 QE5.2 224.13,53.3 CE37.1 225.35,53.5 v2(230.53,53.5) 231.49,53.5 232,54.01 232,54.57 v1(232.04,54.61)
  IN4 w0.254: v1(257.27,57.13) 257.35,57.21 257.74,57.21 258.83,58.3 261.65,58.3 262.54,57.41 264.16,57.41 265.36,58.62 265.36,61.27 265.79,61.69 266.41,61.69 267.09,62.37 267.09,62.62 267.65,63.18 267.65,64.47 269.97,66.79 269.97,67.24 v1(270.01,67.28)
  BOTTOM w0.254: QE7.3 270.5,66.39 CE46.1 270.3,66.99 v1(270.01,67.28) ; v1(257.27,57.13) 256.03,55.89 256.03,55.48 255.25,54.71 253.29,54.71 252.11,55.89 250.2,55.89 249.02,57.07 249.02,58.01 247.62,59.41 247.62,59.86 247.99,60.23 247.99,61.12 247.51,61.6 247.11,61.6 v1(246.89,61.83) 246.68,61.63 245.56,61.63 245.14,62.05 241.28,62.05 240.46,61.23 240.46,60.43 239.85,59.82 239.85,53.56 239.16,52.87 233.02,52.87 232,53.88 232,54.57 v1(232.04,54.61)
REM_DIODE4_N: length 308.7
  TOP w0.254: v1(248.1,59.58) 248.14,59.62 248.14,60.14 CE27.1 248.28,60.46 248.28,61.21 248.92,61.85 UE2.A16 ; QE6.3 109.94,105.63 CE39.1 110.34,106.03 110.34,106.97 109.32,107.98 101.74,107.98 100.15,106.4 100.15,100.13 96.72,96.7 95.84,95.82 95.84,93.96 95.51,93.63 v1(95.24,93.63)
  IN2 w0.254: v1(77.61,49.79) 77.59,49.78 77.59,49.27 78.1,48.76 81.71,48.76 82.21,49.26 87.92,49.26 89.18,50.52 203.86,50.52 204.66,49.72 230.48,49.72 231.09,49.11 232.72,49.11 234.1,47.74 234.1,43.6 234.53,43.16 239.29,43.16 239.99,42.46 239.99,41.53 240.34,41.18 246.49,41.18 247.46,40.22 249.29,40.22 249.39,40.31 251.82,40.31 252.21,40.69 252.21,43.96 251.54,44.63 251.54,49.06 252.42,49.95 252.42,50.85 252.7,51.13 252.7,52.52 252.56,52.66 252.56,54.6 250.54,56.63 249.48,56.63 248.43,57.67 248.43,58.76 248.1,59.09 v1(248.1,59.58)
  IN4 w0.254: v1(95.24,93.63) 95.19,93.68 89.35,93.68 88.72,93.05 82.75,93.05 81.62,91.92 80.46,91.92 78.17,89.63 78.17,83.92 70.9,76.65 70.9,71.15 67.94,68.19 67.94,62.07 73.14,56.88 76.85,56.88 77.27,56.45 77.27,54.98 v1(77.31,54.94)
  BOTTOM w0.254: v1(77.61,49.79) 77.61,50.01 78.19,50.6 78.19,51.83 78.65,52.29 78.65,53.3 77.98,53.97 77.48,53.97 77.28,54.17 77.28,54.91 v1(77.31,54.94)
REM_DIODE4_P: length 314.1
  TOP w0.254: UE2.B17 249.77,62.73 249.43,62.38 249.43,61.64 248.79,61 248.79,60.41 CE27.2 248.65,59.91 248.65,59.62 v1(248.69,59.58) ; v1(95.24,94.22) 95.34,94.32 95.34,96.03 v2(96.16,96.86) 99.64,100.34 99.64,106.61 101.53,108.49 109.53,108.49 110.84,107.18 110.84,106.03 CE39.2 111.05,104.87 QE6.2 111.24,104 110.59,103.35 QE6.1
  IN2 w0.254: v1(248.69,59.58) 248.61,59.5 248.61,59.3 248.94,58.97 248.94,57.88 249.69,57.13 250.75,57.13 253.07,54.81 253.07,52.87 253.21,52.73 253.21,50.92 252.93,50.64 252.93,49.73 252.04,48.85 252.04,44.84 252.71,44.17 252.71,40.48 252.03,39.8 249.6,39.8 249.5,39.71 247.25,39.71 246.28,40.67 240.13,40.67 239.48,41.32 239.48,42.25 239.08,42.66 234.32,42.66 233.59,43.38 233.59,47.52 232.51,48.6 230.88,48.6 230.27,49.21 204.45,49.21 203.65,50.01 89.39,50.01 88.13,48.76 82.42,48.76 81.93,48.26 77.89,48.26 77.09,49.06 77.09,49.78 v1(77.05,49.82)
  IN4 w0.254: v1(76.73,54.94) 76.76,54.98 76.76,56.24 76.63,56.37 72.93,56.37 67.43,61.86 67.43,68.41 70.39,71.36 70.39,76.86 77.66,84.13 77.66,89.84 80.25,92.43 81.41,92.43 82.54,93.56 88.51,93.56 89.14,94.19 95.21,94.19 v1(95.24,94.22)
  BOTTOM w0.254: v1(77.05,49.82) 77.1,49.87 77.1,50.22 77.68,50.81 77.68,52.04 78.14,52.5 78.14,53.09 77.76,53.46 77.27,53.46 76.77,53.96 76.77,54.9 v1(76.73,54.94)
RES_BIAS: length 4
  TOP w0.102: UL1.12 263.73,96.09 263.84,96.2 263.84,97.85 263.88,97.89 RL13.1 v2(262.96,98.51)
RESET_OUT#: length 205.9
  TOP w0.102: v1(187.75,110.54) 187.27,111.02 v2(185.68,111.02) 180.26,111.02 179.93,110.69 179.93,109.63 175.02,104.72 172.16,104.72 v1(171.66,104.22) ; v1(258.96,73.82) 258.39,73.82 258.04,74.18 RE56.2 ; v1(128.29,127.69) 128.69,128.09 RC129.1 ; UE2.B39 257.88,65.04 257.75,64.91 v1(257.75,64.54)
  IN1 w0.084: v1(258.96,73.82) 258.96,73.82 257.91,72.77 253.73,72.77 252.83,73.67 249.4,73.67 248.96,73.22 248.96,73.11 248.46,72.61 248.11,72.61 247.3,73.42 246.2,73.42 244.93,74.69 244.93,80.7 244.99,80.76 244.99,83.17 247.92,86.1 247.92,87.64 248.48,88.2 248.48,95.36 242.26,101.59 229.83,101.59 229.54,101.88 227.5,101.88 226.98,102.4 214.26,102.4 213.65,103.01 209.49,103.01 204.64,107.86 192.02,107.86 189.34,110.54 v1(187.75,110.54) ; v1(158.24,123.81) 158.06,123.63 158.06,121.88 159.1,120.83 159.1,119.67 159.58,119.19 159.58,115.98 163.89,111.67 166.55,111.67 168.11,110.1 169.48,110.1 171.18,108.4 171.18,104.71 v1(171.66,104.22)
  IN2 w0.122: v1(257.75,64.54) 257.25,65.04 257.25,69.73 257.48,69.96 258.55,69.96 259.03,70.44 259.03,73.76 v1(258.96,73.82)
  IN4 w0.084: v1(158.24,123.81) 155.86,126.19 148.81,126.19 145.6,122.97 144.53,122.97 144.08,122.52 139.1,122.52 138.12,121.53 136.96,121.53 132.37,126.13 129.86,126.13 v1(128.29,127.69)
  BOTTOM w0.076: v1(171.66,104.22) 171.49,104.05 171.49,102.5 UC1.B6
RESET_OUT#_R: length 9.1
  TOP w0.102: RC128.2 126.73,126.93 v2(126.43,127.24) 126.43,128.48 126.72,128.77 CC33.1 128.82,128.77 v1(128.89,128.85) 129.04,129 RC129.2
  BOTTOM w0.102: v1(128.89,128.85) 129.89,127.85 JXDP1.47
RING2: length 17.7
  TOP w0.102: v2(282.28,51.32) 282.61,51.65 v1(282.84,51.65)
  IN1 w1.27: 283.84,52.09 284.33,52.09 290.13,57.9 292,57.9 295.12,61.02 295.12,63.03
  vias: v1(282.84,52.21) v1(293.34,68.74) v1(293.72,68.28) v1(295.37,64.3) v1(295.76,64.74)
RING2_R: length 1.2
  TOP w0.102: v2(284.76,50.07) 284.4,50.43 CA4.1
  vias: v1(287.94,48.8) v1(288.52,48.8)
RJ45_MDIN0: length 9.4
  IN4 w0.241: JLOM1.2 272.11,128.33 271.75,127.97 270.11,127.97 267.62,125.48 267.62,125.11 v1(267.73,125)
  BOTTOM w0.279: TL1.14 268.28,124.23 268.13,124.38 267.8,124.38 267.64,124.54 267.64,124.91 v1(267.73,125)
RJ45_MDIN1: length 7
  IN2 w0.241: JLOM1.6 276.24,128.33 274.88,126.97 274.88,126.42 275.47,125.83 275.47,125.06 v1(275.57,124.96)
  BOTTOM w0.279: TL1.20 275.9,124.22 275.49,124.63 275.49,124.87 v1(275.57,124.96)
RJ45_MDIN2: length 8.1
  IN4 w0.241: JLOM1.5 275.96,127.1 275.16,126.3 273.9,126.3 273.45,125.85 v1(273.45,124.91)
  BOTTOM w0.279: TL1.18 273.36,124.82 v1(273.45,124.91)
RJ45_MDIN3: length 7
  IN4 w0.241: JLOM1.8 278.37,127.68 278.37,127.11 279.99,125.48 279.99,125.08 280.21,124.86 v1(280.21,124.81)
  BOTTOM w0.279: v1(280.21,124.81) 280.12,124.72 280.12,124.46 280.25,124.33 280.85,124.33 280.98,124.19 TL1.24
RJ45_MDIP0: length 9.4
  IN4 w0.241: v1(267.14,125) 267.25,125.11 267.25,125.63 269.96,128.34 271.6,128.34 271.88,128.62 JLOM1.1
  BOTTOM w0.279: TL1.13 267.01,124.28 267.23,124.49 267.23,124.91 v1(267.14,125)
RJ45_MDIP1: length 7.1
  IN2 w0.241: v1(274.99,124.96) 275.09,125.06 275.09,125.67 274.5,126.27 274.5,127.5 273.92,128.08 JLOM1.3
  BOTTOM w0.279: v1(274.99,124.96) 275.08,124.87 275.08,124.66 274.63,124.22 TL1.19
RJ45_MDIP2: length 8.1
  IN4 w0.241: v1(272.87,124.91) 272.87,124.96 273.09,125.18 273.09,126.01 273.75,126.67 275,126.67 275.59,127.25 275.59,127.68 JLOM1.4
  BOTTOM w0.279: v1(272.87,124.91) 272.96,124.82 272.96,124.58 272.82,124.44 272.23,124.44 272.09,124.3 TL1.17
RJ45_MDIP3: length 7
  IN4 w0.241: v1(279.63,124.81) 279.63,125.33 278,126.96 JLOM1.7
  BOTTOM w0.279: v1(279.63,124.81) 279.71,124.72 TL1.23
RUN_ON: length 303.2
  TOP w0.102: v1(199.37,98.54) 195.98,98.54 195.31,97.86 195.31,95.31 195.47,95.15 195.69,95.15 196.14,94.7 196.14,90.47 196.92,89.68 197.91,89.68 198.14,89.91 199.41,89.91 201.18,88.13 201.64,88.13 203.11,86.66 203.11,76.23 204.09,75.26 204.09,72.59 205.63,71.04 v1(206.86,71.04) ; QE2.2 249.72,56.18 250.2,56.66 RE292.2 251.19,56.43 RE280.2 ; RPE10.1 263.26,63.43 263.7,63.88 264.54,63.88 v1(264.77,64.11) ; RE280.2 250.99,55.37 251.83,55.37 251.96,55.5 UE5.4 ; RE280.2 250.34,55.8 249.4,54.86 v1(249.4,54.31) ; v1(243.11,43.91) 242.95,44.08 PR402.1 ; v1(249.39,46.59) 248.97,47.01 UZ3.3 ; v1(87.35,118.8) 87.68,118.47 87.68,118.07 88.41,117.34 v2(90.07,117.34) 91.38,117.34 94.61,114.11 v1(94.61,112.43)
  IN1 w0.102: v1(264.77,64.11) 263.82,64.11 263.3,64.63 260.65,64.63 260.12,65.16 256.9,65.16 256.07,64.32 250.84,64.32 250.68,64.16 247.08,64.16 245,66.24 v1(240.52,66.24) 240.15,66.61 238.29,66.61 238.04,66.86 235.49,66.86 235.04,66.41 230.78,66.41 230.23,65.86 226.9,65.86 225.54,67.22 218.56,67.22 217.92,66.58 216.73,66.58 215.88,67.43 208.05,67.43 206.86,68.63 v1(206.86,71.04) ; v1(243.11,43.91) 247.43,43.91 248.93,45.42 248.93,46.14 v1(249.39,46.59)
  IN2 w0.102: v1(241.06,54.58) 241.22,54.75 241.22,55.96 239.64,57.55 239.64,60.69 240.23,61.28 240.23,63.88 240.06,64.05 240.06,65.77 v1(240.52,66.24)
  IN3 w0.102: v1(199.37,98.54) 197.79,98.54 197.37,98.95 197.37,99.76 195.95,101.18 195.95,109.69 193.89,111.75 193.89,117.86 193.49,118.26 193.08,118.26 192.44,117.61 183.64,117.61 182.79,118.46 177.24,118.46 175.68,116.9 170.97,116.9 165.67,122.2 162.91,122.2 161.94,121.22 158.87,121.22 155.54,124.55 136.89,124.55 135.07,122.73 133.82,122.73 131.87,120.77 122,120.77 116.98,115.76 113.64,115.76 113.04,115.16 107.5,115.16 106.46,114.12 102.44,114.12 101.38,115.17 100.39,115.17 97.79,112.57 95.72,112.57 95.3,112.15 94.89,112.15 v1(94.61,112.43)
  IN4 w0.102: v1(243.11,43.91) 242.63,44.4 v1(240.73,44.4) ; v1(249.4,54.31) 249.09,54.62 248.35,54.62 247.33,53.6 242.04,53.6 v1(241.06,54.58)
  BOTTOM w0.102: UZ4.3 v1(87.35,118.8) ; v1(241.06,54.58) 241.06,53.36 241.58,52.84 241.58,49.07 241.1,48.59 241.1,44.77 v1(240.73,44.4)
RUN_ON#: length 4.9
  TOP w0.102: QE2.6 247.89,55.53 247.98,55.62 247.98,56.07 247.86,56.18 QE2.5 247.33,56.18 246.86,56.65 246.86,57.03 246.63,57.26 v2(246.63,57.68) 246.75,57.79 247.93,57.79 RE68.2
RUN_ON_EC: length 59
  TOP w0.102: v1(251,66.54) 250.51,67.04 UE2.B9 ; RE292.1 252.59,56.18 253.16,56.18 253.58,55.76 253.58,55.39 254.12,54.85 UE5.2 255.09,54.85 255.36,54.58 255.36,53.45 255.14,53.23 255.14,49.88 256.02,49.01 258.73,49.01 258.94,49.21 261.97,49.21 262.18,49.01 263.88,49.01 264.92,50.05 v2(265.49,50.05) v1(266.05,50.05)
  IN1 w0.102: v1(251,66.54) 251.53,66.54 252.53,67.54 256.9,67.54 257.16,67.28 260.72,67.28 261.05,66.96 262.95,66.96 263.22,66.69 264.95,66.69 266.11,67.85 267.19,67.85 v1(267.45,67.6)
  IN2 w0.102: v1(267.45,67.6) 267.45,66.45 267.27,66.27 267.27,60.63 268.05,59.84 268.05,57.13 267.38,56.45 267.38,55.52 266.29,54.42 266.29,50.29 v1(266.05,50.05)
RUNPWROK: length 268.7
  TOP w0.102: v1(144.15,118.8) 144.15,119.03 v2(143.09,120.08) 142.97,120.2 140.65,120.2 v1(139.96,119.52) ; v1(250.34,57.67) 250.34,58.09 250.11,58.31 249.27,58.31 RE67.2 248.83,57.87 248.83,56.98 248.98,56.83 QE2.3 ; UE2.B26 v1(254.37,63.08) ; UE1.A4 239.11,64.73 239.41,65.02 v1(239.41,65.27)
  IN1 w0.102: v1(239.41,65.27) 239.98,65.85 244.08,65.85 246.57,63.36 250.16,63.36 250.92,64.12 253.51,64.12 253.86,63.78 253.86,63.59 v1(254.37,63.08)
  IN2 w0.102: v1(262.53,73.64) 262.53,75.62 263.18,76.27 263.43,76.27 263.73,76.56 263.73,80.5 264.38,81.15 264.38,82.26 263.73,82.91 263.73,94.4 265.28,95.94 265.28,102.09 269.15,105.96 269.15,107.13 268.01,108.28 268.01,108.63 268.82,109.44 268.82,111.79 267.48,113.13 266.01,113.13 v1(264.84,114.3) ; v1(146.59,119.77) 146.2,119.38 144.73,119.38 v1(144.15,118.8)
  IN4 w0.102: v1(262.53,73.64) 262.95,73.22 262.95,69.18 262.49,68.72 262.49,68.19 262.26,67.96 261.63,67.96 261.41,67.75 261.41,67.31 261.6,67.12 262.44,67.12 262.81,66.74 262.81,64.46 262.38,64.03 260.55,64.03 258.81,62.29 254.97,62.29 254.37,62.88 v1(254.37,63.08) ; v1(264.84,114.3) 260.76,114.3 258.46,116.6 258.46,124.95 252.43,130.98 244.95,130.98 244.25,130.29 225.02,130.29 223.4,128.67 210.59,128.67 207.15,125.23 205.09,125.23 203.1,123.24 201.84,123.24 201.2,122.6 194.2,122.6 191.7,125.09 182.56,125.09 181.39,123.92 179.95,123.92 179.61,123.58 174.97,123.58 174.77,123.77 174.77,124.88 174.61,125.04 162.66,125.04 160.02,122.4 159.32,122.4 159.04,122.12 158.08,122.12 155.18,125.03 149.28,125.03 146.59,122.34 v1(146.59,119.77)
  BOTTOM w0.102: UC8.1 141.76,117.72 142.02,117.46 142.02,116.1 142.43,115.69 144.63,115.69 145.15,116.21 145.65,116.21 146.77,117.34 146.77,119.59 v1(146.59,119.77) 146.59,120 146.3,120.3 UC8.10 ; v1(139.96,119.52) 140.24,119.8 UC8.4 ; UC8.13 v1(144.15,118.8) ; v1(250.34,57.67) 251.46,58.78 255.51,58.78 256.14,59.42 256.14,60.94 254.37,62.71 v1(254.37,63.08)
S5_1.2V: length 5.2
  TOP w0.254: v1(76.3,78.84) 76.05,78.58 PC214.1
  BOTTOM w0.102: PR208.2 77.49,79.89 77.49,81.3 v2(77.56,81.36)
  BOTTOM w0.203: PR208.2 77.06,79.19 76.71,78.84 v1(76.3,78.84) 76.07,78.61 PU201.8
SA_SNUB:
  vias: v2(134.63,117.01)
SA_SW: length 6.4
  TOP w0.102: v1(131.54,114.02) 131.56,114.02 132.03,113.55 v2(132.03,113.5)
  BOTTOM w0.254: PR624.1 135.34,116.53 135.34,116.12 135.16,115.95 135.16,114.23 134.76,113.83 PL601.1
SATA_LED: length 5.8
  TOP w0.102: v1(287.11,20.12) 286.8,19.81 v2(286.56,19.81) 284.54,19.81 QZ4.3
  BOTTOM w0.102: JLED1.3 288.07,19.15 v1(287.11,20.12)
SATA_LED#: length 3.4
  TOP w0.102: QZ3.6 282.48,18.21 283.03,17.66 v2(283.7,17.66) 283.84,17.66 284.24,18.06 QZ4.2
SATA_PRX_C_DTX_N1: length 6.3
  TOP w0.094: C313.2 149,136.71 149,137.92 148.84,138.07 148.84,138.12 148.43,138.54 148.38,138.54 148.34,138.58 148.34,140.03 v4(148.59,140.28)
  BOTTOM w0.094: JDOCK1.56 148.5,139.4 148.34,139.56 148.34,140.03 v4(148.59,140.28)
SATA_PRX_C_DTX_P1: length 6.3
  TOP w0.094: v4(147.91,140.28) 148.16,140.03 148.16,138.5 v5(148.48,138.18) 148.82,137.84 148.82,136.76 C312.2
  BOTTOM w0.094: v4(147.91,140.28) 148.16,140.03 148.16,139.6 148,139.44 JDOCK1.54
SATA_PRX_DTX_N1: length 48.8
  TOP w0.094: C313.1 148.87,135.01 148.87,134.62 148.96,134.53 149.11,134.53 v4(149.3,134.71)
  IN2 w0.122: v4(149.3,134.71) 149.56,134.71 149.75,134.9 149.75,135.36 150.3,135.91 151.27,135.91 151.85,135.33 151.85,132.04 151.23,131.42 150.17,131.42 150.05,131.3 150.05,128.61 150.95,127.71 151.58,127.71 158.07,121.21 158.07,118.58 159.33,117.32 159.33,113.97 162.42,110.88 162.42,100.13 v1(161.76,99.47)
  BOTTOM w0.076: v1(161.76,99.47) 161.99,99.47 UC1.G21
SATA_PRX_DTX_P1: length 48.7
  TOP w0.094: C312.1 148.68,135.23 148.68,134.55 148.88,134.34 149.08,134.34 149.3,134.12 v4(149.3,134.03)
  IN2 w0.122: v1(161.76,100.1) 161.76,100.1 162.08,100.1 162.2,100.22 162.2,110.79 159.12,113.88 159.12,117.23 157.85,118.49 157.85,121.12 151.49,127.49 150.86,127.49 149.83,128.52 149.83,131.39 150.08,131.64 151.15,131.64 151.64,132.13 151.64,135.24 151.18,135.7 150.39,135.7 149.96,135.27 149.96,134.81 149.72,134.57 149.72,134.55 149.71,134.54 149.71,134.43 v4(149.3,134.03)
  BOTTOM w0.076: v1(161.76,100.1) 161.76,99.91 161.83,99.83 161.92,99.83 162.06,99.69 162.2,99.69 162.27,99.76 UC1.F21
SATA_PTX_C_DRX_N1: length 6.4
  TOP w0.094: C315.1 150.75,136.73 150.75,137.49 150.42,137.82 150.42,137.87 150.01,138.29 149.96,138.29 149.84,138.4 149.84,140.03 v4(150.09,140.28)
  BOTTOM w0.094: JDOCK1.62 150,139.4 149.84,139.56 149.84,140.03 v4(150.09,140.28)
SATA_PTX_C_DRX_P1: length 6.4
  TOP w0.094: C314.1 150.47,136.64 150.47,136.65 150.57,136.74 150.57,137.42 v5(150.06,137.93) 149.66,138.33 149.66,140.03 v4(149.41,140.28)
  BOTTOM w0.094: JDOCK1.60 149.5,139.44 149.66,139.6 149.66,140.03 v4(149.41,140.28)
SATA_PTX_DRX_N1: length 46.8
  TOP w0.094: v4(150.4,134.03) 150.77,134.39 150.79,134.39 151.03,134.63 151.03,135.39 C315.2
  IN2 w0.122: v4(150.4,134.03) 150.4,134.08 150.67,134.35 150.76,134.35 150.89,134.22 150.89,133.45 149.7,132.26 148.34,132.26 148.09,132.02 148.09,131.47 148.34,131.22 148.99,131.22 149.11,131.1 149.11,130.74 148.99,130.61 148.34,130.61 148.09,130.37 148.09,128.8 150.06,126.83 151.24,126.83 157.21,120.86 157.21,118.22 158.46,116.98 158.46,112.91 161.15,110.22 161.15,107.46 160.55,106.87 160.55,106.21 160.8,105.95 161.08,105.95 v4(161.33,105.7)
  BOTTOM w0.076: v4(161.33,105.7) 161.33,105.8 161.52,105.99 161.64,105.99 161.78,105.84 161.78,103.72 161.56,103.49 161.56,103.07 161.59,102.98 161.59,102.79 161.56,102.69 161.56,102.45 161.57,102.4 161.61,102.25 161.64,102.17 161.7,101.97 161.7,101.85 161.77,101.59 UC1.D21
SATA_PTX_DRX_P1: length 47
  TOP w0.094: v4(150.4,134.71) 150.54,134.58 150.72,134.58 150.84,134.7 150.84,134.98 150.35,135.47 C314.2
  IN2 w0.122: v4(161.33,106.47) 161.03,106.17 160.89,106.17 160.77,106.29 160.77,106.78 161.36,107.37 161.36,110.31 158.67,113 158.67,117.07 157.43,118.31 157.43,120.95 151.33,127.05 150.15,127.05 148.31,128.89 148.31,130.28 148.43,130.4 149.08,130.4 149.32,130.65 149.32,131.19 149.08,131.44 148.43,131.44 148.31,131.56 148.31,131.93 148.43,132.05 149.79,132.05 151.1,133.36 151.1,134.31 150.85,134.57 150.55,134.57 v4(150.4,134.71)
  BOTTOM w0.076: v4(161.33,106.47) 161.33,106.25 161.43,106.15 161.71,106.15 161.95,105.91 161.95,103.65 161.72,103.42 161.72,103.1 161.76,103.03 161.76,102.76 161.72,102.65 161.72,102.47 161.8,102.22 162.1,102.22 162.29,102.03 162.29,101.91 162.23,101.85 162.05,101.85 UC1.C21
SATAGP0: length 6.7
  BOTTOM w0.076: RPC4.3 177.56,101.93 177.34,102.15 176.84,102.15 176.65,101.96 176.65,101.56 175.93,100.83 175.93,100.25 174.98,99.3 173.36,99.3 UC1.H2
SATAGP1: length 6.5
  BOTTOM w0.076: UC1.H3 172.76,98.72 174.93,98.72 175.9,99.7 v2(176.25,99.7) 176.26,99.7 177.49,100.94 RPC4.1
SD/MMCCD#: length 28.3
  TOP w0.102: UR2.30 267.72,83.11 267.4,83.43 267.4,84.57 267.05,84.91 v1(267.05,85.28)
  BOTTOM w0.102: v1(267.05,85.28) 267.27,85.28 268.58,83.97 268.58,83.05 267.05,81.53 267.05,78.88 266.35,78.18 266.35,70.14 266.61,69.88 267.86,69.88 269.08,68.66 270.51,68.66 272.17,67 JSD1.18
SD/MMCCLK: length 2.7
  TOP w0.102: UR2.17 270.37,78.59 270.84,78.13 271.98,78.13 RR1.1
SD/MMCCLK_R: length 16.6
  TOP w0.102: RR1.2 CR23.1 273.16,77.11 272.88,76.83 v1(272.39,76.83)
  IN1 w0.084: v1(272.39,76.83) 272.63,76.58 272.63,71.9 272.72,71.82 273.23,71.82 273.31,71.73 273.31,71.57 273.23,71.48 272.72,71.48 272.63,71.4 272.63,71.23 272.72,71.15 273.23,71.15 273.31,71.06 273.31,70.9 273.23,70.81 272.72,70.81 272.63,70.73 272.63,70.56 272.72,70.48 273.23,70.48 273.31,70.39 273.31,70.23 273.23,70.14 272.72,70.14 272.63,70.06 272.63,69.89 272.72,69.81 273.23,69.81 273.31,69.72 273.31,69.56 273.23,69.47 272.72,69.47 272.63,69.39 272.63,68.62 v1(272.41,68.4)
  BOTTOM w0.102: JSD1.5 v1(272.41,68.4)
SD/MMCCMD: length 2.2
  TOP w0.102: RR23.1 271.58,79.95 UR2.19
SD/MMCCMD_R: length 17.1
  TOP w0.102: v1(271.51,78.59) 271.76,78.84 272.72,78.84 RR23.2
  IN1 w0.084: v1(274.8,74.1) 274.5,74.1 274.43,74.16 274.43,74.63 274.52,74.71 275.85,74.71 275.93,74.8 275.93,74.96 275.85,75.05 274.52,75.05 274.43,75.13 274.43,77.46 273.3,78.59 272.51,78.59 272.42,78.67 272.42,80.66 272.34,80.74 272.17,80.74 272.09,80.66 272.09,78.67 272.01,78.59 v1(271.51,78.59)
  BOTTOM w0.102: JSD1.2 v1(274.8,74.1)
SD/MMCDAT0/RCLK+: length 3.9
  TOP w0.089: UR2.16 269.72,78.07 269.68,78.03 269.68,77.96 269.88,77.75 270.49,77.75 271.25,77 271.56,77 271.84,76.72 271.84,76.47 RR22.1
SD/MMCDAT0/RCLK+_R: length 15.4
  TOP w0.089: v1(271.98,74.26) 271.85,74.39 271.85,74.98 RR22.2
  IN1 w0.084: v1(271.98,74.26) 271.78,74.05 271.78,73.76 272.03,73.5 272.03,70.7 271.12,69.79 271.12,68.79 272.35,67.55 272.35,65.94 271.97,65.56 271.97,63.71 272.09,63.59 v1(272.13,63.59)
  BOTTOM w0.089: v1(272.13,63.59) 272.33,63.39 272.49,63.39 272.59,63.5 272.59,64.12 272.67,64.2 JSD1.7
SD/MMCDAT1/RCLK-: length 3.9
  TOP w0.089: UR2.15 269.32,78.07 269.36,78.03 269.36,77.82 269.75,77.44 v5(270.14,77.44) 270.36,77.44 271.12,76.68 271.43,76.68 271.53,76.58 271.53,76.47 RR21.1
SD/MMCDAT1/RCLK-_R: length 15.4
  TOP w0.089: RR21.2 271.53,74.98 271.53,74.39 v1(271.4,74.26)
  IN1 w0.084: v1(271.4,74.26) 271.4,73.6 271.65,73.35 271.65,70.86 270.74,69.95 270.74,68.63 271.97,67.4 271.97,66.1 271.59,65.72 271.59,63.55 v1(272.13,63)
  BOTTOM w0.089: v1(272.13,63) 272.2,63.08 272.4,63.08 272.68,62.8 JSD1.8
SD/MMCDAT2: length 2.7
  TOP w0.102: RR18.1 271.94,80.7 271.14,80.7 271.09,80.75 UR2.21
SD/MMCDAT2_R: length 18.5
  TOP w0.102: RR18.2 272.98,82.1 272.68,82.1 v1(271.94,82.84)
  IN1 w0.084: v1(271.94,82.84) 271.94,81.33 272.04,81.23 272.25,81.23 272.33,81.31 272.33,82.07 272.42,82.15 272.59,82.15 272.67,82.07 272.67,81.31 272.75,81.23 275.11,81.23 275.21,81.12 275.21,80.94 275.13,80.86 274.72,80.86 274.63,80.77 274.63,80.61 274.72,80.52 275.13,80.52 275.21,80.44 275.21,80.27 275.13,80.19 274.72,80.19 274.63,80.1 274.63,79.94 274.72,79.85 275.13,79.85 275.21,79.77 275.21,79.6 275.13,79.52 274.72,79.52 274.63,79.43 274.63,79.27 274.72,79.18 275.13,79.18 275.21,79.1 275.21,78.93 275.13,78.85 274.72,78.85 274.63,78.76 274.63,78.59 274.72,78.51 275.13,78.51 275.21,78.43 v1(275.21,76.9)
  BOTTOM w0.102: JSD1.9 275.21,76.9 v1(275.21,76.9)
SD/MMCDAT3: length 1.9
  TOP w0.102: RR17.1 272.12,80.3 271.18,80.3 271.13,80.35 UR2.20
SD/MMCDAT3_R: length 17.3
  TOP w0.102: RR17.2 273.16,80.48 v1(272.83,80.81)
  IN1 w0.084: v1(272.83,80.81) 272.83,79.1 272.93,79 273.16,79 273.24,79.09 273.24,80.68 273.34,80.78 273.48,80.78 273.57,80.68 273.57,79.09 273.66,79 273.83,79 273.91,79.09 273.91,80.64 274.01,80.74 274.15,80.74 274.25,80.64 274.25,78.22 274.35,78.11 274.72,78.11 274.82,78.01 274.82,76.57 274.91,76.48 275.61,76.48 275.69,76.4 275.69,76.23 275.61,76.15 274.91,76.15 274.82,76.07 v1(274.82,75.5)
  BOTTOM w0.102: JSD1.1 v1(274.82,75.5)
SD_GPIO: length 2.5
  TOP w0.102: UR2.28 268.52,83.08 268.26,83.35 268.26,84.95 RR16.2
SD_RCOMP: length 1.2
  TOP w0.381: v1(170.57,92.62) 170.08,92.62 RC96.1
  BOTTOM w0.254: v1(170.57,92.62) UC1.AB7
SD_UHS2_D0N: length 35.2
  TOP w0.089: UR2.25 269.72,83.08 269.68,83.12 269.68,83.73 v1(269.82,83.87)
  IN4 w0.084: v1(298.49,86.15) 298.4,86.05 298.4,85.59 298.06,85.25 296.58,85.25 295.02,86.81 290.5,86.81 288.48,84.79 284.68,84.79 283.98,85.49 281.2,85.49 280.57,84.86 270.15,84.86 269.71,84.42 269.71,83.97 v1(269.82,83.87)
  BOTTOM w0.089: v1(298.49,86.15) 298.36,86.02 298.36,85.84 298.75,85.44 JSD1.12
SD_UHS2_D0P: length 35.2
  TOP w0.089: v1(269.23,83.87) 269.36,83.74 269.36,83.12 269.32,83.08 UR2.26
  IN4 w0.084: v1(269.23,83.87) 269.33,83.97 269.33,84.58 270,85.24 280.41,85.24 281.04,85.87 284.14,85.87 284.84,85.17 288.33,85.17 290.34,87.19 295.17,87.19 296.73,85.63 297.9,85.63 298.02,85.75 298.02,86.04 v1(297.91,86.15)
  BOTTOM w0.089: v1(297.91,86.15) 298.04,86.02 298.04,85.82 297.65,85.43 JSD1.11
SD_UHS2_D1N: length 64.3
  TOP w0.089: v1(271.54,81.73) 271.44,81.63 271.07,81.63 270.99,81.55 270.86,81.55 270.86,81.55 UR2.23
  IN4 w0.084: v1(298.75,54.44) 298.75,56.85 303.38,61.47 303.38,77.28 294.58,86.08 290.61,86.08 286.23,81.7 271.58,81.7 v1(271.54,81.73)
  BOTTOM w0.089: JSD1.15 298.75,54.45 v1(298.75,54.44)
SD_UHS2_D1P: length 64.3
  TOP w0.089: UR2.22 270.89,81.15 270.97,81.23 271.12,81.23 271.2,81.31 271.38,81.31 271.5,81.19 271.5,81.19 v1(271.54,81.15)
  IN4 w0.084: v1(298.16,54.44) 298.37,54.64 298.37,57 302.99,61.63 302.99,77.12 294.42,85.7 290.77,85.7 286.39,81.31 271.71,81.31 v1(271.54,81.15)
  BOTTOM w0.089: v1(298.16,54.44) 297.8,54.44 297.65,54.59 JSD1.16
SDWP: length 27.5
  TOP w0.102: v1(267.83,83.7) 267.83,83.33 268.12,83.04 UR2.29
  BOTTOM w0.102: v1(267.83,83.7) 267.83,83.16 266.51,81.83 266.51,79.12 265.91,78.52 265.91,66.89 267.97,64.83 268.5,64.83 268.87,64.46 268.87,63.24 269.4,62.71 270.67,62.71 270.92,62.46 QR1.1
SDWP_Q: length 9.4
  TOP w0.102: v1(272.09,61.3) v2(272.69,61.3)
  BOTTOM w0.102: QR1.3 269.58,62.03 269.78,61.82 269.78,59.44 270.08,59.15 271.24,59.15 271.94,59.85 271.94,61.15 v1(272.09,61.3) 272.2,61.4 JSD1.19
SIM_DET: length 30.7
  TOP w0.102: RI31.2 287.14,123.49 v1(287.14,123.82) 287.14,124.53 v3(287.56,124.95)
  IN1 w0.102: v1(276.26,108.42) 277.3,109.46 282.14,109.46 283.86,111.17 283.86,118.79 287.14,122.08 v1(287.14,123.82)
  BOTTOM w0.102: v1(276.26,108.42) 276.26,107.31 273.8,104.85 JNGFF2.58
SIM_DET_R: length 3
  TOP w0.102: v3(285.71,124.7) 285.71,124 v1(285.72,123.99) 285.8,123.91 RI31.1
  BOTTOM w0.102: v1(285.72,123.99) 285.72,124.04 JSIM1.9
SIO_EXT_SCI#: length 172.3
  TOP w0.102: RC237.1 174.95,99.94 v2(174.95,100.4) v1(174.95,100.99) ; v1(260.44,60.27) 260.44,63.03 260.17,63.29 UE2.A33
  IN2 w0.102: v1(208.32,71.03) 208.7,70.65 208.7,70.01 208.46,69.76 208.46,69.16 208.24,68.95 191.84,68.95 189.43,71.36 189.43,75.31 v1(190.29,76.17) 190.29,76.95 187.14,80.1 187.14,82.88 184.86,85.15 182.36,85.15 178.26,81.06 173.02,81.06 172.11,81.96 170.36,81.96 169.58,82.74 169.58,84.73 v1(170.04,85.19)
  IN3 w0.102: v1(174.95,100.99) 175.2,100.74 177.63,100.74 177.9,101.01 181.35,101.01 181.98,100.38 188.9,100.38 189.62,99.65 192.59,99.65 196.34,95.9 196.34,94.68 195.41,93.75 195.41,90.58 195.64,90.34 195.64,87.73 192.38,84.46 192.38,82.25 191.32,81.2 191.32,77.2 v1(190.29,76.17) ; v1(208.32,71.03) 208.36,71.03 211.13,68.26 213.47,68.26 215.76,65.97 217.48,65.97 218.17,65.29 222.09,65.29 223.8,63.57 228.23,63.57 229.21,62.59 231.66,62.59 232.57,61.68 237.13,61.68 240.88,57.93 242.52,57.93 242.8,57.65 243.57,57.65 245.36,59.44 247.71,59.44 248.47,58.67 248.83,58.67 249.45,58.05 251.9,58.05 252.65,57.3 255.42,57.3 258.04,59.91 260.08,59.91 v1(260.44,60.27)
  BOTTOM w0.076: v1(170.04,85.19) 170.08,85.23 170.08,85.88 UC1.AN7

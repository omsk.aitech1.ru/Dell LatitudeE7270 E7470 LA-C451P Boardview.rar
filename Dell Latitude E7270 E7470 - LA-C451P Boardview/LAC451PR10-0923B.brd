# Allegro board LAC451PR10-0923B.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
+3.3V_RUN_AUDIO: length 78.1
  TOP w0.203: UA1.3 284.94,71.44 284.3,72.08 v1(284.3,72.27) ; 284.27,68.1 285.2,69.04 UA1.9
  TOP w0.381: v1(284.3,72.27) 284.4,72.37 CA11.1
  TOP w0.508: 275.37,64.11 274.33,63.06 274.33,60.26 275.08,59.51 275.08,57.35 275.94,56.49 275.94,55.08 275.41,54.54 275.41,53.81 RA26.1 274.74,53.5 274.47,53.23 274.47,51.14 274.97,50.64 278.97,50.64 280.68,52.36 RA45.2 ; RA38.2 RA29.1 281.07,53.22 RA45.2 ; RA45.2 281.07,43.72 v3(283.08,41.72) 284.07,40.72 RA1.1 ; RA4.1 294.23,80.36 v1(294.23,84.74) ; RA18.1 282.86,74.96 282.27,75.56 v1(282.27,75.98)
  IN4 w0.508: v1(281.62,66.15) 284.3,68.83 v1(284.3,72.27) 282.27,74.3 v1(282.27,75.98) 283.46,75.98 284.43,76.95 284.43,78.14 290.71,84.43 292.57,84.43 293.02,84.88 294.09,84.88 v1(294.23,84.74)
+3.3V_RUN_AUDIO_UZ5: length 0.7
  TOP w0.102: 279.3,66.54 v2(280.02,66.54)
+3.3V_RUN_CARD: length 4.7
  TOP w0.102: v3(271.78,71.34) 271.55,71.12 v1(270.8,71.12) ; v1(270.8,71.12) 270.8,70.62 v3(270.39,70.21) ; v1(270.8,71.12) 270.8,71.4 v3(270.14,72.06)
  TOP w0.203: v1(267.79,77.34) 268.12,77.67 UR2.12
+3.3V_RUN_DIMM1: length 2.5
  TOP w0.102: v2(150.45,50.69) 150.44,50.68 CD31.1
  BOTTOM w0.305: v1(148.69,51.33) 148.87,51.14 JDIMM1.255
+3.3V_RUN_DIMM2: length 1.4
  BOTTOM w0.305: JDIMM2.255 v1(229.48,48.44)
  vias: v1(230.03,48.55) v2(230.18,49.12)
+3.3V_RUN_VDDA: length 4.4
  TOP w0.203: UV8.H5 v1(218.24,114.82) ; v1(219.54,116.12) 219.21,116.44 UV8.K7 ; UV8.K6 219.21,115.79 v1(219.54,115.47) ; UV8.J4 v1(218.89,114.17)
  TOP w0.254: UV8.H12 v1(217.59,119.37) ; UV8.C10 214.66,118.39 v1(214.34,118.72)
  BOTTOM w0.381: CV100.1 217.59,119.76 v1(217.59,119.37) ; CV98.1 213.48,118.72 v1(214.34,118.72)
  vias: v2(220.05,117.88)
+3.3V_RUN_VDDIO: length 6.4
  TOP w0.203: v1(219.54,120.02) 219.21,119.69 UV8.K12 ; UV8.C12 214.66,119.69 v1(214.34,120.02) ; UV8.K3 219.21,113.85 v1(219.54,114.17) UV8.K4
  TOP w0.254: UV8.C11 214.66,119.04 v1(214.34,119.37) ; UV8.C3 214.66,113.85 v1(214.34,114.17) UV8.C4 ; v1(219.54,119.37) 219.21,119.04 UV8.K11 ; UV8.B6 214.01,115.79 v1(214.34,115.47) 214.01,115.15 UV8.B5
  BOTTOM w0.381: CV97.1 214.16,114.35 v1(214.34,114.17)
  BOTTOM w0.508: CV96.1 213.66,119.6 213.9,119.37 v1(214.34,119.37)
  vias: v2(220.57,121.19)
+3.3V_RUN_VMM: length 49.9
  TOP w0.508: v1(213.64,122.63) 213.27,123 RV518.1 ; v1(206.09,120.33) 206.09,120.72 v3(206.95,121.58) 207.78,122.41 RV85.2 ; v1(219.94,124.13) 219.66,123.85 RV82.2 ; v1(224.81,112) 224.38,112.43 RV88.1
  IN2 w0.508: v1(206.09,120.33) 206.09,120.11 207.44,118.77 207.44,117.85 207.13,117.55 v1(207.13,116.67) 204.29,113.83 201.04,113.83 v1(200.34,113.13)
  IN3 w1.016: 207.58,115.44 209.79,113.23 209.79,109.44 211.12,108.11
  BOTTOM w0.356: RV91.1 206.55,116.02 206.09,115.57 CV121.1 205.13,115.36 205.06,115.43 UV12.14
  BOTTOM w0.381: UV11.14 206.1,121.02
  BOTTOM w0.508: v1(213.64,122.63) 214.36,121.91 RV519.1 ; v1(207.13,116.67) 206.8,116.34 RV91.1 ; v1(206.09,120.33) 206.14,120.38 CV118.1 ; RV90.1 CV118.1 ; CV118.1 206.1,121.02 ; RV87.1 203.3,105.37 203.62,105.05 208.02,105.05 210.6,107.63 211.11,107.63 ; v1(200.34,113.13) 201.24,112.23 RV86.1
  vias: v1(211.6,107.36) v1(212.25,107.36) v1(220.19,118.72) v1(225.59,122.21) v1(225.59,121.64)
+3.3V_SPI: length 61.4
  TOP w0.254: v1(201.13,84.16) 201.13,84.5 199.86,85.77 198.47,85.77 197.46,86.78 194.69,86.78 194.17,86.25 192.74,86.25 v1(192.27,86.72)
  IN2 w0.254: v1(192.27,86.72) 192.27,87.95 190.93,89.29 190.93,89.8 188.22,92.51 188.22,93.11 v1(187.83,93.51) 187.36,93.98 v1(187.36,99.44)
  IN3 w0.254: 187.83,74.67 188.35,74.67 188.86,75.18 188.86,80.51 189.76,81.42 189.76,82.88 192.27,85.39 v1(192.27,86.72)
  BOTTOM w0.254: UC5.8 187.18,100.03 CC9.1 187.17,99.63 v1(187.36,99.44) ; JSPI1.6 197.4,80.68 199.68,82.97 200.25,82.97 201.13,83.84 v1(201.13,84.16) 201.13,84.3 202.79,85.96 RC41.2 202.14,87.47 RC31.1 ; UC6.8 187.98,94.12 187.79,94.31 187.12,94.31 186.88,94.06 CC10.1 ; v1(165.62,88.08) UC1.AJ16 ; v1(192.27,86.72) 192.78,87.23 196.23,87.23 RC30.1
  BOTTOM w0.356: v1(187.83,93.51) 187.47,93.86 CC10.1
+3.3V_SPI_R: length 12.6
  BOTTOM w0.254: RC289.1 RC41.1 RC276.1 v2(202.72,84.99) 202.72,81.66 202.25,81.2 198.55,81.2 197.9,80.55 JSPI1.5
+3.3V_TP: length 18.9
  TOP w0.102: v1(282.19,9.78) v3(282.19,8.79)
  IN3 w0.508: v1(282.19,9.78) 282.5,10.09 282.5,13.25 v1(283.23,13.99) 285.01,12.21 v1(286.52,12.21)
  BOTTOM w0.305: JKBTP1.12 280.74,9.27 281.82,10.36 CZ27.1
  BOTTOM w0.381: v1(282.19,9.78) 282.19,10.04 282.05,10.17 CZ27.1
  BOTTOM w0.508: v1(283.23,13.99) RZ117.1 RZ116.1 ; RZ18.1 RZ19.1 v1(286.52,12.21) 286.52,12.38 286.97,12.82 RZ20.1 RZ21.1
+3.3V_TSP: length 0.8
  BOTTOM w0.102: v1(102.37,117.7) v2(103.15,117.7)
+3.3V_VCCHDA: length 39.9
  TOP w0.102: v1(163.02,88.13) 163.17,88.13 v2(163.46,88.43)
  TOP w0.254: v1(189.67,84.92) 189.89,84.92 CC313.1 190.55,86.96 LC1.2
  IN1 w0.254: v1(177.43,85.09) 177.04,85.48 173.06,85.48 171.5,87.04 168.93,87.04 168.07,87.91 166.76,87.91 166.13,88.54 165.39,88.54 164.5,87.65 163.5,87.65 v1(163.02,88.13)
  IN3 w0.254: v1(189.67,84.92) 188.5,83.75 188.5,82.04 185.3,78.84 182.31,78.84 179.58,81.57 179.58,83.75 178.99,84.34 178.18,84.34 v1(177.43,85.09)
  BOTTOM w0.254: UC1.AJ19 v1(163.02,88.13)
+3.3V_WLAN: length 2.8
  TOP w0.102: CZ20.1 264.02,53.06 v3(264.2,53.06)
  TOP w0.127: v3(264.21,51.27) 264.01,51.46 263.15,51.46 263.15,51.46
  vias: v1(243.28,51.37) v1(243.57,50.88) v1(244.12,51.37) v1(244.13,50.81) v1(261.24,51.16) v1(261.24,50.58) v1(261.24,50) v1(261.81,51.24) v3(242.63,51.77)
+3.3V_WLAN_UZ3: length 1.3
  TOP w0.102: 246.75,49.68 v2(248.07,49.68)
+3.3V_WWAN: length 4.6
  TOP w0.102: v3(279.87,106.51) 279.97,106.41 280.63,106.41 ; v3(280,108.75) 280.5,108.26 280.5,107.44 ; 280.5,106.96 279.74,107.72 v3(278.56,107.72)
  vias: v1(270.04,89.25) v1(270.04,88.68) v1(270.61,89.25) v1(270.61,88.68) v1(281.65,108.25) v1(281.67,107.67) v1(281.67,107.11) v1(281.68,106.52) v1(281.68,105.96)
+3.3V_WWAN_UZ2: length 1.6
  TOP w0.102: 283.73,104.15 v2(283.73,102.54)
+5V_ALW: length 377.9
  TOP w0.203: v1(249.41,47.19) 249.2,47.41 UZ3.4 ; UZ5.4 v1(274.7,68.87)
  TOP w0.254: UZ8.4 199.54,78.89 199.58,78.85 199.58,77.72 199.17,77.31 197.41,77.31 196.9,76.81 196.3,76.81 196.02,77.08 196.02,77.73 196.29,78 v1(196.29,78.69) 196.29,79.24 196.18,79.36 UZ22.4
  TOP w0.305: v1(115.28,126.54) 115.57,126.84 UZ21.3 ; 114.12,73.06 113.53,72.47 UZ26.3
  TOP w0.356: v1(292.81,9.31) 292.94,9.18 CZ94.1
  TOP w0.406: PR9.1 71.65,114.51 72.36,115.22 PU1.5
  TOP w0.508: v1(159.1,119.08) 160.31,120.29 160.31,123.22 v1(160.44,123.35) ; v1(287.03,19.31) 287.42,18.92 288.4,18.92 289.1,18.22 PC507.1 289.12,16.95 PU502.6 ; v1(82.4,76.36) 82.92,76.88 v3(83.2,76.88) 84.77,76.88 v1(85.2,76.45) 85.82,75.83 PR937.2 ; PR9.1 71.35,114.14 71.03,113.83 67.41,113.83 66.65,114.59 66.65,117.06 67.89,118.31 71.38,118.31 72.31,119.23 72.31,121.71 73.19,122.59 v3(77.51,122.59) 78.71,122.59 79.03,122.91 ; v1(107.08,74.53) 107.63,75.08 113.55,75.08 114.12,74.51 114.12,73.06 ; PU1500.6 256.6,45.77 256.75,45.92 256.75,46.54 PC1500.1 257.15,47.19 256.65,47.68 254.9,47.68 v1(254.63,47.42) ; LED3.2 v1(295.79,119.52)
  TOP w1.016: 254.76,100.31 v3(251.2,100.31) 248.66,97.77 248.66,90.24 247.72,89.3 ; 271.88,101.6 270.76,102.71 268.83,102.71
  IN1 w0.508: v1(82.4,76.36) 82.4,79.28 84.49,81.38 84.49,82.52 82.65,84.36 82.65,89.66 83.09,90.1 83.94,90.1 84.62,90.78 v1(84.62,91.11) ; v1(226.98,121.64) 227.26,121.64 v1(229.79,124.16) ; v1(277,27.93) 278.62,26.3 278.62,25.7 285.01,19.31 v1(287.03,19.31) 288.71,19.31 289.84,20.44 v1(289.84,21.57)
  IN1 w1.016: 240.61,46.77 241.91,46.77 244.1,44.57 247.15,44.57 248.27,45.69 248.27,45.78
  IN2 w0.508: v1(210.27,101.42) 207.97,101.42 206,99.45 206,93.47 204.86,92.33 204.86,82.57 205.71,81.72 205.71,80.18 204.87,79.35 204.87,77.62 200.47,73.21 v1(198.55,73.21) ; v1(269.45,51.52) 269.23,51.29 269.23,44.27 275.71,37.79 275.71,30.77 277,29.49 v1(277,27.93) ; v1(89.13,115.79) 89.13,110.99 88.48,110.35 88.48,107.59 87.54,106.65 87.54,96.68 84.62,93.76 v1(84.62,91.11) ; v1(107.08,74.53) 106.56,74.01 105.46,74.01 104.68,74.79 100.61,74.79 98.64,72.82 97.1,72.82 95.59,71.31 91.18,71.31 90.03,72.46 87.11,72.46 85.2,74.37 v1(85.2,76.45) ; v1(295.79,119.52) 295.79,116.35 290.04,110.6 287.87,110.6 v1(287.74,110.47)
  IN2 w1.016: 277.66,98 279.84,95.82 279.84,93.14 280.34,92.64 280.34,88.25 279.47,87.38 279.47,86.34 279.03,85.9 279.03,77.71 279.04,77.69
  IN3 w0.508: v1(196.29,78.69) 196.29,78.01 196.02,77.75 196.02,76.93 198.55,74.4 v1(198.55,73.21) ; v1(275.18,104.03) 276.16,105.01 283.45,105.01 286.74,108.31 286.74,109.96 287.26,110.47 v1(287.74,110.47) ; v1(84.62,91.11) 85.26,91.11 85.84,90.53 88.77,90.53 89.53,89.77 v1(89.53,84.17)
  IN4 w0.508: v1(297.03,6.24) 297.48,6.7 297.48,12.25 296.56,13.18 291.56,13.18 289.84,14.91 v1(289.84,21.57)
  BOTTOM w0.305: 169.73,120.82 169.73,119.46 169.4,119.13 UZ20.3 ; v1(159.1,119.08) 159.93,119.08 160.19,118.82 UZ19.3 ; 293.29,7.04 292.9,7.44 JUSH1.9 292.9,9.22 v1(292.81,9.31)
  BOTTOM w0.508: v1(160.44,123.35) 161.9,123.35 162.51,122.74 168.22,122.74 169.73,121.23 169.73,120.82 ; v1(297.03,6.24) 294.09,6.24 293.29,7.04 ; v1(212.8,106.51) 212.65,106.36 RV662.2 ; v1(289.84,21.57) 289.93,21.57 290.21,21.29 290.21,20.99 289.97,20.75 JLED1.1 ; v1(84.62,91.11) 84.24,90.73 PR602.2 ; PR201.2 81.32,78.77 82.4,77.69 v1(82.4,76.36) 81.86,75.82 81.86,74.17 81.49,73.81 PR205.1
  vias: v1(79.16,124.11) v1(79.16,123.54) v1(79.73,124.11) v1(79.73,123.54) v1(88.39,122.32) v1(88.39,121.75) v1(88.97,122.32) v1(88.97,121.75) v1(97.89,126.46) v1(98.46,126.46) v1(99.03,126.46) v1(99.6,126.46) v1(210.27,102.05) v1(210.91,102.05) v1(210.91,101.42) v1(211.54,102.05) v1(211.54,101.42) v1(212.18,102.05) v1(212.18,101.42) v1(212.81,102.05) v1(212.81,101.42) v1(213.45,102.05) v1(213.45,101.42) v1(239.2,46.87) v1(239.76,46.86) v1(250,47.19) v1(255.52,100.73) v1(255.92,100.33) v1(267.37,102.64) v1(267.93,102.62) v1(269.87,51.1) v1(274.33,103.09) v1(274.76,103.53) v1(275.22,103.09) v1(275.42,99.86) v1(275.63,103.62) v1(275.85,100.26) v1(276.79,98.87) v1(277.35,99.44) v1(277.35,98.85) v1(277.95,99.44) v1(277.95,98.85) v1(279.63,77.16) v1(279.61,76.58)
+5V_ALW2: length 161.6
  IN2 w0.508: v1(211.64,69.95) 211.53,69.83 211.12,69.83 209.71,71.24 209.71,73.8 211.03,75.12 213.15,75.12 214.94,76.91 214.94,80.21 213.87,81.29 208.57,81.29 207.58,82.28 207.58,87.51 v1(207.05,88.05)
  IN4 w0.508: v1(291.57,12.24) 291.57,11.75 292.55,10.77 294.37,10.77 294.99,10.14 294.99,9.57 294.05,8.63 282.51,8.63 281.68,9.46 277.58,9.46 275.55,11.49 275.55,20.87 274.86,21.56 274.86,37.64 272.25,40.25 269.98,40.25 266.29,43.94 263.45,43.94 262.81,44.57 256.59,44.57 255.97,45.2 252.31,45.2 251.22,46.29 251.22,48.78 250.29,49.7 247.52,49.7 245.26,51.96 241.33,51.96 239.94,53.35 229.47,53.35 228.94,53.87 228.43,53.87 226.92,55.38 225.8,55.38 222.92,58.26 222.92,58.9 222.4,59.42 221.76,59.42 218.31,62.87 218.31,64.03 212.39,69.95 v1(211.64,69.95)
  BOTTOM w0.508: RZ86.1 291.58,12.25 v1(291.57,12.24)
+5V_ALW2_R: length 3.3
  TOP w0.102: v1(292.26,9.7) 292.26,9.14 v3(292.11,8.99)
  BOTTOM w0.305: RZ86.2 291.58,10.38 v1(292.26,9.7) 292.33,9.64 292.33,9.1 292.4,9.03 JUSH1.10
+5V_ALWP: length 12.4
  IN4 w0.508: v1(207.07,98.01) 206.65,98.01 205.69,97.05 205.69,87.87 v1(206.32,87.23) v1(206.32,86.65)
  vias: v1(207.05,97.39) v1(207.05,96.81) v1(207.66,97.99) v1(207.66,97.4) v1(207.66,96.82) v2(208.63,96.86)
+5V_RUN: length 320.4
  TOP w0.381: v1(281.28,5.89) 280.96,5.89 CZ29.1
  TOP w0.508: v1(107.35,103.86) 106.46,103.86 106.21,103.6 v3(106.21,98.65) 106.21,97.06 107.89,95.38 107.89,88.15 104.67,84.93 99.58,84.93 98.68,84.03 97.71,84.03 96.3,82.62 v1(96.3,81)
  IN1 w0.508: v1(281.28,5.89) 287.86,5.89 288.6,5.14 291.09,5.14 293.76,7.81 v1(293.76,9.91)
  IN2 w0.508: v1(268.81,67.28) 268.81,67.03 269.94,65.9 269.94,63.19 269.4,62.66 269.4,57.23 269.44,57.2 269.44,55.22 269.31,55.1 269.31,53.61 267.93,52.23 267.93,43.84 274.49,37.29 274.49,16.02 278.09,12.42 278.09,9.79 279.87,8.01 279.87,6.49 280.46,5.89 v1(281.28,5.89)
  IN2 w1.016: 276.36,111.16 275.3,110.09 274.6,110.09 273.4,108.9 273.4,103.75 272.86,103.21 272.86,94.99 271.93,94.06 271.93,86.27 273.97,84.22 273.97,76.74 273.39,76.16 273.39,74.19 271.68,72.47 271.68,70.56 271.54,70.42 ; 81.3,94.27 81.93,94.27 86.14,98.48 86.14,107.02 86.87,107.74 86.87,109.19
  IN3 w2.032: 129.63,123.07 131.94,123.07 133.17,124.3 134.41,124.3 136.37,126.26 161.48,126.26 163.33,124.4 170.59,124.4 170.61,124.42
  IN4 w0.254: v1(96.3,81) 93.7,83.6 93.7,90.84 96.11,93.25 96.11,94.59 95.6,95.09 82.08,95.09 80.73,93.75 v1(80.73,93.4)
  IN4 w0.508: v1(127.58,124.19) 127.58,123.36 129.07,121.88 129.07,118.49 128.19,117.61 127.89,117.61 v1(127.39,117.12)
  IN4 w1.016: 276.21,113.13 275.89,113.45 253.32,113.45 250.26,116.51 250.26,122.77 249.18,123.85 246.39,123.85 245.41,124.82 245.41,126.01
  BOTTOM w0.305: JKBTP1.5 281.16,5.77 v1(281.28,5.89) ; v1(293.76,9.91) 293.9,9.78 JUSH1.7
  BOTTOM w0.381: CZ10.1 293.66,9.91 v1(293.76,9.91)
  BOTTOM w0.508: v1(96.3,81) 96.43,81.12 PC677.1
  BOTTOM w2.032: 87.03,123.92 90.52,123.92 93.76,120.68 93.76,119.48
  vias: v1(81.37,93.4) v1(85.98,110.13) v1(86.55,110.13) v1(90.9,118.08) v1(91.48,118.08) v1(92.05,118.08) v1(92.62,118.08) v1(246.34,127.14) v1(246.34,126.55) v1(246.91,127.14) v1(246.91,126.55) v1(271.5,69.5) v1(271.5,68.93) v1(276.06,112.07) v1(276.64,112.07)
+5V_RUN_AUDIO: length 25.8
  TOP w0.102: v1(297.27,67.69) 297.44,67.69 v2(297.8,67.33)
  TOP w0.508: LA5.2 296.54,67.69 v1(297.27,67.69)
  IN1 w0.508: v1(278.19,72.97) 279.71,71.45 281.87,71.45 282.22,71.1 285.66,71.1 286.99,72.44 295.68,72.44 296.38,71.74 296.38,69.3 297.27,68.41 v1(297.27,67.69)
+5V_RUN_AUDIO_UZ5:
  vias: v2(277.35,71.08)
+5V_RUN_PVDD: length 10.5
  TOP w1.016: 287.27,79.36 279.54,79.36 278.72,78.55 278.72,76.93 278.71,76.92
  vias: v2(289.51,75.83)
+5V_RUN_UZ4: length 1.9
  BOTTOM w0.102: 82.67,121.5 v2(80.81,121.5)
+5V_USB_CHG_PWR: length 10.6
  TOP w0.102: 279.91,104.09 279.91,104.89 279.11,105.69 278.69,105.69 276.9,107.48 v3(276.9,108.42) ; 279.69,104.12 279.69,104.36 v3(279.28,104.77)
  TOP w0.127: v3(276.79,106.64) 277.34,106.64 278.71,105.27 278.71,104.2 278.97,103.95
  vias: v1(281.41,103.44) v1(281.97,103.44) v1(281.97,102.84) v1(282.56,103.44) v1(282.56,102.84) v1(284.25,94.31) v1(284.49,95.94) v1(284.49,95.37) v1(284.5,94.81) v1(284.81,94.31)
+DV33_18: length 1.8
  BOTTOM w0.102: CR37.1 270.69,79.98 v2(270.42,80.25)
  BOTTOM w0.508: CR37.1 v1(271.37,79.28)
+GND_CHASSIS:
  vias: v1(281.89,122.64) v1(281.89,122) v2(280.65,122.07)
+VCC_1P8: length 1
  BOTTOM w0.254: UC1.U11 168.09,94.12 v1(167.76,93.8) 167.44,94.12 UC1.U12
  vias: v2(168.48,94.22)
+VCC_CORE: length 56
  TOP w0.508: CC283.2 CC284.2 163.43,115.86 161.35,113.78 161.35,110.1 160.83,109.58 156.59,109.58 ; CC287.1 142.94,118.28 144,117.22 144,116.82 146.24,114.59 147.3,114.59 148.33,113.56 148.33,111.87
  BOTTOM w0.076: 149.47,97.95 149.46,97.95
  BOTTOM w0.127: 154.95,97.95 UC1.K33 154.65,98.26 ; 154.05,88.27 154.04,88.26 UC1.AK35 ; UC1.AL37 153.86,87.42 153.87,87.44 ; UC1.AL37 153.58,87.73 153.58,87.73 ; UC1.AL37 153.26,87.42 153.26,87.42 ; 150.99,98.26 UC1.K40 151.29,97.95 ; UC1.J37 152.67,99.03 ; UC1.J37 152.97,98.72 ; UC1.J37 152.36,98.72 ; UC1.J37 152.67,98.42 ; UC1.AK33 154.95,87.53 154.95,87.52 ; UC1.AK33 154.95,88.24 ; UC1.AK33 155.29,87.89 ; UC1.J40 150.84,98.42 ; UC1.J40 151.14,98.72 ; UC1.J40 150.84,99.03 ; UC1.J40 150.53,98.72 ; 154.04,97.95 UC1.K35 154.34,98.26 ; UC1.J33 154.8,98.72 ; UC1.J33 154.49,99.03 ; UC1.J33 154.19,98.72 ; 155.41,87.76 UC1.AL33 155.07,87.42 155.06,87.42 ; 150.68,98.26 UC1.K42 150.38,97.95 ; UC1.AK38 152.21,88.3 ; UC1.AK38 151.89,87.89 151.88,87.88 ; UC1.AK38 152.21,87.55 152.21,87.55 ; 151.58,87.89 UC1.AK40 151.29,88.26 151.29,88.26 ; 156.02,98.72 UC1.J30 ; UC1.J30 156.32,98.42 ; UC1.J30 156.32,99.03 ; 149.47,97.95 UC1.K43 149.47,98.58 149.46,98.59 ; 152.51,98.26 UC1.K38 152.21,97.95 ; UC1.AK35 153.74,87.89 ; UC1.AK35 154.04,87.53 154.04,87.52 ; 153.12,97.95 UC1.K37 152.82,98.26 ; 151.75,87.78 151.75,87.78 UC1.AL40 152.08,87.42 152.08,87.42 ; 153.12,87.54 UC1.AK37 ; UC1.AK37 153.41,87.89 ; UC1.AK37 153.12,88.27
  BOTTOM w0.203: UC1.A39 151.58,103.07 v1(151.58,103.39) ; UC1.A30 156.36,103.27 v1(156.5,103.41) ; UC1.A34 153.85,102.92 v1(153.85,103.41) ; UC1.A44 v1(148.92,103.8)
  BOTTOM w0.254: UC1.G35 154.29,99.44 v1(154.49,99.44) 154.7,99.44 UC1.G33 ; UC1.G37 152.87,99.44 v1(152.66,99.44) 152.46,99.44 UC1.G38 ; UC1.G40 151.04,99.44 v1(150.83,99.44) 150.63,99.44 UC1.G42 ; UC1.G32 156.13,99.46 v1(156.35,99.46) 156.51,99.46 UC1.G30
  BOTTOM w0.457: v1(120.62,113.19) 121,113.19 PC1002.1 ; v1(123.04,112.18) 123.42,112.18 PC1173.1 ; v1(120.62,111.92) 121,111.92 PC1073.1 ; PC1008.1 121,110.65 v1(120.62,110.65)
  BOTTOM w0.508: v1(113.13,106.52) 113.51,106.52 PC1077.1 ; PC1174.1 125.8,110.93 v1(125.45,110.93) ; v1(123.04,110.93) 123.39,110.93 PC1079.1 ; PC1001.1 113.51,107.79 v1(113.13,107.79) ; PC1076.1 113.51,109.06 v1(113.13,109.06) ; v1(120.62,114.44) 121.03,114.44 PC1010.1 ; RC140.1 v1(156.82,107.02)
  vias: v1(111.78,111.44) v1(112.37,111.44) v1(112.95,111.44) v1(113.26,105.19) v1(113.54,111.44) v1(113.64,104.56) v1(114.15,105.19) v1(114.15,103.92) v1(114.23,97.93) v1(114.34,96.43) v1(114.53,105.83) v1(114.53,104.56) v1(114.61,98.56) v1(115.03,106.46) v1(115.03,105.19) v1(115.03,103.92) v1(115.12,99.2) v1(115.12,97.93) v1(115.42,105.83) v1(115.42,104.56) v1(115.5,98.56) v1(115.61,96.43) v1(115.92,105.19) v1(115.92,103.92) v1(116.01,99.2) v1(116.01,97.93) v1(116.3,105.83) v1(116.3,104.56) v1(116.39,98.56) v1(116.81,105.19) v1(116.81,103.92) v1(116.88,96.43) v1(116.9,99.2) v1(116.9,97.93) v1(117.19,105.83) v1(117.19,104.56) v1(117.28,98.56) v1(117.7,105.19) v1(117.7,103.92) v1(117.79,99.2) v1(117.79,97.93) v1(118.08,105.83) v1(118.08,104.56) v1(118.17,98.56) v1(118.15,96.43) v1(125.45,112.18) v1(150.12,90.97) v1(150.38,97.31) v1(150.78,95.84) v1(150.84,98.03) v1(150.85,93.39) v1(151.29,97.31) v1(151.34,90.97) v1(151.75,88.21) v1(152.01,95.84) v1(152.06,93.39) v1(152.21,97.31) v1(152.21,88.93) v1(152.53,90.97) v1(152.67,98.03) v1(152.67,86.56) v1(153.12,97.31) v1(153.12,88.93) v1(153.24,95.84) v1(153.27,93.39) v1(153.58,88.21) v1(153.58,86.56) v1(153.74,90.97) v1(154.04,97.31) v1(154.04,88.93) v1(154.49,98.03) v1(154.46,95.84) v1(154.47,93.39) v1(154.49,86.56) v1(154.95,97.31) v1(154.95,90.97) v1(154.95,88.93) v1(155.41,88.21) v1(155.68,95.84) v1(155.73,93.43) v1(156.32,98.03) v3(114.77,101.96)
+VCC_CORE_G0: length 1.5
  TOP w0.254: T122.1 156.08,97.53 v1(155.87,97.31)
  BOTTOM w0.076: UC1.K32 v1(155.87,97.31)
+VCC_CORE_G1: length 1.6
  TOP w0.203: T123.1 155.64,88.71 v1(155.87,88.93)
  BOTTOM w0.076: UC1.AK32 v1(155.87,88.93)
+VCC_GT: length 21.8
  BOTTOM w0.127: 144.59,98.26 UC1.K52 ; UC1.K52 145.2,98.26 ; UC1.K52 144.89,97.95 ; UC1.K53 143.98,97.95 ; UC1.K53 144.28,98.26 ; UC1.K53 143.67,98.26 ; 146.11,98.26 UC1.K50 ; UC1.K50 145.81,97.95 ; UC1.K50 145.5,98.26 ; 146.72,97.95 UC1.K48 ; UC1.K48 147.03,98.26 ; UC1.K48 146.42,98.26 ; 141.84,98.26 UC1.K56 ; UC1.K56 142.15,97.95 ; UC1.K56 142.46,98.26 ; UC1.J53 143.52,98.42 ; 138.64,97.35 UC1.L63 ; UC1.L63 138.34,97.07 ; UC1.L63 138.64,96.76 ; UC1.J50 145.35,98.42 ; 141.24,97.95 UC1.K58 ; UC1.K58 141.54,98.26 ; UC1.K58 140.93,98.26 ; 138.34,96.15 UC1.N63 138.64,96.46 ; 142.76,98.26 UC1.K55 ; UC1.K55 143.37,98.26 ; UC1.K55 143.06,97.95 ; 139.11,92.65 UC1.Y62 139.42,92.95 ; 139.11,97.83 UC1.L62 139.11,97.22 ; 138.34,93.41 UC1.W63 138.64,93.1 ; UC1.J60 139.86,98.42 ; UC1.K60 140.63,98.26 ; UC1.K60 140.02,98.26 ; UC1.K60 140.32,97.95 ; 139.42,94.78 UC1.T62 139.11,94.47 ; UC1.J55 142.61,98.42 ; UC1.J56 141.69,98.42 ; 139.11,96.91 UC1.M62 139.11,96.3 ; UC1.J46 147.18,98.42 ; 148.7,98.72 UC1.J43 149.01,98.42 ; UC1.J58 140.78,98.42 ; 138.64,92.8 UC1.AA63 138.34,92.49 ; UC1.J45 148.09,98.42 ; UC1.J48 146.26,98.42 ; 138.95,95.24 UC1.R63 138.64,94.93 ; UC1.J52 144.44,98.42
  BOTTOM w0.203: UC1.A58 v1(141.49,103.9) ; v1(139.02,103.73) 139.01,103.71 UC1.A62 ; v1(143.95,103.85) 143.97,103.83 UC1.A53 ; v1(146.95,103.83) 146.44,103.33 UC1.A48 ; UC1.A66 v1(136.53,103.9)
  vias: v1(109.12,82.83) v1(109.12,82.06) v1(109.12,81.3) v1(109.12,80.54) v1(109.88,82.83) v1(109.88,82.06) v1(109.88,81.3) v1(109.88,80.54) v1(110.64,82.83) v1(110.64,82.06) v1(110.64,81.3) v1(110.64,80.54) v1(111.4,82.83) v1(111.4,82.06) v1(111.4,81.3) v1(111.4,80.54) v1(112.16,82.83) v1(112.16,82.06) v1(112.16,81.3) v1(112.16,80.54) v1(112.94,92.62) v1(112.93,82.83) v1(112.93,82.06) v1(112.93,81.3) v1(112.93,80.54) v1(113.57,88.93) v1(113.69,82.83) v1(113.69,82.06) v1(113.69,81.3) v1(113.69,80.54) v1(114.3,82.84) v1(114.3,82.08) v1(114.59,92.62) v1(115.22,88.93) v1(116.24,92.62) v1(116.88,88.93) v1(117.76,92.62) v1(118.4,88.93) v1(127.87,97.14) v1(128.4,94.67) v1(128.4,92.28) v1(129.44,97.13) v1(129.93,94.67) v1(129.93,92.28) v1(131.45,94.67) v1(131.45,92.28) v1(132.99,94.67) v1(132.97,92.23) v1(133.77,95.69) v1(133.77,93.86) v1(133.77,92.04) v1(134.42,96.61) v1(134.42,94.78) v1(134.42,92.95) v1(135.07,95.69) v1(135.07,92.04) v1(135.72,96.61) v1(135.72,94.78) v1(135.72,93.86) v1(135.72,92.95) v1(136.37,95.69) v1(136.37,92.04) v1(137.02,96.61) v1(137.02,94.78) v1(137.02,92.95) v1(137.67,93.86) v1(138.32,96.61) v1(138.32,94.78) v1(138.32,92.95) v1(139.38,97.07) v1(139.8,96.62) v1(139.8,95.27) v1(139.8,92.92) v1(139.86,98.03) v1(140.32,97.31) v1(140.78,98.03) v1(141.24,97.31) v1(141.69,98.03) v1(142.15,97.31) v1(142.61,98.03) v1(143.06,97.31) v1(143.52,98.03) v1(143.98,97.31) v1(144.44,98.03) v1(144.89,97.31) v1(145.35,98.03) v1(145.67,95.33) v1(145.65,92.54) v1(145.81,97.31) v1(146.26,98.03) v1(146.72,97.31) v1(146.92,95.33) v1(146.9,92.54) v1(147.18,98.03) v1(148.09,98.03) v1(149.01,98.03) v3(111.44,77.42)
+VCC_GTUS: length 0.5
  TOP w0.102: v1(142.61,88.07) 142.61,88.25 v2(142.86,88.5)
+VCC_SA: length 94.5
  TOP w0.254: PR636.2 85.11,93.47 PR641.2 v3(83.91,94.33) 83.48,94.33 v1(83.22,94.06)
  TOP w0.457: PC1057.1 158.49,94.22 v1(158.2,94.22) ; PC1144.1 158.49,95.43 v1(158.2,95.43)
  IN3 w0.254: v1(83.22,94.06) 84.79,95.64 92.95,95.64 95.03,97.72 95.03,107.98 97.22,110.17 100.54,110.17 102.02,111.64 108.84,111.64 111.32,114.12 116.95,114.12 117.61,114.79 119.44,114.79 120.9,116.24 122.04,116.24 123.69,117.89 127.66,117.89 128.16,117.39 134.53,117.39 134.92,117 135.57,117 135.81,117.24 v1(135.81,117.47)
  BOTTOM w0.127: UC1.K23 160.13,98.26 ; UC1.K23 160.44,97.95 ; UC1.K23 160.44,98.56 ; UC1.AK25 159.83,87.89 ; UC1.AK25 159.22,87.89 ; UC1.AK25 159.52,88.19 ; UC1.K27 158.61,97.95 ; UC1.K27 158.61,98.56 ; UC1.K27 158.3,98.26 ; UC1.K28 157.69,98.56 ; UC1.K28 157.69,97.95 ; UC1.K28 158,98.26 ; 156.78,97.95 UC1.K30 156.78,98.56 ; UC1.K25 159.83,98.26 ; UC1.K25 159.52,98.56 ; UC1.K25 159.52,97.95 ; 158.46,98.72 UC1.J27 ; UC1.J27 158.15,98.42 ; UC1.J27 157.85,98.72 ; 160.13,87.89 UC1.AK23 160.44,88.19 ; UC1.J23 159.98,98.42 ; UC1.J23 159.68,98.72 ; UC1.J23 160.29,98.72 ; 160.9,98.42 UC1.J22 160.59,98.72
  BOTTOM w0.254: UC1.G28 157.95,99.44 v1(158.15,99.44) 158.36,99.44 UC1.G27 ; UC1.G23 160.18,99.44 v1(159.98,99.44) 159.78,99.44 UC1.G25 ; PL601.2 135.84,113.83 135.52,114.14 135.52,115.78 135.72,115.99 135.72,116.49 PH604.2 136.17,117.47 v1(135.81,117.47) ; PC633.2 PR643.1 PC637.2 83.97,93.32 PC644.1 83.22,93.38 v1(83.22,94.06)
  BOTTOM w0.508: RC168.1 154.18,106.79 v1(153.91,107.06)
  vias: v1(139.47,114.08) v1(139.47,113.45) v1(139.91,115.45) v1(140.1,114.08) v1(140.1,113.45) v1(140.74,114.08) v1(140.74,113.45) v1(141.2,115.48) v1(141.37,114.08) v1(141.37,113.45) v1(157.55,105.13) v1(157.69,97.31) v1(158.15,98.01) v1(158.61,97.31) v1(159.39,88.88) v1(159.52,97.31) v1(159.98,98.01) v1(159.96,88.82) v1(160.09,95.61) v1(160.09,94.47) v1(160.09,93.33) v1(160.44,97.31)
+VCC_SFR_OC: length 64.4
  TOP w0.508: v1(160.9,88.11) 160.9,88.73 160.68,88.95 CC288.1
  IN2 w0.508: 157.57,81.99 157.02,81.44 157.02,70.38 155.9,69.26 111.12,69.26 v1(108.25,72.13)
  BOTTOM w0.203: UC1.AL23 v1(160.9,88.11)
  vias: v2(107.81,71.76)
+VDDA_AVDD1: length 6.3
  TOP w0.102: v2(296.57,66.58) 296.43,66.72 CA8.1
  TOP w0.203: CA9.1 293.93,67.67 293.49,67.67 292.53,68.64 UA1.27
  TOP w0.508: CA9.1 295.3,67.55 LA5.1 295.63,67.47 CA8.1
+VDDA_PVDD:
  vias: v2(293.88,77.03)
GND: length 4289
  TOP w0.102: v3(46.89,59.07) 46.89,58.96 48.26,57.59 PC828.2 ; v1(106.63,123.06) v3(106.63,123.82) ; v1(239.82,120.7) v3(239.06,120.7) ; v1(277.59,22.77) 276.85,23.51 v3(276.85,23.69) ; v1(125.58,116.05) 125.45,116.18 v3(124.64,116.18) ; v3(45.12,58.57) CN29.2 ; v3(14.26,36.97) 14.62,36.61 v1(14.62,35.94) ; v1(265.35,121.5) v3(264.56,121.5) ; v1(97.89,104.05) v3(97.32,104.05) ; v3(152.89,111.41) 152.78,111.3 152.09,111.3 v1(152.08,111.31) ; v1(24.01,48.73) 24.01,48.32 v3(24.55,47.79)
  TOP w0.203: UV7.52 246.83,114.22 v1(246.82,114.21) ; UV8.J12 218.56,119.69 v1(218.89,120.02) ; PU901.32 85.17,69.14 v1(84.87,69.44) ; UV8.H4 v1(218.24,114.17) ; UZ3.11 v1(245.87,47.41) ; v1(239.63,107.73) 239,108.36 UV26.52 ; UV26.11 v1(233.58,113.26) ; UV8.E4 v1(215.64,114.17) ; UV7.19 251.23,122.95 251.49,123.22 v1(251.74,123.22) ; v1(51.92,52.29) 52.11,52.29 52.86,53.05 PU801.22 ; UZ5.11 v1(278.2,68.87) ; v1(229.56,113.42) 229.73,113.42 230.38,112.77 UV26.19 ; UZ2.11 v1(284.02,110.52) ; v1(251.78,119.75) 251.78,119.75 UV7.11
  TOP w0.254: v1(214.35,68.87) 214.2,69.02 UZ12.23 ; UV8.D4 v1(214.99,114.17) ; UV8.G10 217.26,118.4 v1(217.59,118.72) UV8.G11 ; UV8.G8 v1(217.59,117.42) ; UV8.D8 215.31,117.09 v1(214.99,117.42) UV8.D9 ; PU901.14 92.48,69.14 v1(92.63,69.29) ; v1(214.99,120.67) 214.67,120.34 UV8.C13 ; v1(214.99,120.67) UV8.C14 ; v1(214.99,120.67) 215.31,120.99 UV8.D14 ; v1(214.99,120.67) 215.31,120.34 UV8.D13 ; v1(217.14,68.87) 217.49,68.52 UZ12.32 ; v1(218.89,119.37) 218.56,119.04 UV8.J11 ; UV8.F7 v1(216.29,116.12) 216.61,115.8 UV8.F6 ; UZ8.5 199.54,81.84 199.87,82.18 CZ42.2 ; v1(217.59,118.07) 217.26,117.75 UV8.G9 ; v1(237.34,45.5) 237.2,45.36 PU401.6 ; UV8.F4 v1(216.29,114.17) ; UV8.G5 217.26,115.15 v1(217.59,115.47) UV8.G6 ; UN5.7 38.47,55.89 v1(38.07,56.3) ; UV8.J8 218.56,117.1 v1(218.89,117.42) ; v1(24.1,56.68) 24.1,56.55 24.38,56.27 UN4.7 ; UV8.D5 v1(214.99,114.82) ; UV8.F5 216.61,115.15 v1(216.29,115.47) ; UV8.D6 v1(214.99,115.47) 214.66,115.15 UV8.C5 ; UV8.K5 v1(219.54,114.82) ; UV8.H10 217.92,118.39 v1(218.24,118.72) ; UV8.J9 218.56,117.75 v1(218.89,118.07) ; UV8.J6 v1(218.89,115.47) ; UV8.G7 v1(217.59,116.12) ; v1(88.36,73.48) 88.69,73.16 PU901.23 ; v1(216.29,117.42) 216.61,117.09 UV8.F8 ; UV8.G4 v1(217.59,114.17) ; UV8.F11 v1(216.29,119.37) 215.96,119.05 UV8.E11 ; UV8.F9 216.61,117.74 v1(216.29,118.07) ; UV8.D7 v1(214.99,116.12) ; UV8.F10 v1(216.29,118.72) ; UZ12.16 214,72.02 v1(214.35,71.66) ; UV8.D11 214.99,118.72 v1(214.99,118.72) 215.31,118.39 UV8.D10 ; UV8.L6 219.86,115.8 v1(220.18,116.12) 220.18,116.12 UV8.L7 UV8.L8 ; v1(217.14,71.66) 217.49,72.01 UZ12.9 ; PU402.6 241.45,91.23 v1(241.27,91.41) ; UV8.J7 218.56,116.44 v1(218.89,116.12) ; UV8.J5 v1(218.89,114.82) ; RI14.1 277.43,104.4 277.72,104.11 UI3.14 ; PU901.5 v1(88.69,65.25)
  TOP w0.305: v1(190.06,64.13) JAPS1.14 ; 231.95,58.84 232.51,58.84 RE85.2 ; UZ26.5 109.39,73.12 CZ114.2 107.4,72.94 v1(106.87,73.48) ; v1(254.3,70.98) 254.37,71.06 UE2.B60 ; UZ21.5 119.1,126.19 120,127.09 v1(120,127.68) ; UE2.B11 250.71,66.04 251,65.74 v1(251,65.53) ; v1(189.17,64.13) 189.06,64.01 JAPS1.12 ; UE1.B27 232.67,71.28 232.93,71.01 v1(232.93,70.9) ; v1(187.97,64.13) 187.97,63.69 188.06,63.61 JAPS1.10 188.06,61.94 187.3,61.94 187.06,62.19 JAPS1.8 ; UE2.B66 251.37,71.01 v1(251.4,70.98) ; UE2.B18 250.37,62.17 250.11,61.91 250.11,60.89 v1(250.1,60.88) ; v1(278.34,7.18) 278.16,7.37 JDEG1.10 ; UE2.B54 v1(257.37,70.98)
  TOP w0.356: CI3.2 v1(71.55,125.13) ; PC1048.2 139.81,99.39 v1(139.86,99.44) ; v1(142.61,99.44) 142.68,99.37 PC1040.2 ; PC1164.2 150.01,98.12 v1(149.92,98.03) ; v1(136.37,93.86) 136.36,93.87 PC1042.2 ; PC1055.2 144.5,99.39 v1(144.44,99.45) ; PC1047.2 140.84,99.38 v1(140.78,99.44) ; CC209.2 164.18,92.58 163.67,93.1 v1(163.67,93.16) ; v1(134.42,91.16) 134.42,91.16 PC1041.2 ; PC1046.2 137.65,95.71 v1(137.67,95.69) 137.65,95.68 PC1044.2 ; v1(213.61,73.55) 214.27,74.21 CZ74.2 214.27,75.32 CZ76.2 ; PC1150.2 160.44,91.84 v1(160.7,92.11) PC1152.2 160.7,93.35 RC324.2 ; CZ73.2 220.34,71.54 v1(220.11,71.31) ; v1(249.73,75.85) 250.59,75.85 251.25,75.19 CE11.2 ; CZ72.2 220.74,67.75 CZ71.2 221.45,68.36 v1(221.85,68.76)
  TOP w0.381: v1(7.34,57.18) 7.47,57.05 PQ911.1 ; CV8.2 92.52,109.94 v1(92.67,110.09) ; v1(153.88,101.74) 154.17,101.45 PC1095.2 ; CZ78.2 117.32,131.69 v1(117.04,131.97) ; CZ40.2 194.04,85.3 v1(194.76,86.03) ; CZ47.2 243.48,46.11 242.5,47.09 v1(242.5,47.5) ; UE4.3 248.41,82.02 248.21,82.23 248.21,82.48 v1(248.08,82.61) ; CR10.2 269.05,75.07 v1(269.21,74.9) ; v1(258.39,87.13) 258.8,87.54 CL9.2 ; PQ902.4 66.47,68.98 v1(66.77,68.68) ; v1(167.87,71.43) 168.8,71.43 CC270.2 168.85,72.21 CC24.2 ; v1(208.9,69.48) 208.9,69.35 209.52,68.74 CZ75.2 ; v1(83.33,40.43) 83.44,40.33 CD30.2 ; 256.51,58.84 256.05,58.38 RE55.1 ; PC1094.2 155.78,101.16 v1(156.36,101.74) 156.83,101.27 PC1032.2 ; CC313.2 191.13,85.91 191.13,86.42 v1(191.47,86.75) ; UD1.3 82.7,43.27 82.24,43.72 v1(81.71,43.72) ; v1(81.38,126.45) 81.07,126.15 CI7.2 ; CZ92.2 v1(281.53,67.47) ; PC1049.2 134.59,94.04 v1(134.42,93.86) ; PC1084.2 151.81,98.09 v1(151.75,98.03) ; v1(239.28,77.21) 238.73,76.67 CE4.2 239.42,75.35 RE24.2 ; CR42.2 269.92,85.49 CR8.2 ; v1(244.24,114) 244.57,113.67 CV510.2 244.57,112.76 CV62.2 ; CL7.2 267.7,91.69 v1(267.74,91.73) ; v1(147.19,99.44) 147.24,99.39 PC1045.2 ; PC1054.2 152.37,101.23 151.86,101.74 v1(151.4,101.74) ; v1(281.7,70.77) 281,70.77 280.36,70.14 CZ89.2 ; CZ34.2 269.09,69.45 v1(268.96,69.33) ; RV607.1 226.41,106.28 226.41,106.97 v1(225.47,106.97) ; CZ18.2 261.77,52.61 CZ16.2 ; PC1031.2 155.14,99.74 v1(155.4,99.49) ; CZ50.2 v1(285.58,113.7) ; CE18.2 260.58,57.76 v1(260.32,57.5) ; PC1053.2 149.58,101.09 v1(148.92,101.74) ; v1(11.28,38.24) 10.93,37.89 CN42.2 ; CZ94.2 294.49,8.92 PR506.2 ; 21.44,37.88 20.86,37.31 CZ60.2 ; PC1036.2 148.52,98.91 v1(149.06,99.45) ; PC1088.2 154.06,99.81 153.69,99.45 v1(153.63,99.45) ; v1(243.76,125.71) 243.86,125.81 CV69.2 244.47,126.54 CV61.2 ; v1(240.81,64.99) 241.08,64.99 241.6,64.47 CE3.2 ; v1(6.83,58.71) 6.48,58.35 PQ911.4 ; v1(286.31,14.97) 285.98,15.3 CZ48.2 ; v1(157.24,98.03) 157.24,98.55 PC1033.2 ; CL4.2 268.4,93.87 CL3.2 ; v1(269.59,111.88) CL21.2 CL20.2 ; CR36.2 266.66,76.16 CR43.2 ; v1(242.15,106.71) 240.89,106.71 240.89,105.65 RV606.1 ; RE17.1 228.27,75.6 228.83,75.6 228.83,76.21 229.18,76.56 v1(229.18,77.95) ; v1(244.14,54.79) 244.7,54.23 CZ15.2 ; CI11.2 101.89,125.22 CI12.2 ; v1(278.5,111.9) 278.48,111.91 CL16.2 CL17.2 ; CI10.2 93.55,125.32 v1(92.95,124.72) ; v1(254.2,107.1) 255.37,107.1 CL26.2 ; CE7.2 224.89,62.58 224.89,62.14 ; PC1149.2 161.63,96.6 v1(161.72,96.52) ; PC1037.2 v1(153.02,89.49) ; v1(46.2,57.1) 45.86,57.44 CN29.2 ; CZ39.2 v1(285.86,103.16) ; v1(244.73,65.74) 244.93,65.95 245.72,65.95 ; CV66.2 254.19,115.86 v1(254.81,116.48) ; CA46.2 288.64,77.19 CA47.2 v1(289.62,76.74) ; CC28.2 130.17,124.6 v1(130.25,124.52) 130.13,124.41 CC29.2 ; PU902.3 64.73,72.96 64.17,72.4 PQ902.1 63.99,70.28 63.5,70.77 62.93,70.77 62.63,70.48 62.63,68.28 63.08,67.84 v1(64.06,67.84) ; v1(153.58,98.03) 153.3,98.32 PC1051.2 ; PC1034.2 155.47,98.1 v1(155.41,98.03) ; 226.41,111.54 226.41,110.85 RV609.1 ; v1(145.35,88.16) 145.15,88.36 PC1089.2 ; 259.69,75.6 258.8,75.6 258.8,76.18 v1(258.4,76.58) ; CD31.2 149.49,49.78 CD32.2 ; v1(243.66,55.18) 243.58,55.1 243.58,54.24 243.81,54.01 CZ17.2 ; PC1052.2 158.6,101.35 v1(159.04,101.8) ; CZ2.2 100.06,117.65 v1(100.06,117.69) ; CL27.2 266.8,110.78 v1(266.8,112.29) ; v1(281.59,68.18) 281.67,68.1 CA50.2 ; CL25.2 255.5,110.93 255.05,111.37 v1(254.51,111.37) ; CL8.2 261.97,87.97 v1(261.13,87.13) ; PC1097.2 149.68,99.69 v1(149.92,99.44) ; v1(252.96,57.7) CE13.2 253.51,58.71 CE14.2 ; v1(96.66,107.76) 96.56,107.76 95.65,108.66 RV2.2 ; PC1043.2 137.46,91.83 v1(137.67,92.04) ; CZ29.2 281.24,6.79 v1(281.29,6.74) ; v1(265.08,76.55) 265.15,76.62 CR13.2 ; PU1.2 v1(76.55,115.22) ; CA48.2 285.53,77.33 CA45.2 v1(286.12,75.1) ; v1(251.54,127.72) 251.53,127.72 CV70.2 ; v1(245.39,71.07) 245.97,71.65 CE17.2 ; v1(253.38,74.18) 253.48,74.18 254.52,75.22 CE20.2 254.86,75.22 255.57,75.93 CE15.2 ; CL11.2 v1(261.47,99.97) ; CL19.2 265.68,121.83 v1(265.35,121.5) ; CA11.2 283.28,72.93 v1(283.04,72.69) ; CN19.2 31.15,58.2 v1(31.48,58.53) ; v1(175.44,89.5) 175.44,89.7 174.85,90.29 CC212.2 174.1,90.29 RC338.2 ; CZ28.2 279.19,6.79 278.98,7 v1(278.98,7.66) ; v1(135.72,95.69) 135.72,95.84 136.12,96.25 PC1056.2 ; PC1083.2 PC1090.2 158.06,100.11 v1(158.08,100.14) 158.26,100.14 158.73,99.67 PC1153.2 PC1151.2 ; 251.69,95.92 v1(251.69,97.07) ; CL10.2 v1(256.13,87.17) ; PC1096.2 152.29,99.86 151.86,99.44 v1(151.74,99.44) ; CZ36.2 v1(243.15,48.8) ; v1(264.12,67.73) CE23.2
  TOP w0.406: UZ6.3 266.32,69.74 266.55,69.52 v1(266.55,69.2) ; v1(66,124.39) 66.01,124.41 DI1.3 ; DI6.3 v1(91.16,126.79) ; v1(251.5,83.96) 251.59,84.05 UE3.3 ; v1(89.35,120.06) 88.85,119.56 UC14.3 ; v1(281.4,96.55) DI7.3 ; PU101.3 207.31,81.11 v1(207.54,81.34) ; v1(280.81,14.73) 280.45,14.37 UZ10.3 ; DE1.2 79.45,90.39 79.58,90.52 CE32.2 ; UL2.3 v1(255.39,96.7)
  TOP w0.432: QE2.4 247.87,56.83 v1(248.12,56.59) ; 278.04,52.91 278.04,53.76 277.58,54.21 QA3.4 ; 278.04,52.91 QA3.1 ; 278.04,52.91 278.04,51.74 277.53,51.23 275.23,51.23 v1(275.18,51.28) ; PU903.3 v1(100.31,69.62) ; PQ907.1 v1(102.37,72.54) ; PQ907.4 v1(101.77,73.84) ; QE2.1 249.11,55.53 248.82,55.24 v1(248.82,54.24)
  TOP w0.457: PC1009.2 155.31,95.17 155.05,95.43 v1(155.05,95.8) ; CE12.2 243.3,79.61 v1(242.9,80.02) ; RC44.2 171.69,91.99 v1(171.69,92.63) ; v1(152.61,95.8) 152.61,95.43 152.87,95.17 PC1074.2 ; v1(158.16,96.06) 157.78,96.06 157.52,95.8 PC1144.2 ; PC1007.2 150.4,95.17 150.15,95.43 v1(150.15,95.8) ; v1(167.21,92.62) 167.21,93.16 CC222.2 ; v1(151.42,93.35) 151.42,92.97 151.68,92.72 PC1068.2 ; PC1006.2 150.74,91.45 v1(150.74,91.01) ; PC1072.2 150.48,92.72 150.22,92.97 v1(150.22,93.35) ; v1(252.96,57.7) 252.92,57.67 RE277.1 ; v1(175.91,87.63) 175.37,88.16 CC204.2 RC337.2 ; PC1004.2 154.37,91.43 v1(154.37,91.01) ; PC1057.2 157.52,94.6 157.78,94.85 v1(158.16,94.85) ; UE5.3 256.2,55.5 256.64,55.94 CE34.2 ; JDEG1.11 v1(276.6,12.87) ; CE52.2 250.53,54.59 v1(250.81,54.31) ; CE44.2 242.31,76.83 v1(242.31,77.55) ; PC1070.2 154.1,92.72 153.84,92.97 v1(153.84,93.35) ; v1(274.32,6.7) 274.65,6.37 JDEG1.12 ; CC27.2 165.38,71.61 v1(164.87,72.12) ; v1(153.17,91.01) 153.17,91.43 PC1071.2 ; PC1013.2 151.96,91.43 v1(151.96,91.01) ; v1(155.1,93.39) 155.1,92.96 PC1064.2 ; RC96.2 169.06,93.47 v1(169.07,93.48) ; PR416.2 233.12,39.87 v1(233.54,40.29) 233.94,40.7 PR415.2 ; PC1069.2 152.89,92.72 152.63,92.97 v1(152.63,93.35) ; RC4.2 174.33,83.26 v1(174.65,82.94) ; PC1066.2 154.09,95.17 153.83,95.43 v1(153.83,95.8) ; PC1012.2 155.59,91.43 v1(155.59,91.01) ; v1(151.38,95.8) 151.38,95.43 151.64,95.17 PC1170.2
  TOP w0.508: RZ111.2 221.28,74.93 v1(221.08,74.72) ; CD49.2 203.46,43.36 v1(203.55,43.45) ; QV2.3 85.71,111.72 v1(86.08,111.35) ; v1(191.04,48.02) 191.23,48.21 CD43.2 ; v1(140.9,95.27) 140.9,94.97 PC1130.2 ; v1(113.44,43.45) 113.43,43.44 CD4.2 ; v1(278.33,34.82) 279.13,34.02 CA23.2 ; CC217.2 161.21,91.82 v1(161.72,92.33) ; RV70.1 248.87,127.33 v1(249.26,127.72) ; v1(238.78,131.26) 240.19,129.86 QV4.3 ; PR831.1 PC833.2 59.24,60.4 v1(58.62,60.4) ; PC424.2 235.68,86.85 236.18,86.36 v1(237.17,86.36) ; PD7.1 79.27,106.46 v1(78.43,105.62) ; v1(176.21,69.46) 176.21,69.49 176.26,69.54 178.14,69.54 178.71,70.11 CC6.1 CC5.1 ; CC255.2 150.65,73.14 v1(150.18,72.66) ; v1(120.62,111.29) 120.24,111.29 PC1073.2 ; v1(189.51,48.02) 189.66,48.16 CD46.2 ; RA35.2 301.42,62.87 v1(301.52,62.77) ; PR424.2 v1(239.42,87.11) ; v1(217.66,124.68) 216.98,124 RV75.2 ; v1(270.05,92.36) 269.54,91.86 RL3.1 ; v1(121.62,48.02) 121.63,48.02 CD19.2 ; v1(228.61,48.52) 228.48,48.65 CD64.2 228.32,49.26 CD63.2 ; CC33.2 127.06,127.86 v1(126.88,127.68) ; PC1137.2 114.59,88.55 v1(114.59,88.93) ; CD15.2 116.75,48.04 v1(116.73,48.02) ; v1(89.88,51.08) 89.85,51.1 CD83.2 ; CD73.2 152.73,49.04 v1(152.61,48.93) ; v1(94.7,90.42) 94.68,90.39 PC654.1 PC651.1 ; v1(170.95,99.42) 170.72,99.19 RC312.1 ; DI2.1 69.68,125.41 v1(68.81,124.53) ; v1(298.35,14.37) 298.75,14.78 PR510.2 ; v1(121.62,43.45) 121.83,43.24 CD12.2 ; CD48.2 203.55,48.03 v1(203.55,48.02) ; v1(137.51,129.08) 136.89,129.7 D20.1 136.65,130.84 136.43,131.06 C318.2 ; v1(295.2,7.51) 295.11,7.6 PR506.2 ; CC205.2 162.93,89.48 v1(162.37,88.91) ; CA24.2 280.13,26.71 v1(279.73,27.11) ; v1(225.31,110.37) 225.31,109.96 224.67,109.32 CV113.2 ; v1(225.31,110.37) 225.31,110.56 225.03,110.84 224.39,110.84 RV73.2 ; v1(225.31,110.37) 225.46,110.52 RV609.1 ; CD79.2 131.01,40.13 v1(131.12,40.24) ; RV616.2 v1(243.65,114.72) ; v1(200.26,43.45) 200.28,43.43 CD50.2 ; CD45.2 192.57,48.02 v1(192.56,48.02) ; v1(183.96,47.26) 185.1,47.26 185.3,47.46 CD96.2 ; v1(263.28,76.98) 263.67,77.38 RR20.2 ; v1(129.29,94.63) 129.29,94.29 PC1135.2 ; RV100.2 v1(251.31,114.13) ; RV1.2 95.69,111.72 v1(95.69,111.97) ; v1(225.47,106.22) 225.32,106.22 225.12,106.42 YV2.2 ; CA53.2 281.53,71.84 281.85,72.16 v1(282.1,72.16) ; v1(110.29,43.45) 110.37,43.37 CD8.2 ; CL14.1 265.02,99.98 v1(264.89,100.11) ; CA41.2 282.87,61.63 QA1.3 282.87,62.32 v1(281.63,63.56) ; v1(152.63,74.74) 152.08,74.74 CC175.2 ; CD6.2 107.74,45.78 108.46,46.49 v1(108.77,46.49) ; v1(92.88,51.08) 93.19,51.39 CD86.2 ; CC265.2 164.98,90.01 v1(164.98,90.65) ; v1(138.95,100.71) 138.93,100.69 RC114.2 ; v1(112.06,126.6) 112.2,126.46 CZ95.2 ; v3(229.72,83.65) v1(229.72,83.03) ; CD29.2 147.93,45.21 147.4,45.73 v1(147.31,45.73) ; RN54.2 v1(29.37,49.31) ; RN66.2 47.47,56.42 v1(47.98,55.91) 47.47,55.41 RN67.2 ; v1(186.22,40.28) 186.22,39.99 186.65,39.57 CD102.2 ; v1(12.93,37.8) 12.68,37.56 CZ61.2 ; v1(201.91,43.45) 201.89,43.43 CD97.2 ; v1(260.17,86.61) 260.28,86.5 262.51,86.5 CL12.2 ; PC1025.2 137.53,90.41 v1(138.22,91.11) ; v1(303.6,56.04) CR40.1 302.8,56.94 CR41.1 ; PC101.1 204.94,80.27 v1(204.89,80.22) ; v1(80.72,96.91) 80.72,97.83 80.53,98.02 PQ1.6 ; v1(243.28,123.69) 243.81,123.69 RV68.1 ; CC203.2 165.57,97.28 v1(165.64,97.35) ; CC178.2 152.28,71.04 v1(152.63,71.39) ; PC411.2 243.49,96.36 v1(243.94,96.81) 244.38,96.36 PR407.2 ; CV115.2 221.31,109.32 221.03,109.04 v1(221.03,108.17) 221.18,108.02 YV2.4 ; v1(161.74,88.18) 161.74,88.02 161.19,87.47 CC213.2 ; v1(281.48,69.13) 281.37,69.25 CZ90.2 ; v1(113.13,105.89) 112.75,105.89 PC1077.2 ; RV65.2 v1(249.12,111.78) ; v1(123.04,111.54) 122.65,111.54 PC1173.2 ; CC210.2 178.56,115.64 178.09,116.11 v1(177.2,116.11) ; v1(156.19,72.79) 156.26,72.72 156.43,72.72 156.76,72.39 CC256.2 ; CC26.2 183.03,89.44 v1(183.26,89.67) ; PC1.2 78.5,103.39 v1(78.85,103.39) ; v1(24.01,48.73) 24.67,49.39 RN40.2 ; v1(222.31,62.85) 222.87,63.41 CE7.2 ; v1(265.08,74.84) 266.19,74.84 266.66,75.31 CR43.2 ; CC23.2 179.37,88.43 v1(179.37,87.16) ; v1(265.2,54.82) 265.2,55.14 CE21.2 CE1.2 ; PC410.2 232.69,42.71 v1(232.48,42.91) ; CR23.2 271.33,77.5 v1(271.29,77.54) ; CA19.2 279.28,31.33 v1(279.07,31.11) ; v1(87.62,40.43) 87.62,40.59 CD84.2 ; CA13.1 v1(286.36,49.5) ; v1(273.89,89.16) 273.58,88.86 CZ55.2 273.16,87.96 CZ54.2 ; v1(208.47,40.27) 208.47,39.62 RD74.2 208.58,39.53 209.41,39.53 ; v1(232.15,87.05) 231.73,87.05 PR310.2 PR302.2 ; CI11.2 101.89,124.02 v1(101.05,123.19) ; v1(246.59,111.73) 247.09,112.23 RV64.2 RV62.2 ; v1(49.57,57.06) 49.03,57.59 PC828.2 ; v1(246.45,85.87) 246.69,86.11 PR420.2 ; v1(76.31,124.71) 76.02,125 UI1.2 ; CR35.2 271.26,85.07 271.56,84.77 v1(271.56,84.45) ; PC834.1 59.28,62.71 59.09,62.9 v1(59.09,63.15) ; v1(169.22,40.24) 169.62,39.85 CD109.2 ; v1(252.94,91.82) 253.41,92.29 253.69,92.29 RL12.2 253.9,92.64 252.99,93.54 CL28.2 ; v1(281.61,75.99) 281.61,75.37 281.79,75.19 CA54.2 ; YL1.2 v1(265.7,97.23) ; CD78.2 125.16,43.42 v1(125.13,43.45) ; v1(269.5,86.33) 270.02,85.81 CR42.2 ; v1(201.91,48.02) 201.78,48.15 CD41.2 ; PC621.1 83.93,81.43 v1(83.79,81.57) PR631.1 ; RV620.2 v1(239.65,110.78) ; v1(48.07,54.39) RN73.2 ; CD25.2 148.23,44.21 v1(147.31,44.21) ; v1(81.01,90.22) 80.71,90.52 CE32.2 ; v1(107.81,113.36) 107.29,112.84 106.93,112.84 QV7.3 ; v1(97.6,124.8) 97.52,124.88 UI2.2 ; v1(253.72,126.6) 253.92,126.4 CV60.2 ; v1(264.12,67.73) 264.78,68.39 RE88.2 ; v1(168.79,112.95) 168.79,111.43 CC216.2 ; CZ19.2 242.24,54.45 241.61,53.83 241.61,51.95 242.28,51.29 v1(242.28,51.14) ; PR608.2 PR611.2 v1(81.81,91.5) ; v1(258.4,76.58) 258.04,76.21 RE56.1 ; CE34.2 256.99,55.74 v1(256.99,55.38) ; v1(197.45,43.43) 197.34,43.32 CD51.2 ; v1(277.23,106.16) 277.43,105.95 RI14.1 ; CD92.2 114.42,51.94 v1(113.9,51.42) ; CD108.2 176.13,39.45 175.73,39.86 v1(175.73,40.24) ; CZ16.2 CZ20.2 v1(262.99,53.64) ; v1(287.06,61.19) 287.06,61.19 287.06,60.96 284.12,58.01 RA37.2 ; CA12.2 v1(286.93,48.04) ; PC1075.2 114.97,96.05 v1(114.97,96.43) ; RL13.2 263.88,99.73 v1(263.56,100.05) ; PC1023.2 127.77,94.23 v1(127.77,94.63) ; v1(81.63,124.71) 81.34,125 CI6.2 ; v1(215.4,64.63) 214.98,65.05 RZ62.2 ; PQ4.3 v1(68.03,115.84) ; CE9.2 230.76,75.01 v1(231.18,74.6) ; v1(132.73,88.1) 133.06,87.77 PC1136.2 ; v1(255.42,117.42) 255.7,117.14 RV61.2 ; CC209.2 164.33,92.32 CC207.2 ; PC1010.2 120.24,113.83 v1(120.62,113.83) ; CD9.2 118.46,47.66 v1(118.44,47.64) ; v1(98.13,40.43) 98.17,40.43 CD93.2 ; v1(288.44,7.43) 288.15,7.72 PC505.2 PR505.2 ; v1(148.6,71.71) 148.6,71.39 149.4,70.58 CC295.2 ; PC1178.2 116.24,88.55 v1(116.24,88.93) ; RV608.1 225.83,108.49 v1(225.45,108.49) ; CD74.2 CD75.2 230.81,47.14 230.53,47.42 v1(230.31,47.42) ; v1(289.15,95.97) 289.05,95.87 DI5.1 ; RV617.2 v1(239.63,107.73) ; v1(138.32,93.86) 138.32,93.94 138.94,94.56 PC1029.2 ; RC167.2 159.34,88.1 v1(158.61,88.83) 158.31,89.13 PC1143.2 ; v1(85.57,117.64) 86.04,117.17 CZ115.2 ; v1(113.13,107.16) 112.72,107.16 PC1061.2 ; v1(234.67,43.96) 234.3,43.6 PR412.1 ; CZ91.2 281.42,68.36 v1(281.59,68.18) ; CD98.2 173.54,51.34 v1(173.48,51.28) ; v1(194.21,48.02) 194.03,48.2 CD42.2 ; CZ30.2 CZ31.2 285.63,12.18 285.76,12.05 v1(285.76,11.59) ; v1(192.56,43.45) 192.68,43.33 CD37.2 ; v1(133.09,118.54) 132.97,118.65 132.97,119.41 133.43,119.87 134.87,119.87 CC32.2 ; v1(158.07,71.64) 158.78,70.94 CC296.2 ; v1(73.86,97.16) PR13.2 ; CD85.2 101.04,51.16 v1(101.14,51.06) ; CC311.2 162.62,73.36 v1(162.68,73.43) 162.69,73.44 RC5.2 RC6.2 ; RN30.2 22.01,54.64 v1(21.56,55.09) 22.01,55.53 RN41.2 ; v1(191.04,43.45) 190.74,43.15 CD107.2 ; v1(265.87,54.14) 265.87,54.68 RE86.1 ; PC1026.2 146.27,92.07 v1(146.27,92.5) ; RN61.2 38.03,49.11 v1(37.89,48.97) ; CD14.2 110.32,48.05 v1(110.29,48.02) ; v1(154.41,73.44) 154.24,73.26 CC257.2 ; v1(287.55,14.39) PR509.2 PC510.2 ; v1(165.63,94) 165.63,94.3 165.9,94.57 CC211.2 ; v1(253.22,40.78) 253.72,40.78 254.06,40.43 PU1500.1 ; RV76.2 v1(224.51,113.45) RV89.2 ; CC3.1 CC4.1 175.91,70.17 175.57,69.83 v1(175.57,69.46) ; RN38.2 23.02,58.96 v1(23.09,58.9) ; v1(146.29,95.3) 146.29,94.92 146.55,94.66 PC1021.2 ; RV3.1 v1(83.72,111.29) ; CE47.2 242.64,59.27 v1(242.54,59.17) ; v1(227.72,40.23) 227.82,40.33 RD73.2 RD72.2 ; v1(143.88,73.27) 143.82,73.21 CC174.2 ; v1(135.9,99.44) 134.68,99.44 134.36,99.12 RC90.2 RC91.2 ; RD68.2 127.78,39.82 127.49,40.12 v1(127.49,40.46) 127.49,40.69 127.85,41.05 RD20.2 ; v1(71.82,117.88) 71.36,117.42 PR10.1 ; RA36.2 v1(291.37,39.45) ; v1(123.44,51.44) 123.17,51.71 CD88.2 ; v1(145.01,92.5) 145.01,92.12 PC1129.2 ; PC835.2 41.67,47.43 v1(42.11,47.87) ; RN68.2 v1(47.23,52.66) ; PD2.1 66.85,41.53 v1(66.41,41.98) ; PC905.1 104.43,70.06 104.96,70.6 v1(104.96,71.64) ; v1(154.44,45.96) 154.28,46.12 RD66.2 RD67.2 ; RZ38.1 236.38,58.5 v1(236.15,58.73) 235.93,58.5 RE299.2 ; v1(123.24,43.45) 123.49,43.19 CD16.2 ; SW3.1 v1(293,119.54) ; v1(175.56,65.22) 175.69,65.22 176.3,65.83 RC220.2 CC266.2 ; CZ52.2 273.5,89.75 273.73,89.98 v1(274.27,89.98) ; v1(137.91,72.88) 137.91,72.87 CC294.2 ; v1(245.87,76.49) 246.15,76.49 CE29.2 ; v1(89.65,126.46) 89.65,125.61 88.76,124.72 DI3.1 ; v1(257.74,47.57) 258.06,47.25 PC1500.2 ; CD57.2 227.39,42.76 v1(226.38,43.77) ; PR427.2 231.37,41.74 v1(231.28,41.83) ; v1(127.77,92.24) 127.77,91.88 PC1180.2 ; v1(198.23,51.13) 198.61,51.51 CD106.2 ; YL1.4 269.3,99.43 269.85,99.98 v1(270.16,99.98) ; RV74.2 211.16,122.41 211.62,121.95 211.62,120.96 211.43,120.77 211.43,120.19 211.87,119.74 v1(211.87,119.6) ; v1(118.44,43.06) 118.42,43.05 CD7.2 ; CC176.2 159.13,73.44 v1(159.67,73.44) ; v1(120.01,44.97) 120.03,44.95 CD80.2 ; PC813.2 v1(53.25,50.58) ; RC88.2 RC89.2 174.25,71.46 v1(174.66,71.87) ; v1(147.31,47.26) 147.45,47.26 148.05,46.66 CD28.2 ; v1(126.88,51.39) 127.2,51.71 CD87.2 ; v1(115.08,43.45) 115.05,43.42 CD17.2 ; CZ37.2 CZ46.2 243.47,47.02 v1(243.13,47.37) ; v1(285.04,66.14) 284.66,65.76 CA10.2 ; CC177.2 146.55,73.49 146.17,73.1 v1(145.93,73.1) ; CC206.2 162.39,93.97 v1(162.37,94) 162.37,94.77 CC218.2 ; v1(240.55,41.7) 240.07,41.22 PC408.2 ; CZ41.2 195.02,85.42 195.35,85.75 v1(195.35,85.99) ; v1(238.2,113.31) 238.99,114.09 CV603.2 ; CC208.2 165.96,93.08 165.63,92.75 v1(165.63,92.33) ; v1(210,43.01) 209.74,42.74 RD24.2 ; v1(140.9,92.92) 140.9,92.62 PC1132.2 ; CD18.2 113.43,48.03 v1(113.44,48.02) ; v1(123.99,128.81) 123.54,129.26 RC219.1 ; PC506.2 v1(292.02,2.57) ; PC4.2 72.63,45.46 v1(72.63,47.23) ; v1(120.01,48.02) 119.97,48.05 CD2.2 ; PC1138.2 130.82,94.29 v1(130.82,94.63) ; RC163.2 133.46,97.94 v1(132.9,97.38) ; RV621.2 v1(237.21,116.51) ; v1(286.78,43.16) 285.34,43.16 284.68,42.5 RA2.2 ; v1(227.65,47.2) 227.94,47.2 CD61.2 ; RC1.1 167.89,95.99 168.42,96.53 v1(168.42,96.78) ; CE8.2 228.39,58.19 v1(228.06,57.86) ; CE40.2 v1(244.78,66.84) ; PR1503.2 253.24,42.97 v1(253.24,43.73) ; v1(229.75,116.45) 229.21,115.91 CV605.2 ; PC906.2 v1(83.86,64.55) ; CD89.2 109.36,51.67 v1(108.88,51.19) ; v1(146.04,43.83) 147.49,42.38 CD24.2 148.02,42.36 CD26.2 ; v1(148.89,47.99) 149.46,47.99 CD71.2 CD70.2 ; CV374.2 88.06,115.17 88.33,115.44 88.33,116.27 v1(88.36,116.3) ; RC342.1 189.7,106.31 v1(189.7,105.93) ; RE55.1 255.62,58.15 v1(255.15,57.68) 255.75,57.08 RE78.2 ; PR658.1 83.41,81.02 83.09,81.34 v1(83.09,81.62) ; v1(116.24,96.43) 116.24,96.05 PC1080.2 ; v1(244.73,65.74) 244.73,64.97 CE31.2 ; v1(241.55,83.45) 241.55,83.16 241.12,82.72 RE82.1 ; JAPS1.20 194.16,62.14 v1(192.17,64.12) ; CD76.2 234.22,46.97 v1(234.63,47.38) ; v1(207.03,51.22) 207.46,51.65 CD100.2 ; CC182.2 155.66,87.45 CC252.2 156.53,87.91 v1(156.32,88.11) ; PC3.2 72.18,57.13 73,57.95 v1(73.38,57.95) ; v1(188.54,40.25) 188.48,40.19 CD99.2 ; v1(181.42,47.26) 182.12,47.26 182.39,47.53 CD95.2 ; PR403.2 241.59,42.15 v1(242.03,41.7) 242.48,42.15 PC402.2 ; v1(172.61,97.53) 172.83,97.76 RC242.1 ; v1(189.98,98.37) 190.47,97.88 CC225.2 ; PC1179.2 116.88,93 v1(116.88,92.62) ; RZ40.1 286.85,112.94 v1(286.85,113.69) ; PC1142.2 v1(158.31,91.76) ; PC1134.2 132.35,94.29 v1(132.35,94.63) ; v1(103.37,51.18) 103.71,51.51 CD81.2 ; CL4.2 269.09,92.77 v1(268.82,92.5) ; CD91.2 105.42,40.64 v1(105.62,40.43) ; CD47.2 200.25,48.02 v1(200.26,48.02) ; v1(80.44,89.8) 79.98,89.34 PC605.1 ; v1(160.89,99.44) 160.27,98.82 CC202.2 ; CD101.2 178.13,39.64 v1(178.73,40.24) ; RL9.2 268.01,87.13 v1(268.09,87.04) ; CD77.2 v1(233,47.34) ; CL18.2 v1(285.18,120.86) ; v1(87.86,94.4) PC601.2 ; PC901.2 v1(94.9,68.61) ; PR925.2 v1(84.25,75.6) ; v1(209.23,108.12) 209.26,108.09 RV79.2 ; v1(130.07,97.1) 130.07,96.84 PC1016.2 ; CC220.2 164.68,113.15 RC3.2 164.84,112.99 165.36,112.99 v1(165.45,112.9) ; PC1133.2 128.5,96.85 v1(128.5,97.11) ; v1(199.16,43.06) 198.98,42.88 CD39.2 ; RV63.2 v1(248.11,111.78) ; CD59.2 231.75,44.32 231.25,43.82 CD60.2 v1(231.25,42.92) ; CD35.2 189.93,40.34 v1(190,40.27) ; CC254.2 148.16,73.82 v1(148.6,73.82) ; PQ908.3 v1(16.21,43.45) ; CC314.2 193.3,97.33 v1(193.61,97.63) ; v1(132.33,92.2) 132.33,91.85 PC1177.2 ; RV600.2 227.43,116.05 v1(227.75,116.37) ; PC404.2 235.78,41.94 v1(235.58,42.14) ; v1(223.58,70.65) 223.71,70.52 RE20.1 ; RN46.2 33.63,55.79 v1(34.14,56.3) 33.63,56.8 RN45.2 ; CC24.2 168.6,72.45 RC48.2 166.88,72.45 RC75.1 165.99,72.45 RC7.2 165.8,72.41 165.16,73.05 165.16,74.04 RC311.1 ; CD62.2 228.1,45.68 v1(227.65,45.68) ; PC504.2 v1(282.42,2.42) ; v1(160.37,113.64) 160.37,112.98 CC199.2 ; v1(200.67,82.23) 200.17,82.74 CZ42.2 ; CE38.2 250.71,58.53 RE77.2 249.86,59.24 v1(249.4,58.78) ; RN47.2 v1(32.04,49.37) ; v1(129.29,92.24) 129.29,91.87 PC1181.2 ; CV10.2 v1(88.86,107.11) ; CE45.2 245.39,77.12 v1(245.87,77.12) ; RZ27.2 v1(277.59,22.77) ; CZ113.2 115.33,72.08 116.62,73.38 v1(116.62,76.4) ; JTAG1.2 261.5,78.88 v1(261.1,79.28) 260.58,78.76 RE65.2 CE30.2 ; v1(75.54,57.49) PC218.2 ; CD27.2 150.92,44.5 v1(150.57,44.85) ; v1(205.32,43.46) 205.32,43.45 CD44.2 ; CD31.2 150.16,49.77 v1(150.42,49.51) ; v1(78.71,102.71) 79.04,102.71 PR15.2 ; RN74.2 v1(43.53,49.49) ; PR929.2 89.38,73.86 v1(89.74,73.5) ; PC511.2 v1(293.84,21.04) ; CZ77.2 211.53,74.38 v1(211.53,73.61) ; PC903.1 68.54,72.25 v1(68.89,71.89) ; v1(156.23,70.89) 155.8,70.89 CC179.2 ; RN59.2 v1(38.07,59.62) ; CN20.2 22.01,51.98 v1(21.56,52.42) 22.01,52.87 RN52.2 ; PC1019.2 115.22,93 v1(115.22,92.62) ; v1(160.49,91.08) 160.49,90.61 CC288.2 160.69,90.41 CC215.2 ; RN39.2 v1(21.47,58.2) ; v1(205.32,48.03) 205.33,48.04 CD40.2 ; R271.2 C311.2 v1(143.86,134.49) ; v1(130.82,92.24) 130.82,91.9 PC1131.2 ; CD105.2 170.69,51.49 v1(170.48,51.28) ; SW3.3 v1(297.08,119.53) ; v1(115.08,48.02) 115.08,48.03 CD10.2 ; RV77.2 v1(224.51,114.72) RV78.2 ; v1(221.47,40.41) 221.78,40.1 CD94.2 ; v1(120.62,112.56) 120.24,112.56 PC1002.2 ; RV50.2 252.55,124.04 v1(251.74,123.22) ; v1(241.42,112.28) 241.22,112.08 CV604.2 ; v1(278.37,38.77) 278.55,38.95 CA22.2 ; PD3.1 v1(65.12,42.49) ; CD90.2 v1(119.38,52.14) ; CV9.2 v1(90.02,110.08) ; v1(21.56,36.74) CZ60.2 ; CC274.2 v1(191.09,94.23) ; v1(94.03,73.78) 94.03,73.79 PQ906.3 93.6,75.04 PR837.2 ; v1(250.49,43.73) 250.49,44.05 250.87,44.43 PR1502.2 PC1504.2 ; v1(242.24,85.87) PR428.2 PC420.2 242.14,87.55 PR419.2 ; PC507.2 288.08,16.82 v1(288.08,16.21) ; CD11.2 111.85,48.05 v1(111.82,48.02) ; v1(225.4,57.48) 225.73,57.81 RE21.1 ; v1(195.13,52.04) 195.15,52.05 CD104.2 ; v1(270.01,95.69) 269.07,95.69 CL13.1 ; CE36.2 259.65,59.29 v1(259.81,59.46) ; CD52.2 194.02,43.25 v1(194.21,43.45) ; PC216.2 v1(74.27,58.33) ; v1(298.49,72.04) CA49.1 ; v1(227.65,44.15) 227.67,44.18 CD58.2 ; RN62.2 35.85,55.15 v1(35.41,54.71) 35.85,54.26 RN31.2 ; JAPS1.19 181.46,62.56 ; CD72.2 v1(151.48,48.9) ; PC1024.2 134.98,90.99 135.07,91.08 v1(135.07,91.18) ; PC1028.2 139.25,91.74 v1(139.58,91.41) ; RN60.2 v1(35.41,57.82) ; PC502.1 v1(293.22,2.24) ; PC508.2 v1(292.67,21.04) ; v1(195.84,43.45) 195.5,43.11 CD38.2 ; CE10.2 v1(245.84,78.44) ; UV24.2 v1(85.95,108.1) ; RN72.2 35.85,52.49 v1(35.41,52.04) 35.85,51.6 CN30.2 ; v1(282.29,76.6) 282.65,76.6 282.99,76.26 CA31.2 ; v1(256.52,81.95) 256.13,81.56 RE313.2 255.33,80.48 256.13,79.68 RE58.2 ; v1(94.89,70.71) 94.6,70.71 PR934.2 ; v1(283.46,71.83) 283.57,71.72 CA33.2 ; CD82.2 133.39,51.38 v1(133.37,51.39) ; DA6.1 v1(284.17,36.48) ; v1(108.77,43.45) 109.19,43.02 CD13.2 ; v1(125.45,111.54) 125.07,111.54 PC1172.2 ; CR9.2 270.04,74.34 v1(269.94,74.24) ; PC313.2 v1(230.22,82.14) ; PC6.2 v1(69.19,99.48) ; v1(87.21,62.06) 87.21,62.7 PC908.2 ; CZ38.2 281.68,110.02 v1(281.56,110.14) ; RV618.2 240.17,108.8 v1(239.63,109.33) 240.01,109.71 RV619.2 ; v1(145.03,95.3) 145.03,94.92 PC1020.2 ; v1(211.73,40.24) 211.73,40.93 RD25.2 ; v1(111.82,43.45) 111.88,43.38 CD3.2 ; PU501.2 v1(289.93,5.75) ; PD6.1 77.29,111.92 77.67,111.54 v1(78.25,111.54) ; RE85.2 232.84,58.07 v1(233.26,57.65) ; PC312.2 v1(228.95,80.04) ; CE28.2 249.28,76.8 v1(249.28,76.26) ; RV67.1 v1(239.82,120.7) ; CZ23.2 v1(281.58,111.03) ; PU502.1 v1(297.24,14.41) ; PC814.2 v1(58.86,50.74) ; PC501.2 v1(283.69,2.4) ; DA7.1 v1(284.17,28.99) ; v1(76.81,57.49) PC220.2 ; PC907.2 v1(95.48,67.47) ; RN53.2 v1(33.39,54.16)
  GND1 w0.203: JMDP1.7 213.79,131.93 ; JMDP1.7 212.91,131.05 ; JMDP1.7 213.9,131.49 ; JMDP1.7 213.35,130.94 ; JMDP1.7 212.91,131.93 ; JMDP1.7 213.35,132.04 ; JMDP1.7 213.79,131.05 ; 226,139.45 JHDMI1.22 ; JHDMI1.22 228.1,139.45 ; JHDMI1.22 226,137.9 ; JHDMI1.22 227.05,137.9 ; JHDMI1.22 226,141 ; JHDMI1.22 228.1,141 ; JHDMI1.22 228.1,137.9 ; JHDMI1.22 227.05,141 ; H28.1 237.91,36.88 ; H28.1 235.59,36.88 ; H28.1 235.19,38.04 ; H28.1 235.59,39.19 ; H28.1 236.75,36.47 ; H28.1 236.75,39.6 ; H28.1 237.91,39.19 ; H28.1 238.31,38.04 ; H20.1 186.43,133.97 ; H20.1 186.85,135.15 ; H20.1 186.43,136.33 ; H20.1 183.65,135.15 ; H20.1 184.07,133.97 ; H20.1 184.07,136.33 ; H20.1 185.25,133.55 ; H20.1 185.25,136.75 ; H16.1 3.47,47.37 ; H16.1 1.03,47.37 ; H16.1 3.9,46.15 ; H16.1 2.25,47.8 ; H16.1 3.47,44.93 ; H16.1 0.6,46.15 ; H16.1 1.03,44.93 ; H16.1 2.25,44.5 ; 126.22,137.56 JDOCK1.159 ; JDOCK1.159 128.25,137.56 ; JDOCK1.159 128.25,139.39 ; JDOCK1.159 126.22,138.48 ; JDOCK1.159 130.28,138.48 ; JDOCK1.159 130.28,139.39 ; JDOCK1.159 126.22,139.39 ; 245.55,137.9 JHDMI1.23 ; JHDMI1.23 246.6,137.9 ; JHDMI1.23 245.55,141 ; JHDMI1.23 244.5,141 ; JHDMI1.23 244.5,137.9 ; JHDMI1.23 244.5,139.45 ; JHDMI1.23 246.6,141 ; JHDMI1.23 246.6,139.45 ; 157.97,133.77 JDOCK1.157 ; JDOCK1.157 158.75,135.58 ; JDOCK1.157 157.72,134.55 ; JDOCK1.157 158.75,133.52 ; JDOCK1.157 159.78,134.55 ; JDOCK1.157 159.53,133.77 ; JDOCK1.157 159.53,135.33 ; JDOCK1.157 157.97,135.33 ; JMDP1.19 217.49,132.25 ; JMDP1.19 217.05,133.24 ; JMDP1.19 216.61,132.25 ; JMDP1.19 216.61,133.13 ; JMDP1.19 217.49,133.13 ; JMDP1.19 217.6,132.69 ; JMDP1.19 217.05,132.14 ; JDOCK1.162 177.25,139.39 ; JDOCK1.162 179.28,139.39 ; JDOCK1.162 175.22,138.48 ; JDOCK1.162 177.25,137.56 ; JDOCK1.162 179.28,137.56 ; JDOCK1.162 175.22,139.39 ; JDOCK1.162 179.28,138.48 ; 182.07,105.81 H3.1 ; H3.1 185.15,105.81 ; H3.1 183.61,102.16 ; H3.1 181.5,104.27 ; H3.1 185.72,104.27 ; H3.1 183.61,106.38 ; H3.1 185.15,102.73 ; H3.1 182.07,102.73 ; JDOCK1.153 159.78,130.63 ; JDOCK1.153 158.75,131.58 ; JDOCK1.153 157.72,131.58 ; JDOCK1.153 157.72,130.63 ; JDOCK1.153 159.78,129.67 ; JDOCK1.153 158.75,129.67 ; JDOCK1.153 157.72,129.67 ; JDOCK1.153 159.78,131.58 ; H17.1 4.55,53.15 ; H17.1 4.08,54.48 ; H17.1 2.75,54.95 ; H17.1 1.42,54.48 ; H17.1 0.95,53.15 ; H17.1 1.42,51.82 ; H17.1 4.08,51.82 ; H17.1 2.75,51.35 ; JNGFF3.68 28.05,29.04 ; JNGFF3.68 27.45,27.86 ; JNGFF3.68 27.45,30.22 ; JNGFF3.68 28.05,30.22 ; JNGFF3.68 28.05,27.86 ; 231.85,132.32 JHDMI1.2 ; JHDMI1.2 232.75,132.32 ; JHDMI1.2 232.3,132.43 ; JHDMI1.2 232.75,131.42 ; JHDMI1.2 231.85,131.42 ; JHDMI1.2 231.74,131.87 ; JHDMI1.2 232.3,131.31 ; JHDMI1.11 237.25,132.92 ; JHDMI1.11 236.8,133.93 ; JHDMI1.11 236.8,132.81 ; JHDMI1.11 237.25,133.82 ; JHDMI1.11 236.35,132.92 ; JHDMI1.11 236.35,133.82 ; H10.1 203.97,96.06 ; H10.1 200.81,96.06 ; H10.1 202.39,96.64 ; H10.1 200.81,92.9 ; H10.1 204.55,94.48 ; H10.1 202.39,92.32 ; H10.1 200.23,94.48 ; H10.1 203.97,92.9 ; JMDP1.21 220.6,135.65 ; JMDP1.21 220.6,136.93 ; JMDP1.21 220.6,134.37 ; JMDP1.21 219.85,134.37 ; JMDP1.21 219.85,136.93 ; 242.7,130.74 JHDMI1.21 ; JHDMI1.21 242.7,132.47 ; JHDMI1.21 244.4,132.47 ; JHDMI1.21 243.55,130.74 ; JHDMI1.21 242.7,134.2 ; JHDMI1.21 244.4,130.74 ; JMDP1.13 215.79,131.05 ; JMDP1.13 214.91,131.05 ; JMDP1.13 215.35,132.04 ; JMDP1.13 214.91,131.93 ; JMDP1.13 215.79,131.93 ; JMDP1.13 214.8,131.49 ; JMDP1.13 215.35,130.94 ; JLOM1.14 285.86,134.12 ; JLOM1.14 284.97,134.12 ; JLOM1.14 285.86,135.85 ; JLOM1.14 284.97,137.58 ; 208.85,129.37 JMDP1.24 ; JMDP1.24 208.85,131.93 ; JMDP1.24 208.1,130.65 ; JMDP1.24 209.6,130.65 ; JMDP1.24 208.1,129.37 ; JMDP1.24 208.1,131.93 ; JMDP1.24 209.6,129.37 ; JDOCK1.154 179.28,129.71 ; JDOCK1.154 177.25,129.71 ; JDOCK1.154 175.22,129.71 ; JDOCK1.154 177.25,131.54 ; JDOCK1.154 179.28,131.54 ; JDOCK1.154 179.28,130.63 ; 300.57,128.47 H22.1 ; H22.1 301.75,128.05 ; H22.1 300.15,129.65 ; H22.1 303.35,129.65 ; H22.1 302.93,130.83 ; H22.1 301.75,131.25 ; H22.1 300.57,130.83 ; H22.1 302.93,128.47 ; 145.72,137.52 JDOCK1.160 ; JDOCK1.160 146.75,139.43 ; JDOCK1.160 146.75,137.52 ; JDOCK1.160 147.78,137.52 ; JDOCK1.160 147.78,138.48 ; JDOCK1.160 145.72,138.48 ; JDOCK1.160 147.78,139.43 ; JDOCK1.160 145.72,139.43 ; H15.1 7.97,40.48 ; H15.1 5.53,38.04 ; H15.1 6.75,37.61 ; H15.1 5.53,40.48 ; H15.1 6.75,40.91 ; H15.1 7.97,38.04 ; H15.1 5.1,39.26 ; H15.1 8.4,39.26 ; JMDP1.1 212.09,132.25 ; JMDP1.1 211.65,132.14 ; JMDP1.1 211.65,133.24 ; JMDP1.1 211.21,133.13 ; JMDP1.1 212.09,133.13 ; JMDP1.1 211.1,132.69 ; JMDP1.1 211.21,132.25 ; H11.1 288.95,87.75 ; H11.1 288.53,88.93 ; H11.1 287.35,86.15 ; H11.1 286.17,88.93 ; H11.1 287.35,89.35 ; H11.1 288.53,86.57 ; H11.1 285.75,87.75 ; H11.1 286.17,86.57 ; JDOCK1.148 178.81,136.38 ; JDOCK1.148 177.92,136.38 ; JDOCK1.148 178.81,132.72 ; JDOCK1.148 178.81,134.55 ; JDOCK1.148 177.92,132.72 ; JDOCK1.158 171.53,135.33 ; JDOCK1.158 171.53,133.77 ; JDOCK1.158 171.78,134.55 ; JDOCK1.158 169.97,135.33 ; JDOCK1.158 169.72,134.55 ; JDOCK1.158 169.97,133.77 ; JDOCK1.158 170.75,135.58 ; JDOCK1.158 170.75,133.52 ; 82.55,131.8 JUSB2.11 ; JUSB2.11 84.25,130.05 ; JUSB2.11 82.55,130.05 ; JUSB2.11 83.4,133.55 ; JUSB2.11 82.55,133.55 ; JUSB2.11 83.4,130.05 ; H13.1 300.75,12.25 ; H13.1 301.93,9.47 ; H13.1 299.57,11.83 ; H13.1 302.35,10.65 ; H13.1 299.15,10.65 ; H13.1 301.93,11.83 ; H13.1 300.75,9.05 ; H13.1 299.57,9.47 ; JDOCK1.161 158.75,139.43 ; JDOCK1.161 159.78,137.52 ; JDOCK1.161 159.78,139.43 ; JDOCK1.161 158.75,137.52 ; JDOCK1.161 157.72,138.48 ; JDOCK1.161 157.72,137.52 ; JDOCK1.161 157.72,139.43 ; JDOCK1.161 159.78,138.48 ; JMDP1.22 220.6,131.93 ; JMDP1.22 219.85,129.37 ; JMDP1.22 219.1,130.65 ; JMDP1.22 220.6,129.37 ; JMDP1.22 219.85,131.93 ; JMDP1.22 219.1,129.37 ; JMDP1.22 220.6,130.65 ; H21.1 251.93,138.27 ; H21.1 249.57,140.63 ; H21.1 250.75,141.05 ; H21.1 249.57,138.27 ; H21.1 250.75,137.85 ; H21.1 252.35,139.45 ; H21.1 249.15,139.45 ; H21.1 251.93,140.63 ; 298.17,90.15 JUSB3.12 ; JUSB3.12 300.97,89.3 ; JUSB3.12 298.17,89.3 ; JUSB3.12 299.57,89.3 ; JUSB3.12 300.97,90.15 ; H7.1 236.22,96.38 ; H7.1 236.76,97.85 ; H7.1 232.74,97.85 ; H7.1 234.75,95.84 ; H7.1 233.28,99.32 ; H7.1 234.75,99.86 ; H7.1 236.22,99.32 ; H7.1 233.28,96.38 ; 4.35,30.22 JNGFF3.69 ; JNGFF3.69 4.95,27.86 ; JNGFF3.69 4.35,27.86 ; JNGFF3.69 4.35,29.04 ; JNGFF3.69 4.95,30.22 ; 181.5,82.13 H4.1 ; H4.1 185.15,80.59 ; H4.1 183.61,84.24 ; H4.1 182.07,80.59 ; H4.1 185.72,82.13 ; H4.1 183.61,80.02 ; H4.1 182.07,83.67 ; H4.1 185.15,83.67 ; SW1.5 184.89,122 ; SW1.5 183.4,122 ; SW1.5 185.13,122.75 ; SW1.5 184.15,121.77 ; SW1.5 183.17,122.75 ; SW1.5 184.15,123.72 ; SW1.5 184.89,123.49 ; SW1.5 183.4,123.49 ; JUSB2.10 99.95,133.55 ; JUSB2.10 99.1,130.05 ; JUSB2.10 98.25,130.05 ; JUSB2.10 99.1,133.55 ; JUSB2.10 99.95,130.05 ; JUSB2.10 99.95,131.8 ; JUSB1.13 76.1,139.91 ; JUSB1.13 76.95,138.6 ; JUSB1.13 76.95,139.91 ; JUSB1.13 76.1,137.29 ; JUSB1.13 76.95,137.29 ; JUSB2.4 88.37,128.75 ; JUSB2.4 87.75,130.17 ; JUSB2.4 86.95,129.37 ; JUSB2.4 87.13,129.99 ; JUSB2.4 88.37,129.99 ; JUSB2.4 87.75,128.57 ; JUSB2.4 87.13,128.75 ; JUSB2.4 88.55,129.37 ; JUSB2.13 99.1,139.91 ; JUSB2.13 99.95,137.29 ; JUSB2.13 99.95,139.91 ; JUSB2.13 99.95,138.6 ; JUSB2.13 99.1,137.29 ; 121.68,104.27 H1.1 ; H1.1 122.25,102.73 ; H1.1 123.79,102.16 ; H1.1 125.9,104.27 ; H1.1 122.25,105.81 ; H1.1 123.79,106.38 ; H1.1 125.33,102.73 ; H1.1 125.33,105.81 ; JUSB2.7 91.87,130.25 ; JUSB2.7 92.05,130.87 ; JUSB2.7 90.63,130.25 ; JUSB2.7 91.25,130.07 ; JUSB2.7 90.45,130.87 ; H2.1 125.9,82.13 ; H2.1 125.33,80.59 ; H2.1 123.79,84.24 ; H2.1 121.68,82.13 ; H2.1 123.79,80.02 ; H2.1 125.33,83.67 ; H2.1 122.25,80.59 ; H2.1 122.25,83.67 ; 290.72,105.85 JUSB3.10 ; JUSB3.10 292.47,106.7 ; JUSB3.10 290.72,105 ; JUSB3.10 290.72,106.7 ; JUSB3.10 294.22,105.85 ; JUSB3.10 294.22,106.7 ; 265.04,137.58 JLOM1.16 ; JLOM1.16 265.92,137.58 ; JLOM1.16 265.04,135.85 ; JLOM1.16 265.92,134.12 ; JLOM1.16 265.04,134.12 ; 190.45,121.77 SW1.4 ; SW1.4 191.19,123.49 ; SW1.4 190.45,123.72 ; SW1.4 189.47,122.75 ; SW1.4 189.7,123.49 ; SW1.4 189.7,122 ; SW1.4 191.43,122.75 ; SW1.4 191.19,122 ; 233.35,132.92 JHDMI1.5 ; JHDMI1.5 233.35,133.82 ; JHDMI1.5 233.8,133.93 ; JHDMI1.5 234.25,132.92 ; JHDMI1.5 234.25,133.82 ; JHDMI1.5 233.8,132.81 ; H12.1 299.97,40.48 ; H12.1 297.1,39.26 ; H12.1 297.53,38.04 ; H12.1 298.75,37.61 ; H12.1 299.97,38.04 ; H12.1 300.4,39.26 ; H12.1 297.53,40.48 ; 146.75,133.52 JDOCK1.156 ; JDOCK1.156 147.53,135.33 ; JDOCK1.156 145.97,133.77 ; JDOCK1.156 147.78,134.55 ; JDOCK1.156 145.72,134.55 ; JDOCK1.156 146.75,135.58 ; JDOCK1.156 147.53,133.77 ; JDOCK1.156 145.97,135.33 ; JUSB3.4 290.75,101.5 ; JUSB3.4 290.61,102.02 ; JUSB3.4 289.43,101.5 ; JUSB3.4 290.09,102.16 ; JUSB3.4 290.09,100.84 ; JUSB3.4 290.61,100.98 ; JUSB3.4 289.57,100.98 ; JUSB3.4 289.57,102.02 ; 234.85,132.32 JHDMI1.8 ; JHDMI1.8 235.3,131.31 ; JHDMI1.8 235.3,132.43 ; JHDMI1.8 235.75,132.32 ; JHDMI1.8 234.85,131.42 ; JHDMI1.8 235.75,131.42 ; JDOCK1.155 134.75,135.58 ; JDOCK1.155 133.97,135.33 ; JDOCK1.155 135.53,133.77 ; JDOCK1.155 133.72,134.55 ; JDOCK1.155 134.75,133.52 ; JDOCK1.155 135.53,135.33 ; JDOCK1.155 133.97,133.77 ; JDOCK1.155 135.78,134.55 ; 290.72,89.3 JUSB3.13 ; JUSB3.13 294.22,89.3 ; JUSB3.13 294.22,90.15 ; JUSB3.13 290.72,90.15 ; JUSB3.13 292.47,89.3 ; JUSB3.13 290.72,91 ; 82.55,139.91 JUSB2.12 ; JUSB2.12 83.4,139.91 ; JUSB2.12 83.4,137.29 ; JUSB2.12 82.55,137.29 ; JUSB2.12 82.55,138.6 ; JUSB1.4 65.55,129.37 ; JUSB1.4 64.13,128.75 ; JUSB1.4 64.75,130.17 ; JUSB1.4 64.75,128.57 ; JUSB1.4 63.95,129.37 ; JUSB1.4 64.13,129.99 ; JUSB1.4 65.37,129.99 ; JUSB1.4 65.37,128.75 ; 60.4,130.05 JUSB1.11 ; JUSB1.11 60.4,133.55 ; JUSB1.11 59.55,133.55 ; JUSB1.11 61.25,130.05 ; JUSB1.11 59.55,130.05 ; JUSB1.11 59.55,131.8 ; 126.69,134.55 JDOCK1.145 ; JDOCK1.145 126.69,136.38 ; JDOCK1.145 126.69,132.72 ; JDOCK1.145 127.58,136.38 ; JDOCK1.145 127.58,132.72 ; 208.1,136.93 JMDP1.23 ; JMDP1.23 208.85,136.93 ; JMDP1.23 208.1,134.37 ; JMDP1.23 208.1,135.65 ; JMDP1.23 208.85,134.37 ; JDOCK1.152 147.78,130.63 ; JDOCK1.152 147.78,131.58 ; JDOCK1.152 146.75,131.58 ; JDOCK1.152 145.72,130.63 ; JDOCK1.152 145.72,129.67 ; JDOCK1.152 145.72,131.58 ; JDOCK1.152 146.75,129.67 ; 128.25,129.71 JDOCK1.151 ; JDOCK1.151 126.22,129.71 ; JDOCK1.151 126.22,131.54 ; JDOCK1.151 128.25,131.54 ; JDOCK1.151 130.28,130.63 ; JDOCK1.151 126.22,130.63 ; 252.84,76.39 H8.1 ; H8.1 252.84,80.41 ; H8.1 250.84,78.4 ; H8.1 254.85,78.4 ; H8.1 251.37,79.87 ; H8.1 254.31,76.93 ; H8.1 251.37,76.93 ; H8.1 254.31,79.87 ; 119.07,133.97 H19.1 ; H19.1 120.25,136.75 ; H19.1 120.25,133.55 ; H19.1 121.85,135.15 ; H19.1 121.43,136.33 ; H19.1 121.43,133.97 ; H19.1 118.65,135.15 ; H19.1 119.07,136.33 ; 76.1,130.05 JUSB1.10 ; JUSB1.10 76.95,130.05 ; JUSB1.10 76.95,131.8 ; JUSB1.10 75.25,130.05 ; JUSB1.10 76.95,133.55 ; JUSB1.10 76.1,133.55 ; H18.1 55.93,137.37 ; H18.1 53.57,137.37 ; H18.1 53.57,139.73 ; H18.1 53.15,138.55 ; H18.1 56.35,138.55 ; H18.1 54.75,136.95 ; H18.1 55.93,139.73 ; H18.1 54.75,140.15 ; 75.57,39.17 H14.1 ; H14.1 75.57,41.53 ; H14.1 77.93,39.17 ; H14.1 77.93,41.53 ; H14.1 76.75,41.95 ; H14.1 76.75,38.75 ; H14.1 75.15,40.35 ; H14.1 78.35,40.35 ; JHDMI1.17 239.8,133.93 ; JHDMI1.17 240.25,132.92 ; JHDMI1.17 240.25,133.82 ; JHDMI1.17 239.35,133.82 ; JHDMI1.17 239.8,132.81 ; JHDMI1.17 239.35,132.92 ; JUSB3.7 292.11,97.48 ; JUSB3.7 291.07,98.52 ; JUSB3.7 291.59,97.34 ; JUSB3.7 292.25,98 ; JUSB3.7 291.07,97.48 ; JUSB3.7 291.59,98.66 ; JUSB3.7 290.93,98 ; JUSB3.7 292.11,98.52 ; 59.55,138.6 JUSB1.12 ; JUSB1.12 60.4,139.91 ; JUSB1.12 59.55,137.29 ; JUSB1.12 60.4,137.29 ; JUSB1.12 59.55,139.91 ; H23.1 152.75,121.75 ; H23.1 150.15,119.15 ; H23.1 150.86,121.04 ; H23.1 155.35,119.15 ; H23.1 150.86,117.26 ; H23.1 154.64,117.26 ; H23.1 154.64,121.04 ; H23.1 152.75,116.55 ; 67.63,130.25 JUSB1.7 ; JUSB1.7 68.87,130.25 ; JUSB1.7 68.25,130.07 ; JUSB1.7 69.05,130.87 ; JUSB1.7 67.45,130.87 ; 298.17,106.7 JUSB3.11 ; JUSB3.11 300.97,106.7 ; JUSB3.11 299.57,106.7 ; JUSB3.11 298.17,105.85 ; JUSB3.11 300.97,105.85 ; JHDMI1.20 229.9,134.2 ; JHDMI1.20 229.05,130.74 ; JHDMI1.20 228.2,130.74 ; JHDMI1.20 229.9,132.47 ; JHDMI1.20 229.9,130.74 ; JHDMI1.20 228.2,132.47
  GND2 w0.203: JUSB1.4 65.37,128.75 ; JUSB1.4 65.55,129.37 ; JUSB1.4 65.37,129.99 ; JUSB1.4 64.75,128.57 ; JUSB1.4 64.13,129.99 ; JUSB1.4 64.75,130.17 ; JUSB1.4 63.95,129.37 ; JUSB1.4 64.13,128.75 ; 265.92,134.12 JLOM1.16 ; JLOM1.16 265.04,137.58 ; JLOM1.16 265.92,137.58 ; JLOM1.16 265.04,134.12 ; JLOM1.16 265.04,135.85 ; H15.1 7.97,40.48 ; H15.1 5.53,40.48 ; H15.1 5.53,38.04 ; H15.1 6.75,37.61 ; H15.1 7.97,38.04 ; H15.1 8.4,39.26 ; H15.1 5.1,39.26 ; H15.1 6.75,40.91 ; H10.1 204.55,94.48 ; H10.1 200.81,92.9 ; H10.1 203.97,92.9 ; H10.1 200.23,94.48 ; H10.1 203.97,96.06 ; H10.1 202.39,96.64 ; H10.1 202.39,92.32 ; H10.1 200.81,96.06 ; 133.97,135.33 JDOCK1.155 ; JDOCK1.155 134.75,133.52 ; JDOCK1.155 134.75,135.58 ; JDOCK1.155 135.78,134.55 ; JDOCK1.155 133.97,133.77 ; JDOCK1.155 133.72,134.55 ; JDOCK1.155 135.53,133.77 ; JDOCK1.155 135.53,135.33 ; JMDP1.7 213.79,131.05 ; JMDP1.7 212.91,131.05 ; JMDP1.7 213.35,132.04 ; JMDP1.7 212.91,131.93 ; JMDP1.7 213.79,131.93 ; JMDP1.7 213.9,131.49 ; JMDP1.7 213.35,130.94 ; 290.72,91 JUSB3.13 ; JUSB3.13 294.22,89.3 ; JUSB3.13 290.72,89.3 ; JUSB3.13 294.22,90.15 ; JUSB3.13 292.47,89.3 ; JUSB3.13 290.72,90.15 ; JDOCK1.148 177.92,136.38 ; JDOCK1.148 177.92,132.72 ; JDOCK1.148 178.81,136.38 ; JDOCK1.148 178.81,132.72 ; JDOCK1.148 178.81,134.55 ; H28.1 238.31,38.04 ; H28.1 236.75,39.6 ; H28.1 235.19,38.04 ; H28.1 237.91,39.19 ; H28.1 236.75,36.47 ; H28.1 235.59,36.88 ; H28.1 235.59,39.19 ; H28.1 237.91,36.88 ; 170.75,133.52 JDOCK1.158 ; JDOCK1.158 171.53,133.77 ; JDOCK1.158 170.75,135.58 ; JDOCK1.158 169.97,135.33 ; JDOCK1.158 169.72,134.55 ; JDOCK1.158 169.97,133.77 ; JDOCK1.158 171.53,135.33 ; JDOCK1.158 171.78,134.55 ; JDOCK1.160 146.75,139.43 ; JDOCK1.160 145.72,137.52 ; JDOCK1.160 146.75,137.52 ; JDOCK1.160 147.78,139.43 ; JDOCK1.160 147.78,138.48 ; JDOCK1.160 147.78,137.52 ; JDOCK1.160 145.72,138.48 ; JDOCK1.160 145.72,139.43 ; JLOM1.14 284.97,137.58 ; JLOM1.14 284.97,134.12 ; JLOM1.14 285.86,135.85 ; JLOM1.14 285.86,134.12 ; JDOCK1.153 159.78,131.58 ; JDOCK1.153 159.78,129.67 ; JDOCK1.153 158.75,129.67 ; JDOCK1.153 157.72,130.63 ; JDOCK1.153 157.72,131.58 ; JDOCK1.153 159.78,130.63 ; JDOCK1.153 157.72,129.67 ; JDOCK1.153 158.75,131.58 ; 243.55,130.74 JHDMI1.21 ; JHDMI1.21 242.7,132.47 ; JHDMI1.21 242.7,130.74 ; JHDMI1.21 244.4,130.74 ; JHDMI1.21 242.7,134.2 ; JHDMI1.21 244.4,132.47 ; 208.85,129.37 JMDP1.24 ; JMDP1.24 208.1,131.93 ; JMDP1.24 208.85,131.93 ; JMDP1.24 209.6,130.65 ; JMDP1.24 209.6,129.37 ; JMDP1.24 208.1,130.65 ; JMDP1.24 208.1,129.37 ; JUSB2.4 87.75,130.17 ; JUSB2.4 88.37,129.99 ; JUSB2.4 87.13,129.99 ; JUSB2.4 87.75,128.57 ; JUSB2.4 86.95,129.37 ; JUSB2.4 88.37,128.75 ; JUSB2.4 87.13,128.75 ; JUSB2.4 88.55,129.37 ; 157.72,138.48 JDOCK1.161 ; JDOCK1.161 158.75,137.52 ; JDOCK1.161 158.75,139.43 ; JDOCK1.161 159.78,138.48 ; JDOCK1.161 159.78,139.43 ; JDOCK1.161 159.78,137.52 ; JDOCK1.161 157.72,137.52 ; JDOCK1.161 157.72,139.43 ; JMDP1.21 220.6,135.65 ; JMDP1.21 219.85,136.93 ; JMDP1.21 220.6,136.93 ; JMDP1.21 219.85,134.37 ; JMDP1.21 220.6,134.37 ; 76.1,137.29 JUSB1.13 ; JUSB1.13 76.95,139.91 ; JUSB1.13 76.95,138.6 ; JUSB1.13 76.1,139.91 ; JUSB1.13 76.95,137.29 ; 122.25,105.81 H1.1 ; H1.1 122.25,102.73 ; H1.1 125.33,105.81 ; H1.1 125.9,104.27 ; H1.1 125.33,102.73 ; H1.1 123.79,106.38 ; H1.1 123.79,102.16 ; H1.1 121.68,104.27 ; 184.07,133.97 H20.1 ; H20.1 184.07,136.33 ; H20.1 183.65,135.15 ; H20.1 186.43,136.33 ; H20.1 185.25,136.75 ; H20.1 186.43,133.97 ; H20.1 186.85,135.15 ; H20.1 185.25,133.55 ; 214.91,131.93 JMDP1.13 ; JMDP1.13 215.79,131.93 ; JMDP1.13 215.35,132.04 ; JMDP1.13 214.91,131.05 ; JMDP1.13 214.8,131.49 ; JMDP1.13 215.35,130.94 ; JMDP1.13 215.79,131.05 ; 300.75,9.05 H13.1 ; H13.1 301.93,11.83 ; H13.1 299.15,10.65 ; H13.1 300.75,12.25 ; H13.1 299.57,9.47 ; H13.1 299.57,11.83 ; H13.1 301.93,9.47 ; H13.1 302.35,10.65 ; 232.3,131.31 JHDMI1.2 ; JHDMI1.2 232.75,132.32 ; JHDMI1.2 231.74,131.87 ; JHDMI1.2 231.85,132.32 ; JHDMI1.2 232.75,131.42 ; JHDMI1.2 232.3,132.43 ; JHDMI1.2 231.85,131.42 ; JUSB3.7 292.25,98 ; JUSB3.7 291.07,97.48 ; JUSB3.7 291.59,98.66 ; JUSB3.7 292.11,98.52 ; JUSB3.7 291.59,97.34 ; JUSB3.7 292.11,97.48 ; JUSB3.7 291.07,98.52 ; JUSB3.7 290.93,98 ; 4.35,27.86 JNGFF3.69 ; JNGFF3.69 4.95,30.22 ; JNGFF3.69 4.35,29.04 ; JNGFF3.69 4.35,30.22 ; JNGFF3.69 4.95,27.86 ; 300.15,129.65 H22.1 ; H22.1 302.93,130.83 ; H22.1 300.57,130.83 ; H22.1 301.75,128.05 ; H22.1 300.57,128.47 ; H22.1 301.75,131.25 ; H22.1 303.35,129.65 ; H22.1 302.93,128.47 ; 99.1,137.29 JUSB2.13 ; JUSB2.13 99.95,139.91 ; JUSB2.13 99.95,138.6 ; JUSB2.13 99.95,137.29 ; JUSB2.13 99.1,139.91 ; JMDP1.19 217.49,132.25 ; JMDP1.19 216.61,132.25 ; JMDP1.19 217.05,133.24 ; JMDP1.19 217.6,132.69 ; JMDP1.19 217.05,132.14 ; JMDP1.19 217.49,133.13 ; JMDP1.19 216.61,133.13 ; JUSB3.12 300.97,89.3 ; JUSB3.12 298.17,90.15 ; JUSB3.12 300.97,90.15 ; JUSB3.12 299.57,89.3 ; JUSB3.12 298.17,89.3 ; 211.21,132.25 JMDP1.1 ; JMDP1.1 211.21,133.13 ; JMDP1.1 211.1,132.69 ; JMDP1.1 211.65,133.24 ; JMDP1.1 212.09,133.13 ; JMDP1.1 212.09,132.25 ; JMDP1.1 211.65,132.14 ; 183.61,80.02 H4.1 ; H4.1 182.07,80.59 ; H4.1 185.72,82.13 ; H4.1 182.07,83.67 ; H4.1 183.61,84.24 ; H4.1 185.15,80.59 ; H4.1 181.5,82.13 ; H4.1 185.15,83.67 ; JUSB3.4 290.09,102.16 ; JUSB3.4 290.61,102.02 ; JUSB3.4 290.75,101.5 ; JUSB3.4 289.57,102.02 ; JUSB3.4 290.61,100.98 ; JUSB3.4 290.09,100.84 ; JUSB3.4 289.57,100.98 ; JUSB3.4 289.43,101.5 ; JDOCK1.162 179.28,137.56 ; JDOCK1.162 179.28,139.39 ; JDOCK1.162 175.22,139.39 ; JDOCK1.162 175.22,138.48 ; JDOCK1.162 179.28,138.48 ; JDOCK1.162 177.25,139.39 ; JDOCK1.162 177.25,137.56 ; 82.55,133.55 JUSB2.11 ; JUSB2.11 83.4,133.55 ; JUSB2.11 84.25,130.05 ; JUSB2.11 83.4,130.05 ; JUSB2.11 82.55,131.8 ; JUSB2.11 82.55,130.05 ; 67.63,130.25 JUSB1.7 ; JUSB1.7 68.87,130.25 ; JUSB1.7 68.25,130.07 ; JUSB1.7 67.45,130.87 ; JUSB1.7 69.05,130.87 ; 90.63,130.25 JUSB2.7 ; JUSB2.7 92.05,130.87 ; JUSB2.7 91.25,130.07 ; JUSB2.7 91.87,130.25 ; JUSB2.7 90.45,130.87 ; 119.07,133.97 H19.1 ; H19.1 118.65,135.15 ; H19.1 120.25,136.75 ; H19.1 119.07,136.33 ; H19.1 121.43,133.97 ; H19.1 121.85,135.15 ; H19.1 121.43,136.33 ; H19.1 120.25,133.55 ; 226,139.45 JHDMI1.22 ; JHDMI1.22 228.1,141 ; JHDMI1.22 228.1,139.45 ; JHDMI1.22 228.1,137.9 ; JHDMI1.22 226,137.9 ; JHDMI1.22 227.05,141 ; JHDMI1.22 226,141 ; JHDMI1.22 227.05,137.9 ; JMDP1.22 219.85,131.93 ; JMDP1.22 219.85,129.37 ; JMDP1.22 219.1,130.65 ; JMDP1.22 219.1,129.37 ; JMDP1.22 220.6,129.37 ; JMDP1.22 220.6,131.93 ; JMDP1.22 220.6,130.65 ; 122.25,80.59 H2.1 ; H2.1 125.33,80.59 ; H2.1 123.79,84.24 ; H2.1 125.9,82.13 ; H2.1 125.33,83.67 ; H2.1 122.25,83.67 ; H2.1 121.68,82.13 ; H2.1 123.79,80.02 ; JDOCK1.154 179.28,129.71 ; JDOCK1.154 177.25,131.54 ; JDOCK1.154 179.28,130.63 ; JDOCK1.154 179.28,131.54 ; JDOCK1.154 177.25,129.71 ; JDOCK1.154 175.22,129.71 ; 290.72,105.85 JUSB3.10 ; JUSB3.10 294.22,106.7 ; JUSB3.10 290.72,105 ; JUSB3.10 294.22,105.85 ; JUSB3.10 292.47,106.7 ; JUSB3.10 290.72,106.7 ; H3.1 183.61,106.38 ; H3.1 185.72,104.27 ; H3.1 183.61,102.16 ; H3.1 181.5,104.27 ; H3.1 182.07,105.81 ; H3.1 182.07,102.73 ; H3.1 185.15,102.73 ; H3.1 185.15,105.81 ; JHDMI1.23 246.6,139.45 ; JHDMI1.23 244.5,141 ; JHDMI1.23 244.5,139.45 ; JHDMI1.23 244.5,137.9 ; JHDMI1.23 245.55,141 ; JHDMI1.23 245.55,137.9 ; JHDMI1.23 246.6,141 ; JHDMI1.23 246.6,137.9 ; JHDMI1.17 240.25,132.92 ; JHDMI1.17 240.25,133.82 ; JHDMI1.17 239.35,132.92 ; JHDMI1.17 239.8,132.81 ; JHDMI1.17 239.35,133.82 ; JHDMI1.17 239.8,133.93 ; 235.3,131.31 JHDMI1.8 ; JHDMI1.8 235.75,131.42 ; JHDMI1.8 234.85,131.42 ; JHDMI1.8 235.3,132.43 ; JHDMI1.8 234.85,132.32 ; JHDMI1.8 235.75,132.32 ; 158.75,133.52 JDOCK1.157 ; JDOCK1.157 159.78,134.55 ; JDOCK1.157 159.53,135.33 ; JDOCK1.157 159.53,133.77 ; JDOCK1.157 157.97,135.33 ; JDOCK1.157 157.72,134.55 ; JDOCK1.157 157.97,133.77 ; JDOCK1.157 158.75,135.58 ; H18.1 54.75,140.15 ; H18.1 53.15,138.55 ; H18.1 53.57,137.37 ; H18.1 56.35,138.55 ; H18.1 55.93,139.73 ; H18.1 55.93,137.37 ; H18.1 53.57,139.73 ; H18.1 54.75,136.95 ; 285.75,87.75 H11.1 ; H11.1 288.53,86.57 ; H11.1 287.35,89.35 ; H11.1 286.17,86.57 ; H11.1 286.17,88.93 ; H11.1 287.35,86.15 ; H11.1 288.95,87.75 ; H11.1 288.53,88.93 ; 82.55,137.29 JUSB2.12 ; JUSB2.12 83.4,137.29 ; JUSB2.12 82.55,138.6 ; JUSB2.12 82.55,139.91 ; JUSB2.12 83.4,139.91 ; 145.72,134.55 JDOCK1.156 ; JDOCK1.156 146.75,135.58 ; JDOCK1.156 145.97,133.77 ; JDOCK1.156 147.53,135.33 ; JDOCK1.156 145.97,135.33 ; JDOCK1.156 147.78,134.55 ; JDOCK1.156 146.75,133.52 ; JDOCK1.156 147.53,133.77 ; H16.1 2.25,47.8 ; H16.1 3.47,47.37 ; H16.1 1.03,47.37 ; H16.1 3.9,46.15 ; H16.1 1.03,44.93 ; H16.1 3.47,44.93 ; H16.1 0.6,46.15 ; H16.1 2.25,44.5 ; JDOCK1.151 130.28,130.63 ; JDOCK1.151 128.25,131.54 ; JDOCK1.151 126.22,129.71 ; JDOCK1.151 126.22,131.54 ; JDOCK1.151 126.22,130.63 ; JDOCK1.151 128.25,129.71 ; 249.57,138.27 H21.1 ; H21.1 251.93,140.63 ; H21.1 249.57,140.63 ; H21.1 250.75,137.85 ; H21.1 250.75,141.05 ; H21.1 249.15,139.45 ; H21.1 252.35,139.45 ; H21.1 251.93,138.27 ; 297.53,40.48 H12.1 ; H12.1 300.4,39.26 ; H12.1 299.97,38.04 ; H12.1 298.75,37.61 ; H12.1 297.1,39.26 ; H12.1 299.97,40.48 ; H12.1 297.53,38.04 ; H7.1 236.76,97.85 ; H7.1 232.74,97.85 ; H7.1 233.28,96.38 ; H7.1 234.75,99.86 ; H7.1 234.75,95.84 ; H7.1 236.22,96.38 ; H7.1 236.22,99.32 ; H7.1 233.28,99.32 ; 126.69,136.38 JDOCK1.145 ; JDOCK1.145 127.58,136.38 ; JDOCK1.145 126.69,134.55 ; JDOCK1.145 127.58,132.72 ; JDOCK1.145 126.69,132.72 ; 60.4,137.29 JUSB1.12 ; JUSB1.12 60.4,139.91 ; JUSB1.12 59.55,139.91 ; JUSB1.12 59.55,137.29 ; JUSB1.12 59.55,138.6 ; 99.1,130.05 JUSB2.10 ; JUSB2.10 98.25,130.05 ; JUSB2.10 99.95,133.55 ; JUSB2.10 99.95,130.05 ; JUSB2.10 99.1,133.55 ; JUSB2.10 99.95,131.8 ; JDOCK1.159 130.28,139.39 ; JDOCK1.159 128.25,137.56 ; JDOCK1.159 130.28,138.48 ; JDOCK1.159 128.25,139.39 ; JDOCK1.159 126.22,139.39 ; JDOCK1.159 126.22,138.48 ; JDOCK1.159 126.22,137.56 ; 233.8,132.81 JHDMI1.5 ; JHDMI1.5 233.8,133.93 ; JHDMI1.5 233.35,132.92 ; JHDMI1.5 234.25,133.82 ; JHDMI1.5 233.35,133.82 ; JHDMI1.5 234.25,132.92 ; 183.4,123.49 SW1.5 ; SW1.5 184.89,122 ; SW1.5 184.15,123.72 ; SW1.5 183.17,122.75 ; SW1.5 184.15,121.77 ; SW1.5 183.4,122 ; SW1.5 184.89,123.49 ; SW1.5 185.13,122.75 ; 75.25,130.05 JUSB1.10 ; JUSB1.10 76.95,130.05 ; JUSB1.10 76.95,133.55 ; JUSB1.10 76.1,130.05 ; JUSB1.10 76.1,133.55 ; JUSB1.10 76.95,131.8 ; H8.1 254.85,78.4 ; H8.1 251.37,76.93 ; H8.1 252.84,76.39 ; H8.1 251.37,79.87 ; H8.1 254.31,76.93 ; H8.1 250.84,78.4 ; H8.1 252.84,80.41 ; H8.1 254.31,79.87 ; 236.35,132.92 JHDMI1.11 ; JHDMI1.11 237.25,133.82 ; JHDMI1.11 236.8,132.81 ; JHDMI1.11 237.25,132.92 ; JHDMI1.11 236.35,133.82 ; JHDMI1.11 236.8,133.93 ; 75.15,40.35 H14.1 ; H14.1 75.57,41.53 ; H14.1 78.35,40.35 ; H14.1 75.57,39.17 ; H14.1 77.93,39.17 ; H14.1 76.75,38.75 ; H14.1 77.93,41.53 ; H14.1 76.75,41.95 ; JUSB3.11 300.97,105.85 ; JUSB3.11 298.17,106.7 ; JUSB3.11 298.17,105.85 ; JUSB3.11 300.97,106.7 ; JUSB3.11 299.57,106.7 ; 145.72,130.63 JDOCK1.152 ; JDOCK1.152 146.75,129.67 ; JDOCK1.152 145.72,131.58 ; JDOCK1.152 145.72,129.67 ; JDOCK1.152 147.78,131.58 ; JDOCK1.152 146.75,131.58 ; JDOCK1.152 147.78,130.63 ; 59.55,133.55 JUSB1.11 ; JUSB1.11 59.55,130.05 ; JUSB1.11 61.25,130.05 ; JUSB1.11 60.4,130.05 ; JUSB1.11 59.55,131.8 ; JUSB1.11 60.4,133.55 ; JNGFF3.68 28.05,27.86 ; JNGFF3.68 27.45,30.22 ; JNGFF3.68 28.05,30.22 ; JNGFF3.68 28.05,29.04 ; JNGFF3.68 27.45,27.86 ; JHDMI1.20 229.9,130.74 ; JHDMI1.20 229.9,134.2 ; JHDMI1.20 229.9,132.47 ; JHDMI1.20 228.2,132.47 ; JHDMI1.20 228.2,130.74 ; JHDMI1.20 229.05,130.74 ; 1.42,51.82 H17.1 ; H17.1 4.08,54.48 ; H17.1 4.55,53.15 ; H17.1 0.95,53.15 ; H17.1 4.08,51.82 ; H17.1 1.42,54.48 ; H17.1 2.75,51.35 ; H17.1 2.75,54.95 ; 150.86,117.26 H23.1 ; H23.1 152.75,121.75 ; H23.1 152.75,116.55 ; H23.1 155.35,119.15 ; H23.1 154.64,117.26 ; H23.1 150.86,121.04 ; H23.1 154.64,121.04 ; H23.1 150.15,119.15 ; 208.85,134.37 JMDP1.23 ; JMDP1.23 208.1,135.65 ; JMDP1.23 208.85,136.93 ; JMDP1.23 208.1,134.37 ; JMDP1.23 208.1,136.93 ; 189.47,122.75 SW1.4 ; SW1.4 190.45,121.77 ; SW1.4 191.43,122.75 ; SW1.4 189.7,123.49 ; SW1.4 191.19,122 ; SW1.4 189.7,122 ; SW1.4 191.19,123.49 ; SW1.4 190.45,123.72
  VCC w0.203: 0.95,53.15 H17.1 ; H17.1 1.42,54.48 ; H17.1 2.75,54.95 ; H17.1 4.55,53.15 ; H17.1 1.42,51.82 ; H17.1 4.08,54.48 ; H17.1 4.08,51.82 ; H17.1 2.75,51.35 ; 265.04,134.12 JLOM1.16 ; JLOM1.16 265.04,135.85 ; JLOM1.16 265.92,137.58 ; JLOM1.16 265.04,137.58 ; JLOM1.16 265.92,134.12 ; JUSB2.4 88.37,128.75 ; JUSB2.4 87.75,130.17 ; JUSB2.4 88.37,129.99 ; JUSB2.4 88.55,129.37 ; JUSB2.4 87.13,128.75 ; JUSB2.4 86.95,129.37 ; JUSB2.4 87.75,128.57 ; JUSB2.4 87.13,129.99 ; H15.1 8.4,39.26 ; H15.1 5.1,39.26 ; H15.1 5.53,38.04 ; H15.1 5.53,40.48 ; H15.1 6.75,37.61 ; H15.1 7.97,38.04 ; H15.1 7.97,40.48 ; H15.1 6.75,40.91 ; 290.72,106.7 JUSB3.10 ; JUSB3.10 290.72,105.85 ; JUSB3.10 290.72,105 ; JUSB3.10 294.22,106.7 ; JUSB3.10 292.47,106.7 ; JUSB3.10 294.22,105.85 ; 298.17,106.7 JUSB3.11 ; JUSB3.11 300.97,105.85 ; JUSB3.11 300.97,106.7 ; JUSB3.11 299.57,106.7 ; JUSB3.11 298.17,105.85 ; JUSB1.13 76.95,139.91 ; JUSB1.13 76.95,137.29 ; JUSB1.13 76.1,139.91 ; JUSB1.13 76.95,138.6 ; JUSB1.13 76.1,137.29 ; JMDP1.22 219.85,131.93 ; JMDP1.22 219.1,129.37 ; JMDP1.22 220.6,131.93 ; JMDP1.22 219.85,129.37 ; JMDP1.22 220.6,130.65 ; JMDP1.22 219.1,130.65 ; JMDP1.22 220.6,129.37 ; JUSB2.13 99.95,138.6 ; JUSB2.13 99.95,137.29 ; JUSB2.13 99.1,137.29 ; JUSB2.13 99.1,139.91 ; JUSB2.13 99.95,139.91 ; 208.1,130.65 JMDP1.24 ; JMDP1.24 208.1,131.93 ; JMDP1.24 208.1,129.37 ; JMDP1.24 209.6,130.65 ; JMDP1.24 208.85,131.93 ; JMDP1.24 209.6,129.37 ; JMDP1.24 208.85,129.37 ; 226,137.9 JHDMI1.22 ; JHDMI1.22 228.1,141 ; JHDMI1.22 226,141 ; JHDMI1.22 228.1,139.45 ; JHDMI1.22 226,139.45 ; JHDMI1.22 227.05,141 ; JHDMI1.22 228.1,137.9 ; JHDMI1.22 227.05,137.9 ; 212.91,131.05 JMDP1.7 ; JMDP1.7 213.35,132.04 ; JMDP1.7 213.9,131.49 ; JMDP1.7 213.79,131.05 ; JMDP1.7 212.91,131.93 ; JMDP1.7 213.35,130.94 ; JMDP1.7 213.79,131.93 ; 232.3,131.31 JHDMI1.2 ; JHDMI1.2 232.75,131.42 ; JHDMI1.2 231.85,132.32 ; JHDMI1.2 231.85,131.42 ; JHDMI1.2 231.74,131.87 ; JHDMI1.2 232.75,132.32 ; JHDMI1.2 232.3,132.43 ; 214.91,131.93 JMDP1.13 ; JMDP1.13 215.79,131.93 ; JMDP1.13 215.35,132.04 ; JMDP1.13 215.79,131.05 ; JMDP1.13 215.35,130.94 ; JMDP1.13 214.8,131.49 ; JMDP1.13 214.91,131.05 ; 287.35,86.15 H11.1 ; H11.1 286.17,86.57 ; H11.1 288.53,88.93 ; H11.1 286.17,88.93 ; H11.1 288.95,87.75 ; H11.1 287.35,89.35 ; H11.1 288.53,86.57 ; H11.1 285.75,87.75 ; 4.95,27.86 JNGFF3.69 ; JNGFF3.69 4.35,29.04 ; JNGFF3.69 4.35,30.22 ; JNGFF3.69 4.95,30.22 ; JNGFF3.69 4.35,27.86 ; 60.4,130.05 JUSB1.11 ; JUSB1.11 59.55,131.8 ; JUSB1.11 61.25,130.05 ; JUSB1.11 59.55,130.05 ; JUSB1.11 59.55,133.55 ; JUSB1.11 60.4,133.55 ; JUSB2.7 92.05,130.87 ; JUSB2.7 90.45,130.87 ; JUSB2.7 90.63,130.25 ; JUSB2.7 91.87,130.25 ; JUSB2.7 91.25,130.07 ; 83.4,137.29 JUSB2.12 ; JUSB2.12 82.55,139.91 ; JUSB2.12 82.55,137.29 ; JUSB2.12 82.55,138.6 ; JUSB2.12 83.4,139.91 ; 233.35,133.82 JHDMI1.5 ; JHDMI1.5 233.8,132.81 ; JHDMI1.5 233.8,133.93 ; JHDMI1.5 234.25,133.82 ; JHDMI1.5 234.25,132.92 ; JHDMI1.5 233.35,132.92 ; 301.75,128.05 H22.1 ; H22.1 300.15,129.65 ; H22.1 301.75,131.25 ; H22.1 303.35,129.65 ; H22.1 302.93,128.47 ; H22.1 300.57,130.83 ; H22.1 302.93,130.83 ; H22.1 300.57,128.47 ; JHDMI1.8 235.75,132.32 ; JHDMI1.8 235.3,131.31 ; JHDMI1.8 234.85,131.42 ; JHDMI1.8 234.85,132.32 ; JHDMI1.8 235.3,132.43 ; JHDMI1.8 235.75,131.42 ; JMDP1.19 217.49,132.25 ; JMDP1.19 217.6,132.69 ; JMDP1.19 217.05,132.14 ; JMDP1.19 217.49,133.13 ; JMDP1.19 217.05,133.24 ; JMDP1.19 216.61,132.25 ; JMDP1.19 216.61,133.13 ; JUSB3.13 294.22,89.3 ; JUSB3.13 290.72,90.15 ; JUSB3.13 292.47,89.3 ; JUSB3.13 290.72,91 ; JUSB3.13 294.22,90.15 ; JUSB3.13 290.72,89.3 ; H2.1 123.79,84.24 ; H2.1 122.25,83.67 ; H2.1 125.9,82.13 ; H2.1 123.79,80.02 ; H2.1 125.33,83.67 ; H2.1 125.33,80.59 ; H2.1 121.68,82.13 ; H2.1 122.25,80.59 ; JUSB3.7 292.25,98 ; JUSB3.7 292.11,97.48 ; JUSB3.7 291.59,98.66 ; JUSB3.7 291.07,97.48 ; JUSB3.7 291.59,97.34 ; JUSB3.7 290.93,98 ; JUSB3.7 291.07,98.52 ; JUSB3.7 292.11,98.52 ; JUSB1.10 76.1,133.55 ; JUSB1.10 76.95,130.05 ; JUSB1.10 76.95,131.8 ; JUSB1.10 75.25,130.05 ; JUSB1.10 76.1,130.05 ; JUSB1.10 76.95,133.55 ; 27.45,27.86 JNGFF3.68 ; JNGFF3.68 27.45,30.22 ; JNGFF3.68 28.05,27.86 ; JNGFF3.68 28.05,29.04 ; JNGFF3.68 28.05,30.22 ; JUSB1.4 65.37,129.99 ; JUSB1.4 64.75,130.17 ; JUSB1.4 64.13,128.75 ; JUSB1.4 63.95,129.37 ; JUSB1.4 65.55,129.37 ; JUSB1.4 65.37,128.75 ; JUSB1.4 64.13,129.99 ; JUSB1.4 64.75,128.57 ; JUSB2.10 99.95,131.8 ; JUSB2.10 99.95,133.55 ; JUSB2.10 98.25,130.05 ; JUSB2.10 99.95,130.05 ; JUSB2.10 99.1,133.55 ; JUSB2.10 99.1,130.05 ; 298.17,89.3 JUSB3.12 ; JUSB3.12 300.97,90.15 ; JUSB3.12 299.57,89.3 ; JUSB3.12 300.97,89.3 ; JUSB3.12 298.17,90.15 ; 67.45,130.87 JUSB1.7 ; JUSB1.7 67.63,130.25 ; JUSB1.7 68.25,130.07 ; JUSB1.7 69.05,130.87 ; JUSB1.7 68.87,130.25 ; 239.35,132.92 JHDMI1.17 ; JHDMI1.17 240.25,132.92 ; JHDMI1.17 240.25,133.82 ; JHDMI1.17 239.8,132.81 ; JHDMI1.17 239.35,133.82 ; JHDMI1.17 239.8,133.93 ; 249.15,139.45 H21.1 ; H21.1 252.35,139.45 ; H21.1 250.75,141.05 ; H21.1 249.57,138.27 ; H21.1 251.93,138.27 ; H21.1 249.57,140.63 ; H21.1 251.93,140.63 ; H21.1 250.75,137.85 ; 244.5,141 JHDMI1.23 ; JHDMI1.23 244.5,139.45 ; JHDMI1.23 246.6,139.45 ; JHDMI1.23 246.6,137.9 ; JHDMI1.23 244.5,137.9 ; JHDMI1.23 245.55,137.9 ; JHDMI1.23 246.6,141 ; JHDMI1.23 245.55,141 ; 208.1,136.93 JMDP1.23 ; JMDP1.23 208.1,135.65 ; JMDP1.23 208.1,134.37 ; JMDP1.23 208.85,134.37 ; JMDP1.23 208.85,136.93 ; JUSB2.11 84.25,130.05 ; JUSB2.11 82.55,133.55 ; JUSB2.11 82.55,131.8 ; JUSB2.11 82.55,130.05 ; JUSB2.11 83.4,130.05 ; JUSB2.11 83.4,133.55 ; 289.57,100.98 JUSB3.4 ; JUSB3.4 289.43,101.5 ; JUSB3.4 290.09,100.84 ; JUSB3.4 290.61,100.98 ; JUSB3.4 289.57,102.02 ; JUSB3.4 290.75,101.5 ; JUSB3.4 290.61,102.02 ; JUSB3.4 290.09,102.16 ; 211.21,133.13 JMDP1.1 ; JMDP1.1 211.65,133.24 ; JMDP1.1 212.09,132.25 ; JMDP1.1 211.21,132.25 ; JMDP1.1 211.65,132.14 ; JMDP1.1 212.09,133.13 ; JMDP1.1 211.1,132.69 ; JLOM1.14 284.97,137.58 ; JLOM1.14 285.86,134.12 ; JLOM1.14 285.86,135.85 ; JLOM1.14 284.97,134.12 ; JHDMI1.21 244.4,132.47 ; JHDMI1.21 242.7,130.74 ; JHDMI1.21 243.55,130.74 ; JHDMI1.21 242.7,132.47 ; JHDMI1.21 242.7,134.2 ; JHDMI1.21 244.4,130.74 ; JMDP1.21 220.6,136.93 ; JMDP1.21 219.85,134.37 ; JMDP1.21 220.6,134.37 ; JMDP1.21 219.85,136.93 ; JMDP1.21 220.6,135.65 ; JHDMI1.20 229.9,134.2 ; JHDMI1.20 229.05,130.74 ; JHDMI1.20 228.2,132.47 ; JHDMI1.20 229.9,132.47 ; JHDMI1.20 228.2,130.74 ; JHDMI1.20 229.9,130.74 ; H16.1 3.47,47.37 ; H16.1 3.9,46.15 ; H16.1 1.03,44.93 ; H16.1 3.47,44.93 ; H16.1 2.25,47.8 ; H16.1 0.6,46.15 ; H16.1 2.25,44.5 ; H16.1 1.03,47.37 ; 53.57,139.73 H18.1 ; H18.1 53.57,137.37 ; H18.1 53.15,138.55 ; H18.1 55.93,137.37 ; H18.1 54.75,136.95 ; H18.1 55.93,139.73 ; H18.1 56.35,138.55 ; H18.1 54.75,140.15 ; 236.35,132.92 JHDMI1.11 ; JHDMI1.11 237.25,132.92 ; JHDMI1.11 237.25,133.82 ; JHDMI1.11 236.35,133.82 ; JHDMI1.11 236.8,133.93 ; JHDMI1.11 236.8,132.81 ; 60.4,137.29 JUSB1.12 ; JUSB1.12 59.55,137.29 ; JUSB1.12 60.4,139.91 ; JUSB1.12 59.55,138.6 ; JUSB1.12 59.55,139.91
  GND3 w0.203: H10.1 204.55,94.48 ; H10.1 200.81,92.9 ; H10.1 203.97,96.06 ; H10.1 203.97,92.9 ; H10.1 200.23,94.48 ; H10.1 202.39,92.32 ; H10.1 202.39,96.64 ; H10.1 200.81,96.06 ; JHDMI1.2 232.3,132.43 ; JHDMI1.2 232.75,132.32 ; JHDMI1.2 231.85,132.32 ; JHDMI1.2 231.85,131.42 ; JHDMI1.2 232.75,131.42 ; JHDMI1.2 231.74,131.87 ; JHDMI1.2 232.3,131.31 ; H1.1 125.33,102.73 ; H1.1 121.68,104.27 ; H1.1 123.79,106.38 ; H1.1 122.25,105.81 ; H1.1 125.9,104.27 ; H1.1 125.33,105.81 ; H1.1 123.79,102.16 ; H1.1 122.25,102.73 ; 249.15,139.45 H21.1 ; H21.1 252.35,139.45 ; H21.1 251.93,138.27 ; H21.1 251.93,140.63 ; H21.1 250.75,137.85 ; H21.1 249.57,140.63 ; H21.1 250.75,141.05 ; H21.1 249.57,138.27 ; H14.1 77.93,41.53 ; H14.1 75.57,41.53 ; H14.1 76.75,38.75 ; H14.1 75.15,40.35 ; H14.1 78.35,40.35 ; H14.1 76.75,41.95 ; H14.1 77.93,39.17 ; H14.1 75.57,39.17 ; 82.55,139.91 JUSB2.12 ; JUSB2.12 83.4,137.29 ; JUSB2.12 83.4,139.91 ; JUSB2.12 82.55,138.6 ; JUSB2.12 82.55,137.29 ; 146.75,133.52 JDOCK1.156 ; JDOCK1.156 145.97,133.77 ; JDOCK1.156 147.53,135.33 ; JDOCK1.156 145.97,135.33 ; JDOCK1.156 147.78,134.55 ; JDOCK1.156 147.53,133.77 ; JDOCK1.156 146.75,135.58 ; JDOCK1.156 145.72,134.55 ; H17.1 4.55,53.15 ; H17.1 2.75,54.95 ; H17.1 0.95,53.15 ; H17.1 4.08,54.48 ; H17.1 4.08,51.82 ; H17.1 2.75,51.35 ; H17.1 1.42,51.82 ; H17.1 1.42,54.48 ; 290.72,106.7 JUSB3.10 ; JUSB3.10 292.47,106.7 ; JUSB3.10 290.72,105.85 ; JUSB3.10 294.22,106.7 ; JUSB3.10 294.22,105.85 ; JUSB3.10 290.72,105 ; H13.1 301.93,9.47 ; H13.1 302.35,10.65 ; H13.1 299.57,11.83 ; H13.1 299.57,9.47 ; H13.1 300.75,12.25 ; H13.1 300.75,9.05 ; H13.1 299.15,10.65 ; H13.1 301.93,11.83 ; 59.55,133.55 JUSB1.11 ; JUSB1.11 61.25,130.05 ; JUSB1.11 59.55,131.8 ; JUSB1.11 60.4,130.05 ; JUSB1.11 60.4,133.55 ; JUSB1.11 59.55,130.05 ; 298.75,37.61 H12.1 ; H12.1 299.97,40.48 ; H12.1 299.97,38.04 ; H12.1 297.53,38.04 ; H12.1 297.53,40.48 ; H12.1 300.4,39.26 ; H12.1 297.1,39.26 ; 119.07,133.97 H19.1 ; H19.1 120.25,133.55 ; H19.1 121.43,136.33 ; H19.1 121.43,133.97 ; H19.1 121.85,135.15 ; H19.1 120.25,136.75 ; H19.1 118.65,135.15 ; H19.1 119.07,136.33 ; JMDP1.19 217.05,133.24 ; JMDP1.19 217.49,133.13 ; JMDP1.19 217.6,132.69 ; JMDP1.19 216.61,133.13 ; JMDP1.19 217.49,132.25 ; JMDP1.19 217.05,132.14 ; JMDP1.19 216.61,132.25 ; JDOCK1.157 159.53,133.77 ; JDOCK1.157 159.78,134.55 ; JDOCK1.157 158.75,133.52 ; JDOCK1.157 158.75,135.58 ; JDOCK1.157 157.97,135.33 ; JDOCK1.157 159.53,135.33 ; JDOCK1.157 157.97,133.77 ; JDOCK1.157 157.72,134.55 ; 150.86,117.26 H23.1 ; H23.1 152.75,116.55 ; H23.1 154.64,117.26 ; H23.1 150.15,119.15 ; H23.1 150.86,121.04 ; H23.1 155.35,119.15 ; H23.1 154.64,121.04 ; H23.1 152.75,121.75 ; 175.22,139.39 JDOCK1.162 ; JDOCK1.162 179.28,139.39 ; JDOCK1.162 179.28,138.48 ; JDOCK1.162 175.22,138.48 ; JDOCK1.162 177.25,137.56 ; JDOCK1.162 177.25,139.39 ; JDOCK1.162 179.28,137.56 ; 229.05,130.74 JHDMI1.20 ; JHDMI1.20 228.2,132.47 ; JHDMI1.20 229.9,132.47 ; JHDMI1.20 228.2,130.74 ; JHDMI1.20 229.9,130.74 ; JHDMI1.20 229.9,134.2 ; SW1.4 190.45,123.72 ; SW1.4 189.7,123.49 ; SW1.4 189.7,122 ; SW1.4 190.45,121.77 ; SW1.4 191.19,123.49 ; SW1.4 189.47,122.75 ; SW1.4 191.43,122.75 ; SW1.4 191.19,122 ; JUSB2.10 99.95,130.05 ; JUSB2.10 98.25,130.05 ; JUSB2.10 99.1,133.55 ; JUSB2.10 99.95,131.8 ; JUSB2.10 99.1,130.05 ; JUSB2.10 99.95,133.55 ; 233.28,99.32 H7.1 ; H7.1 234.75,95.84 ; H7.1 236.76,97.85 ; H7.1 233.28,96.38 ; H7.1 236.22,96.38 ; H7.1 236.22,99.32 ; H7.1 232.74,97.85 ; H7.1 234.75,99.86 ; H28.1 236.75,39.6 ; H28.1 235.59,39.19 ; H28.1 237.91,36.88 ; H28.1 235.19,38.04 ; H28.1 236.75,36.47 ; H28.1 238.31,38.04 ; H28.1 235.59,36.88 ; H28.1 237.91,39.19 ; JUSB1.7 68.87,130.25 ; JUSB1.7 67.63,130.25 ; JUSB1.7 68.25,130.07 ; JUSB1.7 67.45,130.87 ; JUSB1.7 69.05,130.87 ; 157.72,137.52 JDOCK1.161 ; JDOCK1.161 159.78,137.52 ; JDOCK1.161 158.75,137.52 ; JDOCK1.161 157.72,138.48 ; JDOCK1.161 158.75,139.43 ; JDOCK1.161 157.72,139.43 ; JDOCK1.161 159.78,139.43 ; JDOCK1.161 159.78,138.48 ; JDOCK1.148 178.81,136.38 ; JDOCK1.148 178.81,132.72 ; JDOCK1.148 177.92,136.38 ; JDOCK1.148 177.92,132.72 ; JDOCK1.148 178.81,134.55 ; H20.1 186.43,133.97 ; H20.1 186.43,136.33 ; H20.1 185.25,133.55 ; H20.1 186.85,135.15 ; H20.1 184.07,133.97 ; H20.1 183.65,135.15 ; H20.1 185.25,136.75 ; H20.1 184.07,136.33 ; JLOM1.14 285.86,135.85 ; JLOM1.14 284.97,134.12 ; JLOM1.14 285.86,134.12 ; JLOM1.14 284.97,137.58 ; JHDMI1.17 240.25,132.92 ; JHDMI1.17 239.8,133.93 ; JHDMI1.17 239.35,132.92 ; JHDMI1.17 240.25,133.82 ; JHDMI1.17 239.35,133.82 ; JHDMI1.17 239.8,132.81 ; JHDMI1.23 246.6,139.45 ; JHDMI1.23 245.55,141 ; JHDMI1.23 246.6,141 ; JHDMI1.23 244.5,141 ; JHDMI1.23 244.5,137.9 ; JHDMI1.23 246.6,137.9 ; JHDMI1.23 245.55,137.9 ; JHDMI1.23 244.5,139.45 ; 87.75,128.57 JUSB2.4 ; JUSB2.4 87.13,128.75 ; JUSB2.4 87.13,129.99 ; JUSB2.4 86.95,129.37 ; JUSB2.4 87.75,130.17 ; JUSB2.4 88.55,129.37 ; JUSB2.4 88.37,128.75 ; JUSB2.4 88.37,129.99 ; JUSB3.11 300.97,106.7 ; JUSB3.11 300.97,105.85 ; JUSB3.11 298.17,105.85 ; JUSB3.11 298.17,106.7 ; JUSB3.11 299.57,106.7 ; JHDMI1.11 236.8,133.93 ; JHDMI1.11 237.25,133.82 ; JHDMI1.11 236.35,132.92 ; JHDMI1.11 236.8,132.81 ; JHDMI1.11 237.25,132.92 ; JHDMI1.11 236.35,133.82 ; JNGFF3.68 28.05,30.22 ; JNGFF3.68 27.45,30.22 ; JNGFF3.68 28.05,27.86 ; JNGFF3.68 28.05,29.04 ; JNGFF3.68 27.45,27.86 ; JDOCK1.160 147.78,139.43 ; JDOCK1.160 147.78,137.52 ; JDOCK1.160 147.78,138.48 ; JDOCK1.160 146.75,139.43 ; JDOCK1.160 145.72,137.52 ; JDOCK1.160 145.72,138.48 ; JDOCK1.160 146.75,137.52 ; JDOCK1.160 145.72,139.43 ; 181.5,104.27 H3.1 ; H3.1 182.07,105.81 ; H3.1 185.15,105.81 ; H3.1 182.07,102.73 ; H3.1 183.61,102.16 ; H3.1 185.15,102.73 ; H3.1 185.72,104.27 ; H3.1 183.61,106.38 ; JUSB1.12 60.4,139.91 ; JUSB1.12 59.55,139.91 ; JUSB1.12 59.55,138.6 ; JUSB1.12 60.4,137.29 ; JUSB1.12 59.55,137.29 ; JDOCK1.151 128.25,131.54 ; JDOCK1.151 130.28,130.63 ; JDOCK1.151 128.25,129.71 ; JDOCK1.151 126.22,130.63 ; JDOCK1.151 126.22,131.54 ; JDOCK1.151 126.22,129.71 ; 234.85,132.32 JHDMI1.8 ; JHDMI1.8 235.75,132.32 ; JHDMI1.8 235.75,131.42 ; JHDMI1.8 235.3,131.31 ; JHDMI1.8 234.85,131.42 ; JHDMI1.8 235.3,132.43 ; JUSB3.7 291.59,98.66 ; JUSB3.7 292.11,97.48 ; JUSB3.7 291.59,97.34 ; JUSB3.7 291.07,97.48 ; JUSB3.7 292.25,98 ; JUSB3.7 290.93,98 ; JUSB3.7 291.07,98.52 ; JUSB3.7 292.11,98.52 ; 126.22,137.56 JDOCK1.159 ; JDOCK1.159 130.28,138.48 ; JDOCK1.159 126.22,139.39 ; JDOCK1.159 126.22,138.48 ; JDOCK1.159 128.25,139.39 ; JDOCK1.159 128.25,137.56 ; JDOCK1.159 130.28,139.39 ; JLOM1.16 265.92,137.58 ; JLOM1.16 265.04,134.12 ; JLOM1.16 265.92,134.12 ; JLOM1.16 265.04,135.85 ; JLOM1.16 265.04,137.58 ; JUSB1.10 76.95,131.8 ; JUSB1.10 76.95,133.55 ; JUSB1.10 76.95,130.05 ; JUSB1.10 76.1,133.55 ; JUSB1.10 76.1,130.05 ; JUSB1.10 75.25,130.05 ; 211.1,132.69 JMDP1.1 ; JMDP1.1 212.09,132.25 ; JMDP1.1 212.09,133.13 ; JMDP1.1 211.65,133.24 ; JMDP1.1 211.21,133.13 ; JMDP1.1 211.21,132.25 ; JMDP1.1 211.65,132.14 ; JUSB3.12 300.97,89.3 ; JUSB3.12 300.97,90.15 ; JUSB3.12 298.17,89.3 ; JUSB3.12 299.57,89.3 ; JUSB3.12 298.17,90.15 ; 285.75,87.75 H11.1 ; H11.1 288.53,86.57 ; H11.1 288.95,87.75 ; H11.1 287.35,89.35 ; H11.1 287.35,86.15 ; H11.1 286.17,86.57 ; H11.1 288.53,88.93 ; H11.1 286.17,88.93 ; JMDP1.7 213.9,131.49 ; JMDP1.7 212.91,131.05 ; JMDP1.7 213.35,130.94 ; JMDP1.7 212.91,131.93 ; JMDP1.7 213.79,131.93 ; JMDP1.7 213.35,132.04 ; JMDP1.7 213.79,131.05 ; H4.1 185.72,82.13 ; H4.1 185.15,83.67 ; H4.1 183.61,80.02 ; H4.1 181.5,82.13 ; H4.1 182.07,80.59 ; H4.1 182.07,83.67 ; H4.1 185.15,80.59 ; H4.1 183.61,84.24 ; 133.97,133.77 JDOCK1.155 ; JDOCK1.155 134.75,135.58 ; JDOCK1.155 135.78,134.55 ; JDOCK1.155 133.72,134.55 ; JDOCK1.155 135.53,135.33 ; JDOCK1.155 134.75,133.52 ; JDOCK1.155 133.97,135.33 ; JDOCK1.155 135.53,133.77 ; 290.72,91 JUSB3.13 ; JUSB3.13 292.47,89.3 ; JUSB3.13 294.22,89.3 ; JUSB3.13 294.22,90.15 ; JUSB3.13 290.72,90.15 ; JUSB3.13 290.72,89.3 ; JDOCK1.152 146.75,131.58 ; JDOCK1.152 147.78,130.63 ; JDOCK1.152 145.72,129.67 ; JDOCK1.152 146.75,129.67 ; JDOCK1.152 145.72,131.58 ; JDOCK1.152 145.72,130.63 ; JDOCK1.152 147.78,131.58 ; JUSB1.13 76.95,137.29 ; JUSB1.13 76.95,138.6 ; JUSB1.13 76.1,139.91 ; JUSB1.13 76.95,139.91 ; JUSB1.13 76.1,137.29 ; JMDP1.13 215.35,132.04 ; JMDP1.13 214.8,131.49 ; JMDP1.13 214.91,131.05 ; JMDP1.13 214.91,131.93 ; JMDP1.13 215.79,131.05 ; JMDP1.13 215.79,131.93 ; JMDP1.13 215.35,130.94 ; H15.1 8.4,39.26 ; H15.1 5.1,39.26 ; H15.1 6.75,40.91 ; H15.1 6.75,37.61 ; H15.1 5.53,40.48 ; H15.1 7.97,38.04 ; H15.1 7.97,40.48 ; H15.1 5.53,38.04 ; 300.57,130.83 H22.1 ; H22.1 302.93,130.83 ; H22.1 300.15,129.65 ; H22.1 302.93,128.47 ; H22.1 303.35,129.65 ; H22.1 301.75,128.05 ; H22.1 300.57,128.47 ; H22.1 301.75,131.25 ; 184.15,121.77 SW1.5 ; SW1.5 183.17,122.75 ; SW1.5 183.4,123.49 ; SW1.5 185.13,122.75 ; SW1.5 184.15,123.72 ; SW1.5 184.89,123.49 ; SW1.5 183.4,122 ; SW1.5 184.89,122 ; 0.6,46.15 H16.1 ; H16.1 2.25,47.8 ; H16.1 3.47,47.37 ; H16.1 2.25,44.5 ; H16.1 1.03,44.93 ; H16.1 1.03,47.37 ; H16.1 3.47,44.93 ; H16.1 3.9,46.15 ; 157.72,129.67 JDOCK1.153 ; JDOCK1.153 157.72,131.58 ; JDOCK1.153 158.75,129.67 ; JDOCK1.153 159.78,130.63 ; JDOCK1.153 159.78,131.58 ; JDOCK1.153 158.75,131.58 ; JDOCK1.153 159.78,129.67 ; JDOCK1.153 157.72,130.63 ; JUSB2.11 83.4,133.55 ; JUSB2.11 84.25,130.05 ; JUSB2.11 82.55,133.55 ; JUSB2.11 82.55,131.8 ; JUSB2.11 83.4,130.05 ; JUSB2.11 82.55,130.05 ; 169.97,133.77 JDOCK1.158 ; JDOCK1.158 171.53,133.77 ; JDOCK1.158 171.53,135.33 ; JDOCK1.158 170.75,133.52 ; JDOCK1.158 170.75,135.58 ; JDOCK1.158 169.72,134.55 ; JDOCK1.158 171.78,134.55 ; JDOCK1.158 169.97,135.33 ; H8.1 254.31,76.93 ; H8.1 254.85,78.4 ; H8.1 251.37,76.93 ; H8.1 252.84,76.39 ; H8.1 254.31,79.87 ; H8.1 251.37,79.87 ; H8.1 252.84,80.41 ; H8.1 250.84,78.4 ; 54.75,136.95 H18.1 ; H18.1 53.57,137.37 ; H18.1 53.57,139.73 ; H18.1 55.93,139.73 ; H18.1 54.75,140.15 ; H18.1 56.35,138.55 ; H18.1 55.93,137.37 ; H18.1 53.15,138.55 ; JUSB3.4 290.61,100.98 ; JUSB3.4 290.75,101.5 ; JUSB3.4 290.61,102.02 ; JUSB3.4 290.09,102.16 ; JUSB3.4 289.43,101.5 ; JUSB3.4 290.09,100.84 ; JUSB3.4 289.57,100.98 ; JUSB3.4 289.57,102.02 ; 242.7,134.2 JHDMI1.21 ; JHDMI1.21 243.55,130.74 ; JHDMI1.21 244.4,130.74 ; JHDMI1.21 242.7,132.47 ; JHDMI1.21 244.4,132.47 ; JHDMI1.21 242.7,130.74 ; JDOCK1.154 179.28,131.54 ; JDOCK1.154 179.28,130.63 ; JDOCK1.154 175.22,129.71 ; JDOCK1.154 177.25,131.54 ; JDOCK1.154 179.28,129.71 ; JDOCK1.154 177.25,129.71 ; 219.1,129.37 JMDP1.22 ; JMDP1.22 220.6,130.65 ; JMDP1.22 219.85,131.93 ; JMDP1.22 220.6,131.93 ; JMDP1.22 220.6,129.37 ; JMDP1.22 219.1,130.65 ; JMDP1.22 219.85,129.37 ; 126.69,134.55 JDOCK1.145 ; JDOCK1.145 126.69,132.72 ; JDOCK1.145 126.69,136.38 ; JDOCK1.145 127.58,136.38 ; JDOCK1.145 127.58,132.72 ; 122.25,83.67 H2.1 ; H2.1 125.9,82.13 ; H2.1 125.33,83.67 ; H2.1 125.33,80.59 ; H2.1 123.79,84.24 ; H2.1 122.25,80.59 ; H2.1 123.79,80.02 ; H2.1 121.68,82.13 ; 4.35,30.22 JNGFF3.69 ; JNGFF3.69 4.95,27.86 ; JNGFF3.69 4.35,29.04 ; JNGFF3.69 4.35,27.86 ; JNGFF3.69 4.95,30.22 ; JMDP1.24 208.85,131.93 ; JMDP1.24 208.1,129.37 ; JMDP1.24 209.6,129.37 ; JMDP1.24 209.6,130.65 ; JMDP1.24 208.1,131.93 ; JMDP1.24 208.85,129.37 ; JMDP1.24 208.1,130.65 ; JUSB2.13 99.95,138.6 ; JUSB2.13 99.1,137.29 ; JUSB2.13 99.95,139.91 ; JUSB2.13 99.1,139.91 ; JUSB2.13 99.95,137.29 ; JUSB1.4 64.75,130.17 ; JUSB1.4 64.13,129.99 ; JUSB1.4 63.95,129.37 ; JUSB1.4 65.55,129.37 ; JUSB1.4 64.13,128.75 ; JUSB1.4 64.75,128.57 ; JUSB1.4 65.37,129.99 ; JUSB1.4 65.37,128.75 ; JMDP1.21 219.85,136.93 ; JMDP1.21 220.6,134.37 ; JMDP1.21 220.6,135.65 ; JMDP1.21 220.6,136.93 ; JMDP1.21 219.85,134.37 ; JHDMI1.22 228.1,137.9 ; JHDMI1.22 226,141 ; JHDMI1.22 227.05,137.9 ; JHDMI1.22 226,137.9 ; JHDMI1.22 226,139.45 ; JHDMI1.22 228.1,139.45 ; JHDMI1.22 228.1,141 ; JHDMI1.22 227.05,141 ; JHDMI1.5 233.8,133.93 ; JHDMI1.5 233.8,132.81 ; JHDMI1.5 234.25,132.92 ; JHDMI1.5 233.35,132.92 ; JHDMI1.5 233.35,133.82 ; JHDMI1.5 234.25,133.82 ; 208.1,134.37 JMDP1.23 ; JMDP1.23 208.1,136.93 ; JMDP1.23 208.85,136.93 ; JMDP1.23 208.1,135.65 ; JMDP1.23 208.85,134.37 ; JUSB2.7 91.87,130.25 ; JUSB2.7 90.63,130.25 ; JUSB2.7 92.05,130.87 ; JUSB2.7 90.45,130.87 ; JUSB2.7 91.25,130.07
  BOTTOM w0.076: v1(153.71,103.97) 153.93,103.97 154.25,103.65 154.25,101.06 154.35,100.96 154.35,100.34 154.16,100.15 152.8,100.15 152.58,100.38 152.58,101.15 152.35,101.38 152.35,101.71 152.37,101.73 152.37,102.09 152.35,102.12 152.35,102.51 152.6,102.76 v1(152.6,103.86)
  BOTTOM w0.102: v1(64.06,67.84) v3(64.06,68.47) ; v1(253.72,126.6) v3(254.35,126.6) ; v3(33.25,54.77) 33.39,54.63 v1(33.39,54.16) ; v1(97.6,124.8) v3(96.95,124.8) ; v1(229.75,116.45) v3(229.75,115.83) ; v1(284.17,28.99) v3(284.17,28.39) ; v1(229.72,83.03) v3(229.72,83.65) ; v1(207.81,116.67) v3(208.43,116.67) ; v1(21.47,58.2) v3(20.74,58.2)
  BOTTOM w0.152: UC1.BB60 140.2,80.89 140.2,80.02 v1(140.18,79.99)
  BOTTOM w0.178: UC1.AT71 132.85,84.39 v1(132.67,84.39) ; UC1.AG71 132.85,89.4 132.68,89.56 v1(132.67,89.62) ; v1(163.7,79.99) 163.67,80.02 UC1.BB18 ; v1(149.96,79.95) 149.99,79.98 UC1.BB43 ; UC1.BB34 154.94,80.64 154.94,79.35 v1(154.9,79.31) ; UC1.H71 132.85,99 v1(132.76,99.08) ; UC1.BB30 157.57,80.26 157.57,79.87 v1(157.7,79.74) ; UC1.BB64 137.86,80.38 v1(137.86,79.99) ; v1(152.63,79.92) 152.6,79.95 152.6,80.9 UC1.BB38 ; UC1.BB55 142.82,80.52 142.82,80.03 v1(142.86,79.99) ; UC1.AM71 133.48,86.74 132.73,86.74 v1(132.68,86.69) ; UC1.BB26 159.92,80.51 159.92,80 v1(159.97,79.95)
  BOTTOM w0.203: UC1.F1 174.18,100.36 v1(174.38,100.57) ; UC1.AK27 v1(158.61,88.83) ; UC1.J35 v1(153.58,98.03) ; v1(136.21,82.73) 136.4,82.73 UC1.AW66 136.75,82.91 137.71,82.91 UC1.AW64 138.25,82.86 138.28,82.89 138.57,82.89 138.6,82.86 UC1.AW62 139.47,82.86 139.51,82.89 139.8,82.89 139.83,82.86 UC1.AW60 140.7,82.86 140.73,82.89 141.03,82.89 141.06,82.86 UC1.AW57 141.98,82.86 142.01,82.89 142.3,82.89 142.33,82.86 UC1.AW55 143.2,82.86 143.23,82.89 143.53,82.89 143.56,82.86 UC1.AW53 144.43,82.86 144.46,82.89 144.76,82.89 144.79,82.86 UC1.AW51 145.6,82.86 145.63,82.89 145.92,82.89 145.95,82.86 UC1.AW49 146.85,82.86 146.88,82.89 147.18,82.89 147.21,82.86 UC1.AW47 148.02,82.86 148.05,82.89 148.34,82.89 148.37,82.86 UC1.AW45 149.24,82.86 149.27,82.89 149.57,82.89 149.63,82.83 150.05,82.83 UC1.AW43 ; v1(136.21,82.73) UC1.AY66 UC1.BA66 ; v1(136.21,82.73) 135.75,83.19 UC1.AV68 ; UC1.AL58 v1(141.69,88.11) ; v1(136.21,86.54) 135.91,86.84 UC1.AM68 ; v1(73.82,75.04) 74.19,75.41 PU201.1 ; UC1.AD20 162.58,91.18 162.15,91.18 UC1.AD21 ; UC1.AV68 135.44,83.19 v1(135.25,83) ; UC1.AV68 135.72,83.2 135.72,83.56 135.77,83.61 135.77,83.8 135.72,83.97 UC1.AT68 135.72,84.77 135.75,84.81 135.75,85.1 135.72,85.13 UC1.AP68 135.72,86 135.75,86.03 135.75,86.33 135.72,86.36 UC1.AM68 ; v1(151.8,83.37) 152.31,82.86 UC1.AW38 152.97,82.86 153,82.89 153.3,82.89 153.33,82.86 UC1.AW36 154.2,82.86 154.23,82.89 154.52,82.89 154.55,82.86 UC1.AW34 155.04,83.01 v1(155.38,83.35) 155.88,82.86 UC1.AW32 156.73,82.86 156.76,82.89 157.05,82.89 157.08,82.86 UC1.AW30 157.95,82.86 157.98,82.89 158.28,82.89 158.31,82.86 UC1.AW28 159.18,82.86 159.21,82.89 159.51,82.89 159.54,82.86 UC1.AW26 160.41,82.86 160.44,82.89 160.73,82.89 160.76,82.86 UC1.AW23 161.73,82.86 161.76,82.89 162.06,82.89 162.09,82.86 UC1.AW21 162.88,82.86 162.91,82.89 163.21,82.89 163.24,82.86 UC1.AW18 164.15,82.86 164.18,82.89 164.48,82.89 164.51,82.86 UC1.AW16 164.96,82.86 v1(165.47,83.37) 165.98,82.86 UC1.AW14 166.57,82.86 166.6,82.89 166.9,82.89 166.93,82.86 UC1.AW12 167.75,82.86 v1(168.24,83.34) 168.51,83.07 UC1.AW10 168.99,82.86 169.03,82.89 169.32,82.89 169.35,82.86 UC1.AW8 ; PU201.3 73.57,76.21 v1(73.53,76.17) ; UC1.AV1 174.52,83.07 v1(174.65,82.94) ; PC661.2 108.52,104.01 107.71,103.2 PU603.3 ; UC1.AM68 135.72,87.23 135.8,87.31 135.8,87.59 135.39,88 UC1.AK68 135.46,88.07 v1(135.8,88.41) 135.8,88.53 136.04,88.77 UC1.AH67 ; UC1.J38 v1(151.75,98.03) ; UC1.AL52 v1(145.35,88.16) ; v1(174.72,89.68) 174.52,89.87 173.86,89.87 UC1.AF1 UC1.AF2 172.89,89.96 172.33,89.96 UC1.AF4 ; UC1.K71 133.16,97.64 v1(132.9,97.38) ; UC1.BA1 173.9,81.21 UC1.BA2 ; UC1.D48 UC1.D47 147.13,101.25 147.51,101.25 147.54,101.23 147.83,101.23 147.85,101.25 148.24,101.25 UC1.D45 UC1.D44 ; UC1.AL66 136.79,87.05 136.83,87.01 137.21,87.01 137.26,87.05 UC1.AL65 137.42,87.05 137.47,87.01 137.85,87.01 137.89,87.05 UC1.AL64 ; UC1.K63 138.93,98.26 UC1.K61 ; UC1.AF63 138.75,89.64 138.75,88.94 UC1.AH63 ; UC1.AL55 v1(143.52,88.11) ; UC1.C1 174.47,102.25 v1(174.57,102.35) ; UC1.J32 v1(155.41,98.03) ; UZ4.11 v1(83.8,118.4)
  BOTTOM w0.254: UC1.G48 146.93,99.19 v1(147.19,99.44) ; UC1.K63 v1(138.3,97.55) UC1.K64 ; v1(163.61,100.73) 164.1,100.49 UC1.E18 ; UC1.AM13 167.33,87.44 v1(167.75,87.44) 167.76,87.44 168.09,87.77 UC1.AK11 ; UC1.BA57 v1(141.52,82.35) UC1.AW57 ; UC1.D14 v1(166.27,101.73) UC1.B14 ; JDOCK1.26 v1(140,139.8) ; UC1.T2 v1(172.61,94.86) UC1.T4 ; UC1.AW14 v1(166.09,82.2) UC1.BA14 ; UC1.G22 161.14,99.19 v1(160.89,99.44) ; v1(139.58,91.41) 139.29,91.12 UC1.AD62 ; v1(170.93,82.35) 170.89,82.39 UC1.AW6 ; v1(170.93,82.35) 171.18,82.6 171.68,82.6 171.94,82.35 v1(171.95,82.35) 172.06,82.24 172.19,82.24 172.55,81.87 UC1.AY3 UC1.BA2 ; v1(170.93,82.35) UC1.BA6 UC1.BB6 ; UC1.AM27 v1(158.15,86.56) ; v1(98.08,115.29) 98.14,115.35 98.93,115.35 JEDP1.8 ; UC1.Y17 UC1.V16 v1(165.63,94) 165.63,94.11 UC1.T15 UC1.R13 v1(166.21,95.7) UC1.N13 ; v1(161.21,129.29) 161,129.51 JDOCK1.101 ; 164.32,89.81 164.64,89.49 UC1.AG17 ; 164.32,89.81 UC1.AF17 ; 164.32,89.81 UC1.AG18 163.9,89.3 163.43,89.3 UC1.AG19 UC1.AG20 162.69,89.24 v1(162.37,88.91) ; UC1.F22 160.96,99.44 v1(160.89,99.44) ; UC1.D26 158.83,101.59 v1(159.04,101.8) ; v1(158.87,129.23) 159.2,129.23 159.5,129.53 JDOCK1.95 ; JDOCK1.58 v1(149,139.78) ; UC1.AP58 v1(140.78,85.27) ; UC1.E53 143.98,100.5 144.02,100.55 143.98,100.59 143.98,100.97 143.97,100.98 UC1.D53 v1(143.97,101.74) UC1.B53 ; v1(159.04,101.8) 159.51,101.33 UC1.D25 ; v1(159.04,101.8) 159.15,101.91 UC1.C25 ; UC1.AT23 v1(159.98,84.64) UC1.AR23 ; JDOCK1.87 156.5,129.27 v1(156.21,128.98) ; v1(143.04,129.26) 143,129.29 JDOCK1.37 ; PC641.2 v1(81.82,81.5) ; JDOCK1.93 158,129.74 158.16,129.57 v1(158.16,129.24) 157.76,129.24 157.5,129.5 JDOCK1.91 ; JDOCK1.49 146,129.79 146.34,129.45 v1(146.49,129.45) ; v1(153.71,103.97) 153.71,104.38 153.44,104.64 153.44,107.29 156.51,110.36 156.51,114.5 156,115.01 152.04,115.01 151.57,114.54 151.57,109.44 152.65,108.37 152.65,104.21 152.6,104.16 v1(152.6,103.86) ; UC1.AW49 v1(146.4,82.35) UC1.BA49 ; UC1.K66 v1(137,97.55) UC1.K65 ; UC1.G58 v1(140.78,99.44) ; JDOCK1.70 v1(152,139.8) ; v1(138.95,100.71) 139.01,100.77 UC1.D62 UC1.B62 ; JDOCK1.44 v1(144.5,139.8) ; UC1.AR48 v1(146.26,84.64) ; JDOCK1.94 158,139.47 158,139.47 158,139.76 158.23,139.99 v1(158.23,140.23) ; UC1.F42 150.32,99.84 v1(149.92,99.44) ; UC1.AK21 v1(161.74,88.18) UC1.AK22 ; UC1.AP32 v1(155.41,85.27) ; v1(162.37,88.91) 162.04,89.24 UC1.AG21 ; v1(162.37,88.91) 162.69,88.59 UC1.AJ20 ; UC8.7 141.76,121.71 141.54,121.93 v1(141.54,122.13) ; UC1.AN38 v1(152.67,85.91) UC1.AN37 ; 163.21,82.89 163.18,82.91 UC1.AU20 UC1.AT20 v1(162.72,84.64) UC1.AR20 ; UC1.F4 172.59,100.36 v1(172.6,100.35) 172.62,100.36 UC1.F2 ; UC1.B48 UC1.D48 ; JDOCK1.82 v1(155,139.78) ; UC1.AL28 v1(158.15,88.11) ; UC1.E46 v1(147.19,100.71) ; UC1.P21 UC1.T21 v1(162.37,94) ; UC1.F13 166.84,99.89 166.57,100.16 v1(166.38,100.16) 166.28,100.16 165.95,100.49 UC1.E15 ; v1(164.98,90.65) UC1.AD16 164.88,91.48 164.33,91.48 UC1.AB18 ; JDOCK1.64 v1(150.5,139.81) ; UC1.D39 v1(151.4,101.74) UC1.B39 ; UC1.AP70 v1(135.11,85.57) UC1.AP68 ; UC1.AG17 164.64,89.31 v1(164.98,88.97) UC1.AG16 UC1.AF15 166.21,89.96 166.21,89.68 166.79,89.11 UC1.AH13 166.51,88.55 UC1.AJ15 ; UC1.AG17 163.99,88.74 UC1.AJ18 163.99,88.55 163.81,88.37 163.81,87.9 UC1.AK18 v1(163.64,87.18) ; JDOCK1.61 150,130.55 150,129.54 150.28,129.26 v1(150.45,129.26) 150.5,129.3 JDOCK1.63 ; JDOCK1.43 144.5,129.34 v1(144.57,129.27) ; UC1.AR42 150.36,85 v1(149.91,84.64) 150.38,84.35 UC1.AT42 ; UC1.G43 149.32,99.19 v1(149.06,99.45) 148.8,99.19 UC1.G45 ; UC1.G60 v1(139.86,99.44) ; UC1.U67 136.04,94.19 v1(136.37,93.86) 136.69,94.19 UC1.U66 ; UC1.E21 161.81,100.71 161.81,100.71 v1(161.78,100.71) ; v1(163.64,85.27) 164.07,85.63 UC1.AP18 ; UC1.P17 v1(164.32,95.68) ; UC1.E65 v1(136.92,100.71) ; 90.57,102.29 89.69,102.93 88.88,102.93 v1(88.4,103.41) ; UC1.AN23 v1(159.98,85.91) ; v1(165.47,83.37) UC1.AU15 ; UC1.B22 v1(161.31,101.71) UC1.D22 ; UC1.AP20 v1(162.72,85.91) UC1.AN20 ; JDOCK1.114 v1(164,139.8) ; UC1.L4 v1(172.61,97.53) UC1.L2 ; JDOCK1.132 v1(168.5,139.8) ; v1(169.15,85.38) 169.37,85.16 169.43,85.16 UC1.AR8 ; UC1.AP28 v1(157.24,85.27) ; UC1.AP42 v1(149.92,85.27) UC1.AR43 ; UC1.F68 UC1.D69 134.67,100.87 v1(134.67,100.87) ; v1(142.61,86.79) 142.8,86.95 UC1.AM55 ; JDOCK1.8 v1(135.5,139.8) ; v1(170.96,95.83) UC1.N6 ; UC1.N10 v1(168.42,96.78) UC1.L11 ; UC1.AT56 142.36,84.56 v1(142.61,84.56) 143.06,84.92 UC1.AR55 ; JDOCK1.120 v1(165.5,139.8) ; UC1.F40 151.29,99.83 151.68,99.44 v1(151.74,99.44) 151.81,99.44 UC1.F38 ; UC1.G52 144.7,99.19 v1(144.44,99.45) ; UC1.AP35 v1(153.58,85.27) ; v1(132.72,82.82) 132.9,83 UC1.AV71 UC1.AV70 UC1.AV69 v1(135.25,83) ; v1(135.72,92.04) 135.39,92.36 UC1.AA68 ; UC1.AR50 v1(145.35,84.64) UC1.AR52 v1(144.44,84.64) ; UC1.D44 v1(148.92,101.74) UC1.B44 ; JDOCK1.31 v1(141.5,129.32) ; UC1.U69 134.74,94.19 v1(134.42,93.86) 134.09,94.19 UC1.U70 ; UC1.P19 v1(163.68,94.84) UC1.T18 164.14,94.27 164.5,94.27 UC1.T17 ; UC1.A5 172.27,103.68 v1(172.27,104.21) ; UC1.BA36 v1(153.76,82.35) UC1.AW36 ; v1(168.24,83.34) 168.67,83.66 UC1.AU10 ; JDOCK1.57 149,129.61 148.96,129.56 148.96,129.17 v1(148.79,129) 148.5,129.29 JDOCK1.55 ; v1(138.95,86.56) UC1.AM61 ; UC1.AM61 139.5,87.04 140.23,87.04 UC1.AM60 ; UC1.AM61 UC1.AK63 v1(138.29,88.38) ; JEDP1.15 98.61,111.31 v1(98.96,111.31) ; v1(137.67,92.04) 137.34,92.36 UC1.AA65 ; JDOCK1.20 v1(138.5,139.8) ; UC1.L20 162.69,96.88 162.25,96.44 162.25,96.3 UC1.N21 161.72,96.42 v1(161.72,96.52) ; UC1.AR11 168.04,85.29 v1(168.25,85.29) 168.67,85.63 UC1.AP10 ; v1(164.08,129.29) 164,129.38 JDOCK1.113 ; UC1.D66 v1(136.53,101.74) UC1.B66 ; UC1.F35 154.01,99.84 v1(153.63,99.45) 153.24,99.84 UC1.F37 ; JDOCK1.138 v1(170,139.8) ; UC1.AP63 v1(138.04,85.27) ; v1(138.29,88.38) UC1.AH64 ; v1(138.29,88.38) UC1.AH63 ; JDOCK1.13 137,129.59 v1(137.51,129.08) ; v1(160.9,98.01) 161.14,98.26 UC1.K22 ; UC1.BA23 v1(161.22,82.35) UC1.AW23 ; UC1.L16 v1(164.97,96.52) UC1.L17 ; UC1.AR46 147.68,85 v1(148.09,84.68) 148.5,85 UC1.AR45 ; UC1.AN30 v1(157.24,85.91) UC1.AN28 ; UC1.AP38 v1(151.75,85.27) ; UC1.N65 137.34,96.02 v1(137.67,95.69) ; UC1.AT2 172.79,84.45 v1(172.61,84.28) 172.43,84.45 UC1.AT4 ; UC1.AL38 v1(152.67,88.21) ; UC1.AM21 v1(161.81,86.54) ; v1(147.18,86.56) UC1.AM46 147.18,87.41 UC1.AL48 ; UC1.B58 v1(141.49,101.74) UC1.D58 ; UC1.AM8 170.04,87.41 UC1.AK8 170.04,88.01 v1(169.68,88.37) ; UC1.R6 v1(171.68,94.8) ; UC1.W9 169.39,93.16 v1(169.07,93.48) 168.74,93.81 UC1.U10 ; v1(170.9,96.8) 170.48,96.8 UC1.L8 ; UC1.F33 155.05,99.84 v1(155.4,99.49) 155.75,99.84 UC1.F32 ; 149.01,87.41 UC1.AM43 v1(149.01,86.56) 148.61,86.95 UC1.AM45 ; 149.01,87.41 UC1.AM45 ; 149.01,87.41 UC1.AL45 ; UC1.AL32 v1(156.32,88.11) ; UC1.AW32 v1(156.24,82.35) UC1.BA32 ; UC1.BA71 132.94,81.05 v1(132.67,80.78) 132.86,80.58 UC1.BB70 ; v1(160.89,99.44) 160.83,99.44 UC1.F23 ; JDOCK1.50 v1(146,139.8) ; JDOCK1.123 166.5,129.35 v1(166.41,129.26) 166.53,129.13 166.85,129.13 167,129.28 JDOCK1.125 ; JDOCK1.32 v1(141.5,139.8) ; UC1.AF63 UC1.AE64 UC1.AE65 UC1.AE66 136.69,90.86 v1(136.37,91.18) 136.04,90.86 UC1.AE67 UC1.AE68 UC1.AE69 134.42,90.99 v1(134.42,91.16) ; UC1.A67 135.86,103.39 135.58,103.66 v1(135.58,103.79) ; JDOCK1.102 v1(161,139.8) ; UC1.E56 v1(141.69,100.71) ; v1(135.53,79.83) 135.53,79.94 135.83,80.24 135.83,80.56 UC1.BB67 ; UC1.AP23 v1(159.98,85.27) ; UC1.Y20 UC1.Y21 161.72,92.42 v1(161.72,92.33) 162.04,92 UC1.AB21 UC1.AD21 ; v1(169.1,100.18) UC1.F8 ; UC1.K16 v1(165.64,97.35) ; v1(146.26,100.71) 146.04,100.49 UC1.E50 ; UC1.N68 135.39,96.02 v1(135.72,95.69) ; UC1.D18 v1(163.79,101.71) UC1.B18 ; v1(100.06,117.69) 99.92,117.55 99.92,117.13 JEDP1.4 ; UC1.K18 UC1.H18 v1(163.64,98.81) ; JDOCK1.47 145.5,129.64 v1(145.98,129.16) ; v1(138.04,85.91) 138.21,86.06 138.24,86.06 138.38,86.2 UC1.AN63 ; UC1.BA45 v1(148.81,82.35) ; UC1.AN32 v1(155.41,85.91) ; v1(98.57,116.02) 98.73,116.18 99.53,116.18 JEDP1.6 ; UC1.AK69 134.73,88.07 134.91,88.25 135.22,88.25 UC1.AK68 ; JDOCK1.25 v1(140,129.26) ; UC1.P20 v1(163.02,95.7) UC1.N19 v1(163.68,96.52) UC1.L18 ; UC1.U64 137.99,94.19 v1(138.32,93.86) 138.64,94.19 UC1.U63 ; UC1.G5 v1(170.95,99.42) UC1.G6 ; UC1.AJ4 v1(171.61,88.37) UC1.AH6 ; UC1.W13 v1(167.21,92.62) ; UC1.AR63 v1(138.04,84.64) UC1.AT63 ; UC1.AT35 v1(153.58,84.64) UC1.AR35 ; v1(170.25,91.57) UC1.AB8 ; UC1.K70 134.71,97.64 134.82,97.74 UC1.K68 UC1.K67 136.4,97.48 v1(136.4,97.49) ; UC1.AT28 v1(157.24,84.64) UC1.AR28 ; UC1.BA62 v1(139.04,82.35) UC1.AW62 ; v1(151.29,82.35) UC1.BA41 ; JDOCK1.14 v1(137,139.8) ; JDOCK1.75 v1(153.5,129.32) ; UC1.Y19 v1(163.67,93.16) UC1.V18 164.21,93.8 164.43,93.8 UC1.V17 ; UC1.AR16 v1(165.47,84.64) UC1.AR15 ; UC1.AR53 v1(143.52,84.64) ; v1(170.51,128.57) 170,129.08 JDOCK1.137 ; UC1.AD8 v1(170.33,90.51) ; UC1.G66 v1(135.9,99.44) ; UC1.C5 v1(171.33,101.77) UC1.D6 ; UC1.AN42 150.44,86.3 v1(150.84,85.91) UC1.AN40 ; UC1.AT58 v1(140.78,84.64) UC1.AR58 ; UC1.AA2 UC1.AA4 171.91,92.41 v1(171.69,92.63) 171.69,92.75 UC1.W6 ; UC1.AY71 v1(132.72,81.7) ; UC1.AW28 v1(158.74,82.35) UC1.BA28 ; UC1.E11 167.42,100.49 167.22,100.69 v1(167.22,100.79) 167.67,101.24 168.05,101.24 UC1.D11 UC1.D10 UC1.B10 ; UC1.AN35 v1(153.58,85.91) ; JEDP1.28 93.19,107.16 93.17,107.16 v1(93.11,107.54) 93.44,107.6 JEDP1.27 ; UC1.J11 v1(167.3,98.17) UC1.J13 ; JDOCK1.38 v1(143,139.8) ; UC1.AM45 v1(148.09,86.56) ; JNGFF2.25 281.35,96.6 v1(281.4,96.55) ; JDOCK1.108 v1(162.5,139.8) ; UC1.D30 v1(156.36,101.74) UC1.B30 ; UC1.BA53 v1(143.99,82.35) UC1.AW53 ; PH603.1 v1(108.55,97.77) ; v1(151.8,83.37) 152.21,83.66 UC1.AU38 ; UC1.AL66 136.69,87.03 v1(136.21,86.54) ; UC1.H15 v1(165.43,98.79) ; v1(151.98,129.3) 152,129.33 JDOCK1.69 ; UC1.E6 v1(170.13,100.16) ; v1(155.38,83.35) 155.84,83.7 UC1.AU32 ; UC1.AW10 v1(168.51,82.35) UC1.BA10 ; UC1.AF10 v1(168.42,90.51) ; UC1.AM25 v1(159.07,86.56) ; UC1.J25 v1(159.07,98.01) ; UC1.AB15 v1(165.63,92.33) UC1.AB16 ; UC1.BA18 v1(163.67,82.17) UC1.AW18 ; JDOCK1.81 155,129.73 155.2,129.52 v1(155.2,128.99) ; UC1.AR5 171.41,84.91 171.13,84.63 v1(170.94,84.63) ; UC1.AL35 v1(154.49,88.21) ; v1(162.91,129.07) 162.5,129.48 JDOCK1.107 ; v1(167.74,90.44) 167.22,90.44 167.15,90.51 UC1.AD13 ; UC1.D34 v1(153.88,101.74) UC1.B34 ; UC1.E71 132.89,100.8 v1(132.76,100.93) ; JDOCK1.19 v1(138.5,129.29) ; v1(132.94,102.8) 132.98,102.76 133.43,102.76 UC1.B71 UC1.A70 ; UC1.AD20 162.9,90.86 163.14,90.86 UC1.AD19 ; UC1.J42 v1(149.92,98.03) ; UC1.J8 v1(169.09,98.11) ; JDOCK1.96 159.5,140.04 v1(159.28,140.27) ; v1(135.5,129.26) JDOCK1.7 ; UC1.AL4 172.43,87.1 v1(172.61,86.93) 172.79,87.1 UC1.AL2 ; JDOCK1.76 v1(153.5,139.8) ; JDOCK1.131 168.5,129.45 168.31,129.26 v1(168.31,129.26) ; UC1.G55 v1(142.61,99.44) ; UC1.J28 v1(157.24,98.03) ; UC1.AN33 v1(154.49,85.91) ; JDOCK1.88 v1(156.5,139.8) ; UC1.AK16 v1(165.47,87.18) ; UC1.F27 158.41,99.84 158.11,100.14 v1(158.08,100.14) 157.78,99.84 UC1.F28 ; JDOCK1.119 165.5,128.94 v1(166.02,128.42) ; JDOCK1.126 v1(167,139.8) ; UC1.AN58 v1(140.78,85.91) ; v1(133.7,129.32) 134,129.62 JDOCK1.1 ; v1(168.21,99.43) UC1.G10 ; JDOCK1.52 v1(147.5,139.8) ; UC1.G63 v1(137.93,99.44)
  BOTTOM w0.279: JXDP1.32 v1(125.89,119.01) ; JXDP1.38 v1(127.39,119.01) ; v1(119.63,124.39) 119.89,124.65 JXDP1.7 ; v1(133.4,128.1) 133.4,127.9 132.89,127.39 JXDP1.59 ; JXDP1.31 v1(125.89,127.68) ; JXDP1.50 v1(130.39,119.01) ; JXDP1.26 v1(124.39,119.01) ; JXDP1.37 127.39,127.47 127.18,127.68 v1(126.88,127.68) ; v1(121.53,127.68) 121.39,127.54 JXDP1.13 ; JXDP1.19 v1(122.89,127.68) ; JXDP1.25 124.39,127.63 v1(124.62,127.86) ; v1(130.25,124.52) 130.25,124.88 130.39,125.01 JXDP1.49 ; JXDP1.2 118.39,119.25 118.2,119.06 116.93,119.06 116.6,119.39 v1(116.6,121.15) ; JXDP1.20 v1(122.89,119.01) ; JXDP1.14 v1(121.39,119.01) ; v1(119.67,117.32) 119.67,118.33 119.89,118.55 JXDP1.8
  BOTTOM w0.305: v1(278.89,94.32) 278.89,94.65 279.34,95.1 JNGFF2.19 ; JNGFF2.43 281.35,101.1 v1(281.4,101.15) ; JDIMM1.23 88.88,50.92 88.71,51.09 v1(87.88,51.09) ; v1(200.16,78.48) 199.9,78.75 JSPI1.1 ; JKBTP1.9 279.1,7.77 v1(278.98,7.66) ; JNGFF1.10 v1(247.85,51.32) ; JDIMM1.9 v1(85.37,51.17) ; JNGFF1.55 259.1,46.13 v1(259.01,46.21) ; JNGFF1.15 v1(249.1,43.76) ; JNGFF3.3 24.95,35.62 v1(25.18,35.85) 25.45,35.58 JNGFF3.1 ; JNGFF2.49 281.17,102.6 v1(281.4,102.83) ; JNGFF3.39 v1(15.95,35.88) ; JUSH1.20 287.4,8.95 v1(287.06,9.29) 286.9,9.14 JUSH1.21 ; v1(21.37,35.91) 21.56,35.91 21.95,35.52 JNGFF3.15 ; v1(14.62,35.94) 14.45,35.77 JNGFF3.45 ; JNGFF1.7 245.1,45.7 245.32,45.91 245.75,45.91 245.96,45.7 v1(245.96,45.41) ; v1(198.52,80.51) 198.52,80.46 198.9,80.09 JSPI1.3 ; JNGFF1.31 253.1,45.77 253.35,46.02 v1(253.36,46.02) ; v1(22.6,35.85) 23.16,35.85 23.45,35.56 JNGFF3.9 ; v1(170.53,115.99) 170.39,115.84 UZ20.5 ; JKBTP1.17 279.43,11.77 278.95,12.25 278.95,13.27 v1(278.96,13.27) JKBTP1.20 ; JUSH1.17 288.9,9.6 v1(288.99,9.69) ; JDIMM1.31 90.88,50.84 90.64,51.08 v1(89.88,51.08) JDIMM1.27 ; JNGFF2.63 279.41,106.1 v1(279.18,106.33) 279.45,106.6 JNGFF2.65 ; JNGFF1.61 260.6,44.88 v1(260.6,46.03) ; UZ19.5 162.07,115.78 v1(162.2,115.91) ; JNGFF1.22 v1(250.85,51.32) ; JKBTP1.3 279.31,4.77 v1(279.02,4.48) 279.22,4.27 JKBTP1.2 ; JNGFF2.3 279.17,89.1 278.91,89.36 v1(278.91,89.51) 279.01,89.6 JNGFF2.5 ; v1(281.37,99.41) 281.18,99.6 JNGFF2.37 ; JNGFF1.67 262.1,46.71 v1(262.24,46.85) ; JNGFF1.43 v1(256.1,46.2) ; JSPI1.2 199.4,80.28 v1(199.16,80.51) ; JNGFF3.27 v1(18.95,35.88) ; JNGFF1.25 251.6,43.88 251.75,43.73 v1(253.24,43.73) ; v1(253.22,40.78) 252.73,40.78 252.5,41 JLPDE1.9 ; JNGFF2.31 281.21,98.1 v1(281.38,98.27) ; JNGFF3.57 v1(11.45,33.69) ; JNGFF1.1 243.6,46.89 v1(243.13,47.37) ; v1(257.74,47.57) 257.92,47.39 257.92,45.91 257.6,45.58 JNGFF1.49 ; JNGFF1.21 250.6,43.84 v1(250.49,43.73) ; JNGFF1.16 v1(249.35,51.32) ; v1(252.24,51.33) 252.35,51.43 JNGFF1.28 ; v1(83.18,48.1) 83.18,48.59 83.37,48.78 JDIMM1.1 ; JNGFF3.21 v1(20.45,35.88) ; JUSH1.2 296.4,7.84 v1(296.14,7.58) 295.9,7.81 JUSH1.3 ; v1(178.92,76.44) 178.48,76.44 178.27,76.65 178.27,77.24 177.92,77.58 CC214.2 ; JKBTP1.15 279.06,10.77 278.75,10.46 278.75,10.45 v1(278.76,10.45) ; JNGFF3.51 12.95,33.91 13.14,33.71 v1(13.75,33.71) ; JNGFF2.11 v1(277.85,91.1) ; JNGFF3.33 v1(17.45,35.88) ; JNGFF1.37 v1(254.6,46.19) ; JDIMM2.81 v1(183.97,51.28)
  BOTTOM w0.356: v1(187.4,93.09) 187.07,93.09 CC10.2 ; v1(156.89,116.05) 157.11,115.83 CZ82.2 ; CV114.2 199.59,105.66 v1(199.31,105.94) ; v1(207.81,116.67) 207.81,116.23 206.94,115.36 CV121.2 ; CV88.2 215.19,111.95 CV85.2
  BOTTOM w0.381: UV11.7 196.22,124.92 195.92,124.62 v1(195.92,124.38) ; CZ10.2 292.9,12.14 v1(292.77,12.26) ; CZ85.2 173.04,115.68 v1(173.48,116.11) ; v1(282.88,9.28) 282.88,10.12 CZ27.2 ; CV91.2 220.24,112.62 v1(220.8,112.06) ; v1(173.3,110.19) 173.52,110.41 CC281.2 ; v1(87.88,51.09) 87.18,51.09 86.88,50.78 JDIMM1.15 ; CZ64.2 82.17,116 v1(82.41,115.76) ; CZ44.2 81.85,120.34 v1(81.79,120.34) ; JDIMM1.19 87.88,47.85 v1(87.29,47.26) ; UC12.3 178.55,113.87 RC227.2 ; v1(287.63,10.5) 287.96,10.83 CZ12.2 ; CV27.2 240.94,128.32 CV26.2 ; CZ11.2 292.21,11.41 v1(292.21,12.25) ; CZ24.2 285.87,11.48 v1(285.76,11.59) ; v1(191.47,86.75) 191.13,86.75 190.44,87.44 UC7.3 ; UV12.7 v1(199.41,119.33) ; v1(206.78,120.35) 206.73,120.4 CV118.2 ; JDIMM1.5 84.37,50.77 84.78,51.18 85.37,51.18 v1(85.37,51.17) ; v1(187.42,101.63) 187.17,101.38 CC9.2 ; CC30.1 145.63,117.66 145.63,117.15 v1(145.62,117.14) ; CV23.2 v1(246.61,132.06)
  BOTTOM w0.406: v1(160.88,120.01) 161.11,119.78 UC13.3 ; DI4.3 288.83,98.59 v1(288.87,98.62) ; JMDP1.14 215.25,128.19 v1(215.26,128.18) ; v1(204.89,80.22) 204.57,80.53 204.57,81.29 205.06,81.78 PR116.2 ; v1(213.43,128.16) 213.45,128.18 JMDP1.8
  BOTTOM w0.457: CC312.2 136.15,107.93 v1(136.52,107.56) ; CC306.2 127.96,117.74 127.3,118.4 127.3,118.92 v1(127.39,119.01) ; v1(179.47,111.21) 179.47,113.53 179,113.99 RC227.2 ; v1(163.8,107.59) 164.4,106.99 CC195.2
  BOTTOM w0.508: PQ809.3 63.01,59.07 v1(62.96,59.03) ; QV9.3 v1(207.12,125.78) ; RC141.2 155.94,106.7 155.6,107.04 v1(155.39,107.04) 155.06,106.71 RC166.2 ; CC22.2 155.81,111.11 v1(155.99,111.29) ; PC1176.2 118.4,93 v1(118.4,92.62) ; C33.2 174.09,124.16 174.37,123.88 v1(174.37,123.67) ; CV509.2 217.65,124.7 v1(217.66,124.68) ; RV20.2 248.46,130.21 248.46,132.2 v1(248.33,132.33) ; PC209.2 79.67,74.27 v1(79.86,74.46) ; v1(117.51,96.43) 117.51,96.05 PC1011.2 ; PC1079.2 122.6,110.32 v1(123.04,110.32) ; JUSH1.27 v1(298.05,5.28) ; v1(41.07,49.11) 41.07,48.52 PC805.2 ; JSIM1.14 v1(290.51,109.92) ; CV619.1 215.33,106.34 v1(215.15,106.52) ; v1(200.67,82.23) 201.2,82.76 JSPI1.21 ; v1(94.27,88.63) PC647.1 93.41,87.87 PR647.1 ; v1(214.99,120.67) 215.41,121.09 CV92.2 ; 189.8,51.95 190.5,52.65 206.56,52.65 207.29,51.93 ; PC1173.2 122.65,111.54 v1(123.04,111.54) ; v1(113.7,96.43) 113.7,96.05 PC1081.2 ; v1(269.09,79.79) 269.59,79.28 CR37.2 ; PC1178.2 116.24,88.55 v1(116.24,88.93) ; CV85.2 215.1,111.48 214.72,111.1 v1(214.15,111.1) ; JEDP1.44 v1(88.5,104.11) ; v1(175.18,124.04) 175.18,124.49 C316.2 ; JSD1.26 v1(292.4,85.27) ; JRTC1.2 v1(278.63,17.4) ; UV27.2 v1(219.81,128.18) ; PC629.1 89.9,90.36 89.9,91.35 v1(89.72,91.52) ; CC21.2 152.28,111.11 v1(152.08,111.31) ; v1(275.3,55.27) 275.96,55.27 276.66,55.97 JSD1.23 ; v1(206.6,118.68) 206.83,118.68 207.12,118.97 QV10.3 ; CV90.2 220.22,111.48 v1(220.8,112.06) ; v1(213.43,128.16) 213.55,128.05 213.55,125.69 213.17,125.31 RV503.1 ; v1(82.35,92.01) 82.75,92.41 PC644.2 83.79,91.89 84.7,91.89 PR654.1 ; RC86.1 140.59,108.8 140.33,108.54 CC304.2 ; RC86.1 v1(140.85,109.42) ; RC86.1 140.85,108.8 CC303.2 ; v1(169.07,120.84) 168.81,120.57 CZ84.2 ; PC677.2 v1(97.34,81.82) ; v1(226.79,122.35) v3(226.34,122.8) 225.19,122.8 224.83,122.44 CV616.2 ; v1(168.64,121.32) 168.6,121.28 CC273.2 165.38,120.51 CZ87.2 ; v1(178.97,106.9) 178.42,106.36 CC302.2 ; JSIM1.5 v1(302.57,122.02) ; v1(288.08,16.21) 288.62,16.75 JLED1.6 ; PC206.2 v1(71.66,72.06) ; v1(220.51,124.35) 220.76,124.1 UV27.4 ; v1(106.63,123.06) v3(106.63,120.43) 106.63,118.4 107.39,117.64 DV4.1 ; v1(279.54,22.04) 280.02,21.56 JRTC1.4 ; CC221.2 168.25,112.4 v1(168.79,112.95) ; PC1179.2 116.88,93 v1(116.88,92.62) ; PC1010.2 120.24,113.83 v1(120.62,113.83) ; PC1077.2 112.75,105.89 v1(113.13,105.89) ; PC404.2 235.78,41.94 v1(235.58,42.14) ; v1(298.49,72.04) v1(302.03,72.04) ; RC139.1 131.19,117.88 v1(131.19,118.45) ; v1(280.15,85.75) 280.15,85.71 280.15,85.7 JSD1.24 ; RC316.1 v1(201.24,89.33) ; v1(116.24,96.43) 116.24,96.05 PC1080.2 ; PH601.1 93.51,82.43 v1(93.96,81.97) ; JDIMM1.261 150.55,54.64 v1(148.14,52.23) 146.61,52.23 ; v1(271.41,66.99) 272.8,65.6 JSD1.6 ; RC136.1 145.97,119.53 146.31,119.19 CC308.2 v1(146.31,118.17) ; v1(117.76,88.93) 117.76,88.55 PC1175.2 ; PC2.2 282.64,17.26 v1(282.7,17.19) ; CV93.2 213.01,115.2 v1(212.28,115.93) 212.28,114.75 CV97.2 ; JIR1.8 55.4,133.68 v1(55.01,134.07) ; 127.77,52.14 v1(119.38,52.14) 109.98,52.14 109.62,51.79 ; v1(194.35,116.1) 194.35,115.67 194.79,115.22 RV509.1 ; v1(286.06,108.91) 285.5,108.35 CZ53.2 CZ51.2 ; PC1075.2 114.97,96.05 v1(114.97,96.43) ; PC1008.2 120.24,110.02 v1(120.62,110.02) ; PC1174.2 125.02,110.32 v1(125.45,110.32) ; JEDP1.45 v1(89.11,99.81) ; CV617.1 226.03,102.64 v1(226.83,101.84) ; CV94.2 222.88,119.35 v1(223.1,119.57) ; v1(164.59,127.15) 164.63,127.11 C319.2 ; v1(108.3,123.73) 108.3,124.11 108.67,124.48 CC307.2 ; v1(212.01,116.95) CV89.2 CV86.2 ; v1(184.86,86.69) 184.86,86.4 v3(185.19,86.08) 185.81,86.08 186.12,86.38 RC65.2 ; v1(194.52,96.02) 194.72,96.22 UC5.4 ; C263.2 v1(283.61,122.72) ; JDIMM2.262 163.55,53.64 v1(165.91,51.28) ; PC1076.2 112.75,108.43 v1(113.13,108.43) ; v1(79.69,92.62) 78.89,92.62 78.28,92 JFAN1.6 ; v1(218.89,117.42) 218.89,116.83 CV99.2 ; CL22.1 v1(290.18,127.12) ; C42.2 151.39,127.11 150.35,128.15 150.35,129.15 v1(150.45,129.26) ; v1(276.64,21.65) 276.55,21.56 JRTC1.3 ; JNGFF2.68 281.36,87.5 v1(281.37,87.5) ; PC1137.2 114.59,88.55 v1(114.59,88.93) ; RC109.1 v1(126.68,99.6) CC300.2 ; v1(286.51,123.79) 286.52,123.78 JSIM1.12 ; v1(197.36,90.43) 197.24,90.31 UC6.4 ; JSPK1.6 v1(290.85,36.82) ; v1(90.15,92.06) 90.15,92.29 89.82,92.62 PC649.2 ; JLED1.10 v1(293.2,13.85) ; PC128.2 205.17,82.69 PR118.2 205.31,83.57 205.92,84.18 v1(205.92,84.36) ; JSD1.21 272.1,69.85 271.52,70.43 v1(269.72,70.43) ; RV660.2 220.89,105.34 v1(220.89,106.09) ; v1(113.13,107.16) 112.75,107.16 PC1001.2 ; PC1073.2 120.24,111.29 v1(120.62,111.29) ; CC226.2 v3(162.6,114.21) 162.6,115.52 v1(162.2,115.91) ; v1(81.19,118.58) 81.39,118.78 CZ45.2 CZ69.2 ; v1(81.94,60.84) 82.95,59.83 JDIMM1.262 ; v1(118.41,129.65) 117.1,129.65 RC122.2 ; CC269.2 108.72,122.34 v1(108.63,122.42) ; v1(216.37,124.67) 216.11,124.67 215.75,125.04 RV502.1 ; v1(75.54,57.49) PC218.2 ; CC25.2 203.83,79.13 CMOS1.2 205.5,79.13 v1(205.72,79.35) ; v1(269.72,73.57) 269.72,72.87 CR38.1 270.75,72.61 CR39.1 ; JSIM1.15 295.45,109.47 v1(295.44,109.46) ; JSIM1.11 294.22,125.41 v1(294.22,125.41) ; C43.2 155.47,127.11 154.86,127.73 154.86,128.76 155.09,128.99 v1(155.2,128.99) ; v1(242.71,126.08) 242.71,126.07 242.99,126.35 UV2.2 ; RC112.1 v1(126.73,100.62) RC110.1 ; CC8.1 181.49,100.03 v1(181.12,100.4) ; PR908.1 v1(9.04,42.91) ; JSIM1.10 303.41,124.3 v1(303.4,124.29) ; PC618.1 82.59,82.46 v1(82.08,82.97) 82.46,83.35 PC619.1 ; PR680.2 v1(91.48,81.8) ; JSPK1.5 v1(290.87,27.37) ; RZ10.1 CZ68.2 296.31,12.28 v1(296.33,12.29) ; v1(278.55,13.75) 278.55,14.8 277.98,15.37 JKBTP1.22 ; PC1018.2 113.57,93 v1(113.57,92.62) ; v1(87.86,94.4) 87.81,94.34 PC652.2 ; v1(170.32,112.98) 170.32,112.43 CC219.2 170.93,111.24 CC264.2 ; v1(272.65,83.05) 272.98,82.73 JSD1.22 ; v1(83.42,91.39) 83.2,91.16 PC604.2 ; v1(180.3,95.28) 178.61,95.28 RC268.2 ; CV27.2 242.07,127.19 242.07,125.83 v1(242.28,125.62) ; UV9.4 207.11,113.48 206.84,113.75 v1(206.51,113.75) ; CC7.1 v1(188.4,89.55) ; RC349.2 188.81,77.75 v1(188.3,77.24) ; v1(192.75,121.45) 193.38,120.81 v3(193.98,120.81) RV508.1 ; v1(120.62,112.56) 120.24,112.56 PC1002.2 ; PC602.2 83.02,85.24 v1(83.35,85.57) ; v1(240.55,41.7) 240.07,41.22 PC408.2 ; v1(76.81,57.49) PC220.2 ; PR653.1 90.87,92.5 v1(91.03,92.67) 91.42,93.06 PC645.2 ; v1(271.22,73.25) 271.77,72.7 JSD1.3 ; v1(173.67,123.68) 172.57,124.79 C317.2 ; JSPI1.22 v1(189.16,82.76) ; v1(211.87,119.6) CV96.2 212.56,118.75 CV98.2 ; v1(73.37,97.7) 73.37,98.15 73.42,98.21 JFAN1.5 ; JNGFF1.69 v1(264.52,45.65) ; v1(228.06,57.86) 228.17,57.75 JDIMM2.261 ; v1(214.91,101.98) CV618.2 ; v1(115.22,92.62) 115.22,93 PC1019.2 ; v1(143.7,123.76) 144.12,124.17 R268.2 C310.2 ; JNGFF1.68 v1(242.5,47.5) ; PC207.1 v1(79.38,78.11) ; PC216.2 v1(74.27,58.33) ; JSD1.13 299.85,85.78 299.54,86.09 v1(299.12,86.09) ; CC305.2 137.45,110.85 137.18,111.12 v1(136.89,111.12) ; v1(128.03,105.02) v3(128.03,106.08) 127.28,106.83 RC113.1 CC310.2 ; v1(286.2,113.7) 286.2,112.8 JSIM1.13 ; v1(221.46,114.72) 221.08,115.1 CV101.2 ; JEDP1.43 v1(91.67,110.78) ; CZ67.2 v1(282.84,119.41) ; JUSH1.28 282.54,5.52 v1(282.54,6.71) ; PC1015.2 112.94,88.55 v1(112.94,88.93) ; PC661.2 v1(109.19,104.49) ; v1(282.99,117.89) CZ65.2 CZ66.2 ; JSD1.10 296.55,85.67 v1(297.03,86.14) ; PR110.2 212.38,83.87 213.45,82.8 v1(213.8,82.8) ; JSD1.20 272.2,58.3 271.84,58.66 v1(271.45,58.66) ; RC182.1 147.3,111.87 146.73,112.43 145.01,112.43 v1(144.64,112.06) RC180.1 ; JSD1.25 v1(294.25,54.74) ; JKBTP1.21 v1(278.19,1.67) ; JSD1.17 v1(296.55,54.39) ; JNGFF2.69 v1(277.72,108.2) ; JLED1.9 v1(292.98,22.05) ; v1(50.98,131.21) 50.98,132 JIR1.7 ; v1(78.25,111.54) PJPDC1.7
  vias: v1(0.51,57.76) v1(0.51,48.93) v1(0.52,43.26) v1(0.52,35.64) v1(0.52,28.02) v1(6.39,34.83) v1(6.39,34.26) v1(6.74,60.78) v1(14.36,60.78) v1(18.6,38.08) v1(21.99,61.78) v1(26.26,55.79) v1(26.26,54.39) v1(27.4,55.79) v1(27.4,54.39) v1(28.19,31.67) v1(29.17,37.75) v1(29.5,48.61) v1(29.61,61.78) v1(32.8,37.75) v1(33.44,48.68) v1(33.44,48.1) v1(36.68,37.82) v1(37.23,61.78) v1(40.23,55.41) v1(40.23,53.88) v1(40.37,37.77) v1(40.68,39.91) v1(41.12,42.58) v1(41.12,41.94) v1(41.31,39.91) v1(41.5,55.41) v1(41.5,53.88) v1(42.45,39.91) v1(43.09,39.91) v1(44.85,61.78) v1(47.99,37.77) v1(49.25,46.2) v1(49.25,45.56) v1(49.25,44.93) v1(49.25,44.29) v1(49.76,134.16) v1(50.01,46.2) v1(50.01,45.56) v1(50.01,44.93) v1(50.01,44.29) v1(50.77,46.2) v1(50.77,45.56) v1(50.77,44.93) v1(50.77,44.29) v1(50.86,134.26) v1(50.85,133.63) v1(50.99,64.07) v1(51.34,133.14) v1(51.34,132.51) v1(51.98,133.14) v1(51.98,132.51) v1(52.61,133.14) v1(52.61,132.51) v1(54.07,56.3) v1(54.06,55.46) v1(54.44,130.04) v1(54.9,56.3) v1(54.9,55.47) v1(55.65,66.92) v1(55.61,37.77) v1(57.95,135.67) v1(57.95,135.09) v1(58.58,135.67) v1(58.58,135.09) v1(59.22,135.67) v1(59.22,135.09) v1(59.99,70.8) v1(60.32,125.31) v1(62.02,119.4) v1(62.06,113.84) v1(62.58,43.09) v1(62.58,42.45) v1(62.84,46.01) v1(62.84,45.37) v1(62.84,44.74) v1(62.84,44.1) v1(63.22,43.09) v1(63.22,42.45) v1(63.23,37.77) v1(63.47,46.01) v1(63.47,45.37) v1(63.47,44.74) v1(63.47,44.1) v1(63.54,111.35) v1(63.71,75.73) v1(64.74,106.51) v1(66.27,113.19) v1(66.27,112.43) v1(66.42,81.31) v1(66.61,48.31) v1(66.94,101.2) v1(67.03,113.19) v1(67.03,112.43) v1(67.79,113.19) v1(67.79,112.43) v1(68.11,95.53) v1(68.12,83.4) v1(68.23,90.04) v1(68.35,87.92) v1(68.55,113.19) v1(68.55,112.43) v1(69.31,113.19) v1(69.31,112.43) v1(69.7,91.22) v1(70.33,91.22) v1(70.85,37.77) v1(75.66,76.62) v1(75.66,75.79) v1(76.05,62.9) v1(76.05,61.63) v1(76.49,76.62) v1(76.49,75.79) v1(76.43,62.26) v1(76.68,62.9) v1(76.68,61.63) v1(76.81,63.66) v1(77.06,62.26) v1(77.32,62.9) v1(77.32,61.63) v1(77.44,63.66) v1(77.7,62.26) v1(77.95,62.9) v1(77.95,61.63) v1(78.08,63.66) v1(78.33,62.26) v1(78.41,75.75) v1(78.71,63.66) v1(78.88,88.78) v1(78.88,87.61) v1(78.88,75.42) v1(79.05,132.14) v1(79.03,131.53) v1(79.64,132.14) v1(79.61,131.53) v1(80.19,131.53) v1(80.21,132.14) v1(80.24,37.75) v1(84.15,47.28) v1(84.15,45.76) v1(84.15,44.23) v1(84.62,40.43) v1(85.42,40.47) v1(85.57,119.16) v1(85.57,118.4) v1(85.95,88.87) v1(85.95,87.85) v1(85.95,86.84) v1(86.02,47.64) v1(86.02,45.35) v1(86.63,121.08) v1(86.76,40.46) v1(87.09,88.87) v1(87.09,87.85) v1(87.09,86.84) v1(87.11,80.18) v1(87.11,79.61) v1(87.11,79.04) v1(87.11,78.47) v1(87.11,77.89) v1(87.11,77.3) v1(87.16,70.66) v1(87.16,69.14) v1(87.16,67.61) v1(87.29,45.73) v1(87.29,44.21) v1(87.86,37.75) v1(88.24,88.87) v1(88.24,87.85) v1(88.24,86.84) v1(88.69,70.66) v1(88.69,69.14) v1(88.69,67.61) v1(88.62,40.43) v1(89.42,104.66) v1(89.62,40.43) v1(90.09,47.26) v1(90.09,45.73) v1(90.09,44.21) v1(90.21,70.66) v1(90.21,69.14) v1(90.21,67.61) v1(90.47,105.56) v1(90.62,40.43) v1(91.35,46.11) v1(91.35,43.75) v1(91.46,106.99) v1(91.86,115.54) v1(91.86,114.97) v1(92.49,115.54) v1(92.49,114.97) v1(92.63,47.26) v1(92.63,45.73) v1(92.63,44.21) v1(92.85,80.98) v1(92.85,80.22) v1(92.85,79.46) v1(92.85,78.7) v1(92.85,77.94) v1(93.13,40.43) v1(93.7,109.13) v1(93.61,80.98) v1(93.61,80.22) v1(93.61,79.46) v1(93.61,78.7) v1(93.61,77.94) v1(94.08,109.57) v1(94.13,40.43) v1(94.37,80.98) v1(94.37,80.22) v1(94.37,79.46) v1(94.37,78.7) v1(94.37,77.94) v1(95.2,47.26) v1(95.2,45.73) v1(95.2,44.21) v1(95.13,40.43) v1(95.48,37.75) v1(95.88,51.1) v1(96.52,80.39) v1(97,47.64) v1(97,45.35) v1(97.1,80.39) v1(97.57,114.52) v1(97.51,101.89) v1(97.89,105.83) v1(97.89,104.94) v1(97.89,103.16) v1(98.27,47.26) v1(98.27,45.73) v1(98.27,44.21) v1(98.37,51.08) v1(99.87,123.15) v1(100.45,123.17) v1(100.82,47.26) v1(100.82,45.73) v1(100.82,44.21) v1(101.13,40.43) v1(101.93,93.67) v1(102.08,46.04) v1(102.08,43.75) v1(102.38,130.54) v1(102.44,91.82) v1(103.1,37.75) v1(103.36,47.26) v1(103.36,45.73) v1(103.36,44.21) v1(103.62,40.43) v1(103.86,104.81) v1(103.86,103.98) v1(103.86,103.35) v1(103.86,102.71) v1(103.86,102.08) v1(103.86,101.44) v1(103.86,100.81) v1(103.86,99.98) v1(104.18,93.9) v1(104.49,104.81) v1(104.49,103.98) v1(104.49,103.35) v1(104.49,102.71) v1(104.49,102.08) v1(104.49,101.44) v1(104.49,100.81) v1(104.49,99.98) v1(104.4,92.13) v1(104.62,40.43) v1(105.13,104.81) v1(105.13,103.98) v1(105.13,103.35) v1(105.13,102.71) v1(105.13,102.08) v1(105.13,101.44) v1(105.13,100.81) v1(105.13,99.98) v1(105.37,51.09) v1(107.25,48.02) v1(107.81,114.13) v1(107.89,109.7) v1(107.87,109.09) v1(108.07,126.98) v1(108.49,114.13) v1(108.49,113.36) v1(108.52,109.7) v1(108.51,109.09) v1(108.62,40.43) v1(108.77,48.02) v1(108.77,44.97) v1(109.62,40.43) v1(110.29,46.49) v1(110.29,44.97) v1(110.72,37.75) v1(111.82,46.49) v1(111.82,44.97) v1(113.32,128.52) v1(113.44,46.49) v1(113.44,44.97) v1(114.81,76.74) v1(114.81,76.11) v1(115.08,46.49) v1(115.08,44.97) v1(115.42,76.74) v1(115.42,76.11) v1(115.99,132.8) v1(116.02,76.74) v1(116.02,76.11) v1(116.16,137.8) v1(116.32,112.58) v1(116.32,111.65) v1(116.73,46.49) v1(116.73,45.73) v1(116.73,44.21) v1(116.95,112.58) v1(116.95,111.65) v1(118.34,37.75) v1(118.44,45.35) v1(120.01,46.49) v1(121.62,46.49) v1(121.62,44.97) v1(123.24,46.49) v1(123.24,44.97) v1(123.96,140.23) v1(125.13,48.02) v1(125.13,46.49) v1(125.13,44.97) v1(125.58,114.97) v1(125.58,114.21) v1(125.99,85.99) v1(125.96,37.75) v1(126.33,88.87) v1(126.65,48.02) v1(126.65,46.49) v1(126.65,44.97) v1(126.65,43.45) v1(127.09,88.87) v1(127.12,89.96) v1(127.75,86.39) v1(128.01,83.78) v1(128.1,116.34) v1(128.24,115.79) v1(128.37,89.96) v1(128.67,116.34) v1(128.81,115.79) v1(129.05,88.87) v1(129.19,47.26) v1(129.19,45.73) v1(129.19,44.21) v1(129.25,116.34) v1(129.39,115.79) v1(129.7,86.39) v1(129.82,116.34) v1(129.96,115.79) v1(130.08,82.16) v1(130.35,116.63) v1(130.32,89.96) v1(130.35,84.21) v1(130.46,47.64) v1(130.46,45.35) v1(130.92,116.63) v1(131.06,141.35) v1(131,88.87) v1(131.13,97.44) v1(131.37,51.39) v1(131.73,47.26) v1(131.73,45.73) v1(131.73,44.21) v1(132,75.87) v1(132,73.92) v1(132.37,111.86) v1(132.37,111.29) v1(133.58,37.75) v1(133.85,77.17) v1(133.85,75.22) v1(134.12,40.41) v1(134.27,47.26) v1(134.27,45.73) v1(134.27,44.21) v1(135.54,46.11) v1(135.54,43.83) v1(135.63,40.24) v1(135.98,76.59) v1(135.97,74.61) v1(135.99,51.39) v1(136.57,51.39) v1(136.81,47.26) v1(136.81,45.73) v1(136.81,44.21) v1(137.63,40.24) v1(137.91,74.83) v1(138.45,51.14) v1(138.68,141.35) v1(138.63,40.24) v1(139.11,116.12) v1(139.35,47.26) v1(139.35,45.73) v1(139.35,44.21) v1(139.67,111.92) v1(140.31,116.87) v1(140.31,111.92) v1(140.57,74.18) v1(140.57,72.88) v1(140.62,47.64) v1(140.62,45.35) v1(140.88,51.09) v1(140.94,116.87) v1(140.94,111.92) v1(141.2,37.75) v1(141.58,116.87) v1(141.58,111.92) v1(141.89,47.26) v1(141.87,45.74) v1(141.89,44.21) v1(142.01,119.8) v1(142.66,75.22) v1(143.88,77.17) v1(143.88,75.22) v1(143.87,51.09) v1(144.52,47.26) v1(144.52,45.73) v1(144.52,44.21) v1(144.7,106.01) v1(145.2,108.67) v1(145.93,75.7) v1(146.04,46.87) v1(146.04,46.11) v1(146.23,78.66) v1(146.3,141.35) v1(146.49,106.78) v1(146.49,104.98) v1(146.87,51.21) v1(147.04,89.07) v1(147.04,88.36) v1(147.99,93.77) v1(147.99,92.63) v1(147.99,91.48) v1(147.93,90.84) v1(148.42,134.01) v1(148.6,75.77) v1(148.92,107.69) v1(148.91,105.71) v1(149.32,39.76) v1(150.18,77.39) v1(150.18,75.26) v1(150.98,89.1) v1(151.36,88.68) v1(152.55,134.17) v1(152.63,76.69) v1(152.63,72.68) v1(153.49,134.27) v1(153.92,141.35) v1(154.41,77.34) v1(154.41,75.39) v1(154.41,71.33) v1(154.4,37.82) v1(156.19,74.74) v1(156.28,134.54) v1(156.67,97.14) v1(156.73,95.86) v1(156.79,94.62) v1(157.45,93.35) v1(157.45,92.59) v1(157.44,91.89) v1(157.46,91.22) v1(157.44,90.61) v1(157.64,107.04) v1(158.07,76.69) v1(158.07,74.74) v1(158.07,72.85) v1(158.18,93.58) v1(158.66,48.28) v1(158.96,122.69) v1(159.67,77.34) v1(159.67,75.39) v1(159.87,37.82) v1(160.86,105.3) v1(161.54,141.35) v1(161.65,74.74) v1(163.64,48.01) v1(163.69,44.5) v1(164.13,39.04) v1(164.29,73.44) v1(164.62,47.26) v1(164.62,45.73) v1(164.62,44.21) v1(166.62,47.64) v1(166.62,45.35) v1(166.68,37.75) v1(167.23,104.99) v1(167.61,106.85) v1(167.89,47.26) v1(167.89,45.73) v1(167.89,44.21) v1(168.32,40.27) v1(168.49,51.28) v1(169.16,141.35) v1(170.69,47.26) v1(170.69,45.73) v1(170.69,44.21) v1(171.95,46.04) v1(171.95,43.75) v1(173.23,47.26) v1(173.23,45.73) v1(173.23,44.21) v1(173.73,40.24) v1(174.3,37.75) v1(175.18,129.99) v1(175.8,47.26) v1(175.8,45.73) v1(175.8,44.21) v1(176.26,76.6) v1(176.48,51.28) v1(176.78,141.35) v1(177.39,87.14) v1(177.6,47.64) v1(177.6,45.35) v1(178.2,117.32) v1(178.7,71.85) v1(178.87,47.26) v1(178.87,45.73) v1(178.87,44.21) v1(178.98,51.28) v1(179.63,126.45) v1(179.82,64.13) v1(180.39,64.13) v1(180.78,126.45) v1(181.42,45.73) v1(181.42,44.21) v1(181.54,140.14) v1(181.69,51.28) v1(181.73,40.24) v1(181.94,126.46) v1(181.92,37.75) v1(182.48,117.36) v1(182.68,46.04) v1(182.68,43.75) v1(182.88,67.91) v1(183.46,67.91) v1(183.96,45.73) v1(183.96,44.21) v1(184.22,40.24) v1(185.97,51.28) v1(189.37,136.7) v1(189.48,51.28) v1(189.51,46.49) v1(189.51,44.97) v1(189.51,43.45) v1(189.54,37.75) v1(190.6,130.22) v1(191.04,46.49) v1(191.04,44.97) v1(192.08,127.26) v1(192.56,46.49) v1(192.56,44.97) v1(193.55,126.54) v1(194.13,100.76) v1(194.21,46.49) v1(194.21,44.97) v1(194.42,117.83) v1(195.04,80.93) v1(195.63,127.02) v1(195.77,83.32) v1(195.81,80.93) v1(195.84,48.02) v1(195.84,46.49) v1(195.84,44.97) v1(196.85,113.08) v1(196.81,111.39) v1(196.96,73.2) v1(197.16,37.75) v1(197.45,48) v1(197.45,46.48) v1(197.45,44.95) v1(199.16,47.64) v1(199.16,45.35) v1(200.26,46.49) v1(200.26,44.97) v1(200.71,128.1) v1(201.91,46.49) v1(201.91,44.97) v1(202.17,118.68) v1(202.18,116.71) v1(203.55,46.49) v1(203.55,44.97) v1(203.93,132.56) v1(204.19,90.37) v1(204.19,89.78) v1(204.19,89.2) v1(204.4,100.58) v1(204.4,99.94) v1(204.4,99.31) v1(204.4,98.67) v1(204.78,37.75) v1(204.99,100.58) v1(204.99,99.94) v1(204.99,99.31) v1(204.99,98.67) v1(205.32,46.51) v1(205.32,44.98) v1(205.74,141.35) v1(207.08,48.02) v1(207.08,46.49) v1(207.08,44.97) v1(207.08,43.45) v1(208,80.26) v1(208,79.68) v1(208.43,83.64) v1(208.43,83.05) v1(208.43,82.47) v1(208.58,80.26) v1(208.58,79.68) v1(208.87,84.12) v1(209.04,86.44) v1(209.02,47.2) v1(209.02,45.68) v1(209.02,44.15) v1(209.46,84.12) v1(210.06,83.85) v1(210.06,83.27) v1(210.06,82.69) v1(210.29,47.58) v1(210.29,45.3) v1(210.55,134.17) v1(211.87,51.08) v1(212.07,47.2) v1(212.07,45.68) v1(212.07,44.15) v1(212.2,110.57) v1(212.4,37.75) v1(213.97,51.12) v1(214.35,70.27) v1(214.61,47.2) v1(214.61,45.68) v1(214.61,44.15) v1(214.72,40.35) v1(215.75,71.66) v1(215.75,70.27) v1(215.75,68.87) v1(215.88,46.06) v1(215.88,43.77) v1(215.95,79.97) v1(215.95,79.38) v1(216.1,83.04) v1(216.23,40.24) v1(216.42,106.09) v1(216.51,80.76) v1(216.53,79.97) v1(216.53,79.38) v1(216.68,83.04) v1(216.85,108.47) v1(216.97,51.15) v1(217.15,82.46) v1(217.15,81.87) v1(217.15,81.29) v1(217.15,80.7) v1(217.14,70.27) v1(217.15,47.2) v1(217.15,45.68) v1(217.15,44.15) v1(217.27,83.04) v1(217.36,86.1) v1(217.79,108.47) v1(218.17,134.17) v1(218.16,104.16) v1(218.23,40.24) v1(218.97,51.14) v1(219.18,47.2) v1(219.18,45.68) v1(219.18,44.15) v1(219.23,40.24) v1(220.02,37.75) v1(220.96,47.58) v1(220.96,45.3) v1(221.49,51.08) v1(221.6,89.05) v1(221.6,88.46) v1(221.83,121.69) v1(221.88,91.97) v1(221.88,91.39) v1(221.88,90.8) v1(222.01,84.29) v1(222.23,47.2) v1(222.23,45.68) v1(222.23,44.15) v1(222.64,84.29) v1(222.86,81.16) v1(222.86,80.59) v1(222.86,79.33) v1(222.84,78.76) v1(223.26,101.86) v1(223.26,101.28) v1(223.28,84.29) v1(223.85,101.86) v1(223.85,101.28) v1(224.11,99.56) v1(224.11,98.98) v1(224.13,86.52) v1(224.13,85.89) v1(224.13,85.25) v1(224.13,84.62) v1(224.43,101.86) v1(224.43,101.28) v1(224.48,51.09) v1(224.7,99.56) v1(224.7,98.98) v1(224.88,129) v1(225.02,101.86) v1(225.02,101.28) v1(225.11,47.2) v1(225.11,45.68) v1(225.11,44.15) v1(225.23,40.36) v1(226.38,46.82) v1(226.38,46.06) v1(226.86,116.62) v1(227.48,51.21) v1(227.64,37.75) v1(227.72,134.4) v1(229.03,105.13) v1(230.73,110.78) v1(230.73,108.75) v1(231.11,105.81) v1(231.34,104.81) v1(231.49,68.74) v1(231.49,66.96) v1(231.49,65.19) v1(232.06,126.81) v1(232.69,105.83) v1(233.27,68.74) v1(233.27,66.96) v1(233.27,65.19) v1(233.78,110.78) v1(233.78,108.75) v1(233.83,126.81) v1(234.64,134.25) v1(234.8,105.25) v1(235.05,68.74) v1(235.05,66.96) v1(235.05,65.19) v1(235.01,36.52) v1(235.6,126.81) v1(235.94,105.39) v1(236.83,110.78) v1(236.83,108.75) v1(237.02,87.09) v1(237.34,44.74) v1(238.03,104.83) v1(238.1,45.5) v1(238.1,44.74) v1(238.24,127.47) v1(238.22,87.09) v1(240,46.01) v1(240,45.44) v1(240.13,50.57) v1(240.13,50) v1(240.64,94.14) v1(241.21,94.14) v1(241.27,92.24) v1(242.1,92.24) v1(242.1,91.41) v1(242.26,134.25) v1(242.88,37.75) v1(247.24,122.59) v1(247.24,119.67) v1(247.24,116.62) v1(247.24,94.08) v1(247.24,92.81) v1(247.24,91.66) v1(247.24,90.78) v1(247.62,48.17) v1(247.62,47.41) v1(247.62,46.64) v1(248.55,37.78) v1(249.07,40.88) v1(249.15,122.59) v1(249.15,119.67) v1(249.15,116.62) v1(249.21,53.63) v1(250.12,105.84) v1(250.28,87.82) v1(250.82,53.56) v1(250.91,102.03) v1(250.96,37.75) v1(251.1,40.89) v1(251.74,40.89) v1(252.66,68.82) v1(252.66,67.04) v1(252.66,65.26) v1(254.44,68.82) v1(254.44,67.04) v1(254.44,65.26) v1(254.68,102.17) v1(255.31,123.68) v1(255.37,119.01) v1(255.72,121.52) v1(255.83,133.64) v1(256.22,68.82) v1(256.22,67.04) v1(256.22,65.26) v1(256.8,101.56) v1(257.73,37.77) v1(258.48,131.61) v1(258.42,109.38) v1(258.42,108.11) v1(259.94,109.38) v1(259.94,108.11) v1(260.06,130.53) v1(260.73,46.63) v1(261.26,48.27) v1(261.47,109.38) v1(261.47,108.11) v1(261.83,89.37) v1(262.75,129.83) v1(262.8,128.75) v1(262.99,109.38) v1(262.99,108.11) v1(262.99,37.75) v1(263,80.36) v1(263.45,133.64) v1(264.51,109.38) v1(264.51,108.11) v1(265.35,62.68) v1(265.85,106.35) v1(265.94,62.68) v1(266.48,37.75) v1(267.56,81.31) v1(267.56,79.79) v1(268.32,80.55) v1(268.73,106.94) v1(269.09,81.31) v1(269.62,108.42) v1(270,97.43) v1(270.09,106.23) v1(270.09,105.66) v1(270.09,83.34) v1(270.65,106.23) v1(270.65,105.66) v1(271.14,105.94) v1(271.5,63.09) v1(271.51,82.29) v1(271.87,112.05) v1(272.27,36.7) v1(272.27,29.08) v1(272.27,21.46) v1(272.78,13.84) v1(272.78,6.22) v1(273.36,54.76) v1(273.85,3.69) v1(273.85,3.11) v1(274.13,102.35) v1(274.15,96.47) v1(274.43,111.6) v1(274.44,3.69) v1(274.44,3.11) v1(274.56,0.5) v1(276.45,69.63) v1(276.45,68.87) v1(276.45,68.11) v1(276.51,75.21) v1(276.77,94.2) v1(276.72,25.41) v1(276.96,102.4) v1(276.96,101.38) v1(277.98,102.4) v1(277.98,101.38) v1(280.32,111.04) v1(282.18,0.5) v1(283.16,93.13) v1(283.17,92.54) v1(283.17,91.96) v1(283.28,98.59) v1(283.73,93.14) v1(283.73,92.54) v1(285.85,111.29) v1(285.85,110.52) v1(285.85,109.76) v1(286.74,39.32) v1(287.07,116.8) v1(287.37,51.91) v1(287.37,45.63) v1(287.31,39.33) v1(287.56,71.6) v1(287.56,70.07) v1(287.56,68.55) v1(287.74,106.56) v1(287.75,105.98) v1(287.75,105.42) v1(287.76,104.83) v1(287.76,104.28) v1(287.97,51.9) v1(287.94,45.63) v1(289.09,71.6) v1(289.09,70.07) v1(289.09,68.55) v1(289.8,0.5) v1(289.87,132.14) v1(290.61,71.6) v1(290.61,70.07) v1(290.61,68.55) v1(294.85,54.75) v1(297.18,131.64) v1(297.42,0.5) v1(300,30.26) v1(300,22.64) v1(300,15.02) v1(300,5.94) v1(301.9,76.96) v1(302.46,76.95) v1(302.45,76.39) v1(302.59,111.79) v1(303.65,84.74) v1(303.68,35.31) v1(304.99,107.25) v1(304.99,78.06) v1(304.99,70.44) v1(304.99,62.82) v1(304.99,55.2) v1(305,122.59) v1(305,114.97) v3(49.57,43.72) v3(52.87,53.37) v3(63.19,46.82) v3(76.62,60.8) v3(77.24,75.9) v3(97.51,104.49) v3(124.69,116.58) v3(138.62,52.68) v3(204.37,102.85) v3(219.39,54.44) v3(219.62,49.59) v3(223.43,86.27) v3(224.04,100.25) v6(259.09,94.92) v6(259.13,92.82) v6(260.2,93.89) v6(261.19,94.9) v6(261.11,92.83)

# Allegro board LAC451PR10-0923B.brd (continued)
## Nets (continued)
DDR_A_ACT#: JDIMM1.114 UC1.BA55
DDR_A_ALERT#: JDIMM1.116 UC1.AW50
DDR_A_BA0: JDIMM1.150 UC1.AU52
DDR_A_BA1: JDIMM1.145 UC1.AT48
DDR_A_BG0: JDIMM1.115 UC1.AY55
DDR_A_BG1: JDIMM1.113 UC1.AY54
DDR_A_CKE0: JDIMM1.109 UC1.BA56
DDR_A_CKE1: JDIMM1.110 UC1.BB56
DDR_A_CKE2: T3.1(TP-1) UC1.AW56
DDR_A_CKE3: T4.1(TP-1) UC1.AY56
DDR_A_CLK0: JDIMM1.137 UC1.AT53
DDR_A_CLK1: JDIMM1.138 UC1.AT55
DDR_A_CLK#0: JDIMM1.139 UC1.AU53
DDR_A_CLK#1: JDIMM1.140 UC1.AU55
DDR_A_CS#0: JDIMM1.149 UC1.AU45
DDR_A_CS#1: JDIMM1.157 UC1.AU43
DDR_A_D0: JDIMM1.7 UC1.AL71
DDR_A_D1: JDIMM1.3 UC1.AL68
DDR_A_D2: JDIMM1.21 UC1.AN68
DDR_A_D3: JDIMM1.16 UC1.AN69
DDR_A_D4: JDIMM1.4 UC1.AL70
DDR_A_D5: JDIMM1.8 UC1.AL69
DDR_A_D6: JDIMM1.17 UC1.AN70
DDR_A_D7: JDIMM1.20 UC1.AN71
DDR_A_D8: JDIMM1.28 UC1.AR70
DDR_A_D9: JDIMM1.24 UC1.AR68
DDR_A_D10: JDIMM1.38 UC1.AU71
DDR_A_D11: JDIMM1.42 UC1.AU68
DDR_A_D12: JDIMM1.29 UC1.AR71
DDR_A_D13: JDIMM1.25 UC1.AR69
DDR_A_D14: JDIMM1.41 UC1.AU70
DDR_A_D15: JDIMM1.37 UC1.AU69
DDR_A_D16: JDIMM1.194 UC1.AF65
DDR_A_D17: JDIMM1.195 UC1.AF64
DDR_A_D18: JDIMM1.204 UC1.AK65
DDR_A_D19: JDIMM1.203 UC1.AK64
DDR_A_D20: JDIMM1.190 UC1.AF66
DDR_A_D21: JDIMM1.191 UC1.AF67
DDR_A_D22: JDIMM1.207 UC1.AK67
DDR_A_D23: JDIMM1.208 UC1.AK66
DDR_A_D24: JDIMM1.186 UC1.AF70
DDR_A_D25: JDIMM1.174 UC1.AF68
DDR_A_D26: JDIMM1.173 UC1.AH71
DDR_A_D27: JDIMM1.183 UC1.AH68
DDR_A_D28: JDIMM1.182 UC1.AF71
DDR_A_D29: JDIMM1.187 UC1.AF69
DDR_A_D30: JDIMM1.169 UC1.AH70
DDR_A_D31: JDIMM1.170 UC1.AH69
DDR_A_D32: JDIMM1.46 UC1.BB65
DDR_A_D33: JDIMM1.62 UC1.AW65
DDR_A_D34: JDIMM1.63 UC1.AW63
DDR_A_D35: JDIMM1.45 UC1.AY63
DDR_A_D36: JDIMM1.50 UC1.BA65
DDR_A_D37: JDIMM1.49 UC1.AY65
DDR_A_D38: JDIMM1.59 UC1.BA63
DDR_A_D39: JDIMM1.58 UC1.BB63
DDR_A_D40: JDIMM1.66 UC1.BA61
DDR_A_D41: JDIMM1.70 UC1.AW61
DDR_A_D42: JDIMM1.79 UC1.BB59
DDR_A_D43: JDIMM1.84 UC1.AW59
DDR_A_D44: JDIMM1.67 UC1.BB61
DDR_A_D45: JDIMM1.71 UC1.AY61
DDR_A_D46: JDIMM1.83 UC1.BA59
DDR_A_D47: JDIMM1.80 UC1.AY59
DDR_A_D48: JDIMM1.211 UC1.AT66
DDR_A_D49: JDIMM1.215 UC1.AU66
DDR_A_D50: JDIMM1.225 UC1.AP65
DDR_A_D51: JDIMM1.229 UC1.AN65
DDR_A_D52: JDIMM1.216 UC1.AN66
DDR_A_D53: JDIMM1.212 UC1.AP66
DDR_A_D54: JDIMM1.224 UC1.AT65
DDR_A_D55: JDIMM1.228 UC1.AU65
DDR_A_D56: JDIMM1.233 UC1.AT61
DDR_A_D57: JDIMM1.237 UC1.AU61
DDR_A_D58: JDIMM1.246 UC1.AP60
DDR_A_D59: JDIMM1.250 UC1.AN60
DDR_A_D60: JDIMM1.236 UC1.AN61
DDR_A_D61: JDIMM1.232 UC1.AP61
DDR_A_D62: JDIMM1.249 UC1.AT60
DDR_A_D63: JDIMM1.245 UC1.AU60
DDR_A_DQS0: JDIMM1.13 UC1.AM69
DDR_A_DQS1: JDIMM1.34 UC1.AT70
DDR_A_DQS2: JDIMM1.200 UC1.AH65
DDR_A_DQS3: JDIMM1.179 UC1.AG70
DDR_A_DQS4: JDIMM1.55 UC1.AY64
DDR_A_DQS5: JDIMM1.76 UC1.BA60
DDR_A_DQS6: JDIMM1.221 UC1.AR65
DDR_A_DQS7: JDIMM1.242 UC1.AR60
DDR_A_DQS#0: JDIMM1.11 UC1.AM70
DDR_A_DQS#1: JDIMM1.32 UC1.AT69
DDR_A_DQS#2: JDIMM1.198 UC1.AH66
DDR_A_DQS#3: JDIMM1.177 UC1.AG69
DDR_A_DQS#4: JDIMM1.53 UC1.BA64
DDR_A_DQS#5: JDIMM1.74 UC1.AY60
DDR_A_DQS#6: JDIMM1.219 UC1.AR66
DDR_A_DQS#7: JDIMM1.240 UC1.AR61
DDR_A_MA0: JDIMM1.144 UC1.AY50
DDR_A_MA1: JDIMM1.133 UC1.BB50
DDR_A_MA2: JDIMM1.132 UC1.AY51
DDR_A_MA3: JDIMM1.131 UC1.BA50
DDR_A_MA4: JDIMM1.128 UC1.BB52
DDR_A_MA5: JDIMM1.126 UC1.BA51
DDR_A_MA6: JDIMM1.127 UC1.BA52
DDR_A_MA7: JDIMM1.122 UC1.AW52
DDR_A_MA8: JDIMM1.125 UC1.AY52
DDR_A_MA9: JDIMM1.121 UC1.BB54
DDR_A_MA10: JDIMM1.146 UC1.AT50
DDR_A_MA11: JDIMM1.120 UC1.BA54
DDR_A_MA12: JDIMM1.119 UC1.AW54
DDR_A_MA13: JDIMM1.158 UC1.AU46
DDR_A_MA14: JDIMM1.151 UC1.AT46
DDR_A_MA15: JDIMM1.156 UC1.AU48
DDR_A_MA16: JDIMM1.152 UC1.AU50
DDR_A_ODT0: JDIMM1.155 UC1.AT45
DDR_A_ODT1: JDIMM1.161 UC1.AT43
DDR_A_PARITY: JDIMM1.143 UC1.AT52
DDR_B_ACT#: JDIMM2.114 UC1.AN53
DDR_B_ALERT#: JDIMM2.116 UC1.AN43
DDR_B_BA0: JDIMM2.150 UC1.BB44
DDR_B_BA1: JDIMM2.145 UC1.BA44
DDR_B_BG0: JDIMM2.115 UC1.AP52
DDR_B_BG1: JDIMM2.113 UC1.AN52
DDR_B_CKE0: JDIMM2.109 UC1.AN56
DDR_B_CKE1: JDIMM2.110 UC1.AP55
DDR_B_CKE2: T5.1(TP-1) UC1.AN55
DDR_B_CKE3: T6.1(TP-1) UC1.AP53
DDR_B_CLK0: JDIMM2.137 UC1.AP45
DDR_B_CLK1: JDIMM2.138 UC1.AP46
DDR_B_CLK#0: JDIMM2.139 UC1.AN45
DDR_B_CLK#1: JDIMM2.140 UC1.AN46
DDR_B_CS#0: JDIMM2.149 UC1.BB42
DDR_B_CS#1: JDIMM2.157 UC1.AY42
DDR_B_D0: JDIMM2.8 UC1.AY39
DDR_B_D1: JDIMM2.3 UC1.AW39
DDR_B_D2: JDIMM2.16 UC1.AY37
DDR_B_D3: JDIMM2.20 UC1.AW37
DDR_B_D4: JDIMM2.7 UC1.BB39
DDR_B_D5: JDIMM2.4 UC1.BA39
DDR_B_D6: JDIMM2.21 UC1.BA37
DDR_B_D7: JDIMM2.17 UC1.BB37
DDR_B_D8: JDIMM2.28 UC1.AY35
DDR_B_D9: JDIMM2.24 UC1.AW35
DDR_B_D10: JDIMM2.42 UC1.AY33
DDR_B_D11: JDIMM2.38 UC1.AW33
DDR_B_D12: JDIMM2.29 UC1.BB35
DDR_B_D13: JDIMM2.25 UC1.BA35
DDR_B_D14: JDIMM2.37 UC1.BA33
DDR_B_D15: JDIMM2.41 UC1.BB33
DDR_B_D16: JDIMM2.170 UC1.AU40
DDR_B_D17: JDIMM2.174 UC1.AT40
DDR_B_D18: JDIMM2.182 UC1.AT37
DDR_B_D19: JDIMM2.186 UC1.AU37
DDR_B_D20: JDIMM2.173 UC1.AR40
DDR_B_D21: JDIMM2.169 UC1.AP40
DDR_B_D22: JDIMM2.187 UC1.AP37
DDR_B_D23: JDIMM2.183 UC1.AR37
DDR_B_D24: JDIMM2.191 UC1.AT33
DDR_B_D25: JDIMM2.195 UC1.AU33
DDR_B_D26: JDIMM2.203 UC1.AU30
DDR_B_D27: JDIMM2.207 UC1.AT30
DDR_B_D28: JDIMM2.190 UC1.AR33
DDR_B_D29: JDIMM2.194 UC1.AP33
DDR_B_D30: JDIMM2.208 UC1.AR30
DDR_B_D31: JDIMM2.204 UC1.AP30
DDR_B_D32: JDIMM2.50 UC1.AY31
DDR_B_D33: JDIMM2.45 UC1.AW31
DDR_B_D34: JDIMM2.58 UC1.AY29
DDR_B_D35: JDIMM2.62 UC1.AW29
DDR_B_D36: JDIMM2.49 UC1.BB31
DDR_B_D37: JDIMM2.46 UC1.BA31
DDR_B_D38: JDIMM2.63 UC1.BA29
DDR_B_D39: JDIMM2.59 UC1.BB29
DDR_B_D40: JDIMM2.66 UC1.AY27
DDR_B_D41: JDIMM2.70 UC1.AW27
DDR_B_D42: JDIMM2.67 UC1.AY25
DDR_B_D43: JDIMM2.71 UC1.AW25
DDR_B_D44: JDIMM2.79 UC1.BB27
DDR_B_D45: JDIMM2.83 UC1.BA27
DDR_B_D46: JDIMM2.80 UC1.BA25
DDR_B_D47: JDIMM2.84 UC1.BB25
DDR_B_D48: JDIMM2.216 UC1.AU27
DDR_B_D49: JDIMM2.215 UC1.AT27
DDR_B_D50: JDIMM2.224 UC1.AT25
DDR_B_D51: JDIMM2.228 UC1.AU25
DDR_B_D52: JDIMM2.211 UC1.AP27
DDR_B_D53: JDIMM2.212 UC1.AN27
DDR_B_D54: JDIMM2.229 UC1.AN25
DDR_B_D55: JDIMM2.225 UC1.AP25
DDR_B_D56: JDIMM2.233 UC1.AT22
DDR_B_D57: JDIMM2.237 UC1.AU22
DDR_B_D58: JDIMM2.245 UC1.AU21
DDR_B_D59: JDIMM2.249 UC1.AT21
DDR_B_D60: JDIMM2.236 UC1.AN22
DDR_B_D61: JDIMM2.232 UC1.AP22
DDR_B_D62: JDIMM2.246 UC1.AP21
DDR_B_D63: JDIMM2.250 UC1.AN21
DDR_B_DQS0: JDIMM2.13 UC1.AY38
DDR_B_DQS1: JDIMM2.34 UC1.BA34
DDR_B_DQS2: JDIMM2.179 UC1.AR38
DDR_B_DQS3: JDIMM2.200 UC1.AR32
DDR_B_DQS4: JDIMM2.55 UC1.AY30
DDR_B_DQS5: JDIMM2.76 UC1.BA26
DDR_B_DQS6: JDIMM2.221 UC1.AR27
DDR_B_DQS7: JDIMM2.242 UC1.AR21
DDR_B_DQS#0: JDIMM2.11 UC1.BA38
DDR_B_DQS#1: JDIMM2.32 UC1.AY34
DDR_B_DQS#2: JDIMM2.177 UC1.AT38
DDR_B_DQS#3: JDIMM2.198 UC1.AT32
DDR_B_DQS#4: JDIMM2.53 UC1.BA30
DDR_B_DQS#5: JDIMM2.74 UC1.AY26
DDR_B_DQS#6: JDIMM2.219 UC1.AR25
DDR_B_DQS#7: JDIMM2.240 UC1.AR22
DDR_B_MA0: JDIMM2.144 UC1.BA46
DDR_B_MA1: JDIMM2.133 UC1.AY46
DDR_B_MA2: JDIMM2.132 UC1.AY47
DDR_B_MA3: JDIMM2.131 UC1.BB46
DDR_B_MA4: JDIMM2.128 UC1.BA47
DDR_B_MA5: JDIMM2.126 UC1.AY48
DDR_B_MA6: JDIMM2.127 UC1.BA48
DDR_B_MA7: JDIMM2.122 UC1.AP48
DDR_B_MA8: JDIMM2.125 UC1.BB48
DDR_B_MA9: JDIMM2.121 UC1.AP50
DDR_B_MA10: JDIMM2.146 UC1.AW46
DDR_B_MA11: JDIMM2.120 UC1.AN48
DDR_B_MA12: JDIMM2.119 UC1.AN50
DDR_B_MA13: JDIMM2.158 UC1.BA43
DDR_B_MA14: JDIMM2.151 UC1.AY44
DDR_B_MA15: JDIMM2.156 UC1.AY43
DDR_B_MA16: JDIMM2.152 UC1.AW44
DDR_B_ODT0: JDIMM2.155 UC1.BA42
DDR_B_ODT1: JDIMM2.161 UC1.AW42
DDR_B_PARITY: JDIMM2.143 UC1.AP43
DDR_DRAMRST#: RD2.2 RD29.2 UC1.AT13
DDR_DRAMRST#_R: CD6.1 CD35.1 JDIMM1.108 JDIMM2.108 RD29.1
DDR_VTT_CTRL: UC1.AW67 UD1.2
DDR_XDP_WAN_SMBCLK: JDIMM1.253 JDIMM2.253 JXDP1.53 QC2.1 RC319.2
DDR_XDP_WAN_SMBDAT: JDIMM1.254 JDIMM2.254 JXDP1.51 QC2.4 RC318.2
DH_1.2V: PQ201.1 PU201.17
DIMM1_SA0: JDIMM1.256 RD62.2 RD66.1
DIMM1_SA1: JDIMM1.260 RD63.2 RD67.1
DIMM1_SA2: JDIMM1.166 RD64.2 RD68.1
DIMM2_SA0: JDIMM2.256 RD69.2 RD72.1
DIMM2_SA1: JDIMM2.260 RD70.2 RD73.1
DIMM2_SA2: JDIMM2.166 RD71.2 RD74.1
DIMM_TYPE: RC341.1 RC342.2 UC1.P2
DIS_BAT_PROCHOT#: PR907.1 UE1.B51
DISP_ON: DV2.1 JEDP1.22 RV2.1
DK_AC_OFF: PD901.3 PU901.25
DK_AC_OFF_EN: PR938.1 PU901.22
DK_CSS_GC: PR810.2 PU901.11
DK_PWRBAR: PR924.1 PU901.33
DL_1.2V: PQ201.6 PU201.15
DMIC0: CA6.1 JEDP1.7 UA1.47
DMIC_CLK0: CA5.1 CA54.1 JEDP1.9 RA14.2
DMIC_CLK_CODEC: RA14.1 UA1.2
DOCK_AC_OFF: JDOCK1.2 PD901.1 PR925.1
DOCK_AC_OFF_EC: PR929.1 PR938.2 UE1.A63
DOCK_DCIN_IS+: JDOCK1.134 PQ804.1
DOCK_DCIN_IS-: JDOCK1.136 PQ805.1
DOCK_DET#: D19.2 PQ907.2 PR919.1 R272.1 UE1.B41
DOCK_DET_R#: D19.1 JDOCK1.142 JDOCK1.144
DOCK_HP_DET: QA3.2 RA29.2 UE1.A7
DOCK_MIC_DET: QA3.5 RA26.2 UE1.B8
DOCK_POR_RST#: JDOCK1.140 RE277.2 UE2.A21
DOCK_PSID: JDOCK1.135 PD7.2 PD7.3 PU1.1
DOCK_PWR_BTN#: CE44.1 JDOCK1.139 RE42.2
DOCK_PWR_SW#: CE45.1 RE42.1 RE62.2 UE2.A63
DOCK_SMB_ALERT#: JDOCK1.133 PQ2.3 RE9.2 UE1.A51
DOCK_SMB_CLK: JDOCK1.127 RPE3.2 UE2.B4
DOCK_SMB_DAT: JDOCK1.129 RPE3.1 UE2.A3
DOCKED: UE1.A38 UL4.13
DP_OCB#: RV622.2 UV27.3
EC5048_TX: RE305.1 UE1.B2
EC5048_TX_R: JDEG1.9 RE74.2 RE305.2 RE306.2
EC_32KHZ_ECE5048: UE1.B35 UE2.B2
EC_FPM_EN: JUSH1.22 UE2.B62
EDP_AUXN: CV1.1 UC1.E45
EDP_AUXN_C: CV1.2 JEDP1.33
EDP_AUXP: CV2.1 UC1.F45
EDP_AUXP_C: CV2.2 JEDP1.34
EDP_BIA_PWM: DV1.3 UC1.R11
EDP_COMP: RC2.2 UC1.E52
EDP_HPD: JEDP1.26 RC1.2 UC1.L10
EDP_TXN0: CV4.1 UC1.C47
EDP_TXN0_C: CV4.2 JEDP1.36
EDP_TXN1: CV6.1 UC1.D46
EDP_TXN1_C: CV6.2 JEDP1.38
EDP_TXP0: CV3.1 UC1.C46
EDP_TXP0_C: CV3.2 JEDP1.35
EDP_TXP1: CV5.1 UC1.C45
EDP_TXP1_C: CV5.2 JEDP1.37
EDRAM_OPIO_RCOMP: RC90.1 UC1.H66
EMMC_RCOMP: RC4.1 UC1.AT1
EN_1.0V_PRIM_COREP: PC411.1 PR406.2 PR407.1 PU402.13
EN_1.8VALW: PC505.1 PR504.2 PR505.1 PU501.1
EN_1VS_VCCIO: PC402.1 PR402.2 PR403.1 PU401.13
EN_+1VALWP: PR301.1 PR302.1 PR312.1 PU301.1
EN_DK_PWRBAR: PR901.1 PR934.1 PU901.17
EN_DOCK_PWR_BAR: PR901.2 UE1.B37
EN_I2S_NB_CODEC#: UA1.1 UE1.B36
EN_INVPWR: QV2.2 RE55.2 UE2.A25
EN_LCDPWR: DV3.1 RV3.2 UV24.4
ENLDO_3V5V: PR102.1 PR103.1 PU100.11 PU102.11
ENVDD_PCH: DV3.3 UC1.U13 UE2.A7
EOPIO_RCOMP: RC91.1 UC1.H65
ERC1: PC908.1 PU901.3
ERC2: PC901.1 PU901.13
ERC3: PC907.1 PU901.12
FAN1_PWM: JFAN1.2 RE48.2 UE2.A24
FAN1_TACH: JFAN1.3 RE51.2 UE2.B22
FB_1.8VALW: PC503.2 PR501.2 PR506.1 PU501.6
FB_+1VALWP: PR306.2 PR308.2 PR311.1 PU301.4
FB_IA: PR645.2 PR648.2 PR650.1 PU602.17
FB_VSA: PR646.1 PR649.1 PR652.1 PU602.25
FCCM_GT: PR671.2 PU602.11
FCCM_IA: PR659.2 PU602.21
FCCM_VSA: PR679.2 PU602.29
FIVR_EN: RC217.1 RC218.2 RC219.2
FIVR_EN_R: JXDP1.45 RC126.2 RC132.2 RC217.2
FWP#: RE81.2 RE82.2 UE2.B65
GPIO_PSID_SELECT: PU1.6 UE1.A6
GPIOD4: T97.1(TP-1) UE1.B15
GPIOD5: T99.1(TP-1) UE1.A15
GPIOE2: T98.1(TP-1) UE1.A2
GPP_B23: QC3.3 RC326.1 RC327.2 UC1.AM7
GPP_B23_Q: QC3.1 RC317.1 RC327.1
GPP_C5: RC25.1 UC1.W1
GPP_E23: T120.1(TP-1) UC1.N12
GPU_B+: PC672.1 PC673.1 PC679.1 PC688.1 PJP602.1 PU605.5
GPU_SMBCLK: RPE3.4 UE2.B49
GPU_SMBDAT: RPE3.3 UE2.B48
GT1N: PL604.2 PR673.1
GT1P: PL604.3 PR674.2
GT_SNUB1: PC678.1 PR676.2
GT_SW1: PL604.4 PR676.1 PU605.4
H_CATERR#: RC79.2 UC1.D63
H_CPU_SVIDALRT#: RC153.1 UC1.B63
H_CPUPWRGD: CC300.1 RC77.2 UC1.A68
H_CPUPWRGD_R: RC77.1 T9.1(TP-1)
H_PROCHOT#: CC310.1 PC605.2 PR678.1 PR818.1 RC83.2 RC84.1 RE288.2
H_PROCHOT#_R: RC84.2 UC1.C65
H_PROCHOT#_R1: RE288.1 UE2.A46
H_THERMTRIP#: CC312.1 QE4.3 RC80.2 RD4.2 RD61.2 UC1.C63
H_VCCST_PWRGD: CC301.1 RC71.2 RC78.1 RC123.1 RE308.1 UE4.4
H_VCCST_PWRGD_XDP: CC307.1 JXDP1.39 RC123.2 RC124.2
HDA_BIT_CLK: RC93.2 UC1.AY22
HDA_BIT_CLK_R: CC27.1 RA17.1 RC93.1 UA1.6
HDA_RST#: RC95.2 UC1.AW22
HDA_RST#_R: RC95.1 UA1.11
HDA_SDIN0: RA9.1 UC1.BA21
HDA_SDIN0_R: RA9.2 UA1.8
HDA_SDOUT: CC311.1 RC94.2 RC187.2 RC223.2 UC1.BB22
HDA_SDOUT_R: RC94.1 UA1.5
HDA_SYNC: RC92.2 UC1.BA22
HDA_SYNC_R: RC92.1 UA1.10
HDMI_CEC: JHDMI1.13 RV8.1
HDMI_CLKN: CV14.1 LV12.2 RV17.1 RV658.1
HDMI_CLKP: CV13.1 LV12.1 RV16.1 RV656.1
HDMI_CTRL_CLK: JHDMI1.15 QV3.6 RV21.1
HDMI_CTRL_DATA: JHDMI1.16 QV3.3 RV18.1
HDMI_HPD: JHDMI1.19 QV5.1 RV20.1
HDMI_L_CLKN: JHDMI1.12 LV12.3 RV657.1 RV658.2
HDMI_L_CLKP: JHDMI1.10 LV12.4 RV656.2 RV657.2
HDMI_L_TX_N0: JHDMI1.9 LV9.3 RV654.1 RV655.2
HDMI_L_TX_N1: JHDMI1.6 LV6.3 RV651.1 RV652.2
HDMI_L_TX_N2: JHDMI1.3 LV3.3 RV648.1 RV649.2
HDMI_L_TX_P0: JHDMI1.7 LV9.4 RV653.2 RV654.2
HDMI_L_TX_P1: JHDMI1.4 LV6.4 RV650.2 RV651.2
HDMI_L_TX_P2: JHDMI1.1 LV3.4 RV647.2 RV648.2
HDMI_OB: QV4.1 RV10.2 RV11.2 RV12.2 RV13.2 RV14.2 RV15.2 RV16.2 RV17.2
HDMI_TX_N0: CV29.1 LV9.2 RV15.1 RV655.1
HDMI_TX_N1: CV22.1 LV6.2 RV13.1 RV652.1
HDMI_TX_N2: CV18.1 LV3.2 RV11.1 RV649.1
HDMI_TX_P0: CV28.1 LV9.1 RV14.1 RV653.1
HDMI_TX_P1: CV21.1 LV6.1 RV12.1 RV650.1
HDMI_TX_P2: CV17.1 LV3.1 RV10.1 RV647.1
HOST_DEBUG_TX: JDEG1.8 RE73.2 UE2.B44
HOST_SD_WP#: QR1.2 RC292.2 UC1.AB3
HUB_DP0_AUXN: CV123.2 RV85.1 UV8.A11
HUB_DP0_AUXN_C: CV123.1 UV12.5
HUB_DP0_AUXP: CV122.2 RV74.1 UV8.B11
HUB_DP0_AUXP_C: CV122.1 UV12.2
HUB_DP0_CADET: JDOCK1.5 QV10.2 RV509.2 UV8.A14 UV12.1 UV12.4
HUB_DP0_CADETN: QV10.1 RV91.2 UV12.10 UV12.13
HUB_DP0_HPD: C310.1 JDOCK1.39 R268.1 UV8.A6
HUB_DP0_N0: C295.2 UV8.A7
HUB_DP0_N0_C: C295.1 R252.1
HUB_DP0_N0_R: JDOCK1.11 R252.2
HUB_DP0_N1: C299.2 UV8.A8
HUB_DP0_N1_C: C299.1 R255.1
HUB_DP0_N1_R: JDOCK1.17 R255.2
HUB_DP0_N2: C306.2 UV8.A9
HUB_DP0_N2_C: C306.1 R263.1
HUB_DP0_N2_R: JDOCK1.23 R263.2
HUB_DP0_N3: C301.2 UV8.A10
HUB_DP0_N3_C: C301.1 R266.1
HUB_DP0_N3_R: JDOCK1.29 R266.2
HUB_DP0_P0: C302.2 UV8.B7
HUB_DP0_P0_C: C302.1 R259.1
HUB_DP0_P0_R: JDOCK1.9 R259.2
HUB_DP0_P1: C297.2 UV8.B8
HUB_DP0_P1_C: C297.1 R253.1
HUB_DP0_P1_R: JDOCK1.15 R253.2
HUB_DP0_P2: C304.2 UV8.B9
HUB_DP0_P2_C: C304.1 R257.1
HUB_DP0_P2_R: JDOCK1.21 R257.2
HUB_DP0_P3: C300.2 UV8.B10
HUB_DP0_P3_C: C300.1 R265.1
HUB_DP0_P3_R: JDOCK1.27 R265.2
HUB_DP0_SCL: RPV2.3 UV8.B12 UV12.12
HUB_DP0_SDA: RPV2.4 UV8.A12 UV12.9
HUB_DP1_AUXN: CV120.2 RV82.1 UV8.J14
HUB_DP1_AUXN_C: CV120.1 UV11.5
HUB_DP1_AUXP: CV119.2 RV75.1 UV8.J13
HUB_DP1_AUXP_C: CV119.1 UV11.2
HUB_DP1_CADET: JDOCK1.6 QV9.2 RV508.2 UV8.M14 UV11.1 UV11.4
HUB_DP1_CADETN: QV9.1 RV90.2 UV11.10 UV11.13
HUB_DP1_HPD: C311.1 JDOCK1.40 R271.1 UV8.K14
HUB_DP1_N0: C296.1 UV8.E14
HUB_DP1_N0_C: C296.2 R261.2
HUB_DP1_N0_R: JDOCK1.12 R261.1
HUB_DP1_N1: C303.1 UV8.F14
HUB_DP1_N1_C: C303.2 R256.2
HUB_DP1_N1_R: JDOCK1.18 R256.1
HUB_DP1_N2: C307.1 UV8.G14
HUB_DP1_N2_C: C307.2 R264.2
HUB_DP1_N2_R: JDOCK1.24 R264.1
HUB_DP1_N3: C309.1 UV8.H14
HUB_DP1_N3_C: C309.2 R267.2
HUB_DP1_N3_R: JDOCK1.30 R267.1
HUB_DP1_P0: C294.1 UV8.E13
HUB_DP1_P0_C: C294.2 R260.2
HUB_DP1_P0_R: JDOCK1.10 R260.1
HUB_DP1_P1: C298.1 UV8.F13
HUB_DP1_P1_C: C298.2 R254.2
HUB_DP1_P1_R: JDOCK1.16 R254.1
HUB_DP1_P2: C305.1 UV8.G13
HUB_DP1_P2_C: C305.2 R262.2
HUB_DP1_P2_R: JDOCK1.22 R262.1
HUB_DP1_P3: C308.1 UV8.H13
HUB_DP1_P3_C: C308.2 R258.2
HUB_DP1_P3_R: JDOCK1.28 R258.1
HUB_DP1_SCL: RPV1.1 UV8.K13 UV11.12
HUB_DP1_SDA: RPV1.2 UV8.L14 UV11.9
HUB_GPIO4: RV518.2 UV8.B14
HUB_GPIO5: RV519.2 UV8.B13
HUB_GPIO6: RV83.1 UV8.C1
HUB_GPIO7: RPV1.4 UV8.M12
HUB_GPIO8: RPV1.3 UV8.M13
HUB_GPIO9: RV73.1 UV8.L3
HUB_LP_EN: UV8.A5 UV28.4 UV29.9
HUB_SPI_CLK: UV8.B3 UV9.6
HUB_SPI_CS#: RV86.2 UV8.A4 UV9.1
HUB_SPI_DIN: UV8.B4 UV9.2
HUB_SPI_DO: UV8.A3 UV9.5
HUB_SPI_HOLD: RV87.2 UV9.7
HUB_SPI_WP#: RV517.2 UV8.B1 UV9.3
HUB_SRCDET: RV84.1 UV8.C2
HUB_SW1_AUXN: JDOCK1.35 UV12.6 UV12.8
HUB_SW1_AUXP: JDOCK1.33 UV12.3 UV12.11
HUB_SW2_AUXN: JDOCK1.36 UV11.6 UV11.8
HUB_SW2_AUXP: JDOCK1.34 UV11.3 UV11.11
HUB_VGA_BLUE: JDOCK1.45 RV78.1 UV8.M8
HUB_VGA_DET: RV88.2 UV8.M3
HUB_VGA_GREEN: JDOCK1.59 RV77.1 UV8.M7
HUB_VGA_HSYNC: JDOCK1.65 UV8.M9
HUB_VGA_IREF: RV89.1 UV8.M5
HUB_VGA_NC: T108.1(TP-1) UV8.L5
HUB_VGA_RED: JDOCK1.53 RV76.1 UV8.M6
HUB_VGA_SCL: JDOCK1.48 UV8.L4
HUB_VGA_SDA: JDOCK1.46 UV8.M4
HUB_VGA_VSYNC: JDOCK1.67 UV8.L9
HW_GPS_DISABLE#: DZ6.1 RE12.2 UE1.A35
HW_GPS_DISABLE#_R: DZ6.2 JNGFF2.18
I2C_1_SCL: RZ21.2 RZ29.1 UC1.U9
I2C_1_SCL_R: JKBTP1.19 RZ29.2 RZ117.2
I2C_1_SDA: RZ20.2 RZ26.1 UC1.U8
I2C_1_SDA_R: JKBTP1.18 RZ26.2 RZ116.2
I2C_HUB_SCL: RPV2.2 UV8.A2
I2C_HUB_SDA: RPV2.1 UV8.A1
I2S_BCLK: RA31.2 UA1.16
I2S_DO: RA32.2 UA1.17
I2S_MCLK: RA30.2 UA1.15
I_ADP: PR816.1 UE2.A12
I_BATT: PR819.1 RE64.2
I_SYS: PR620.1 PR820.1 RE312.1
I_SYS_R: RE312.2 RE313.1 UE2.A57
IFDET_SATA#_PCIE: JNGFF3.61 RPC5.5 UC1.G4 UN4.20 UN5.20
ILIM_SEL: RI13.1 UI3.4
ILMT_+1VALWP: PR307.2 PR310.1 PU301.3
IMON_IA: PC625.2 PR629.2 PU602.14
IMON_VSA: PC643.1 PR651.1 PU602.23
IMVP_VR_ON: PR616.1 RE304.1 UE3.4 UE4.2
IMVP_VR_ON_EC: RE304.2 UE2.A1 UE3.1
INT_SPK_L+: CA22.1 LA6.1 UA1.42
INT_SPK_L-: CA23.1 LA7.1 UA1.43
INT_SPK_R+: CA19.1 LA8.1 UA1.45
INT_SPK_R-: CA24.1 LA9.1 UA1.44
INT_SPKR_L+: DA6.2 JSPK1.1 LA6.2
INT_SPKR_L-: DA6.3 JSPK1.2 LA7.2
INT_SPKR_R+: DA7.2 JSPK1.3 LA8.2
INT_SPKR_R-: DA7.3 JSPK1.4 LA9.2
INTRUDER#: RC69.1 UC1.AP16
IR_CAM_DET#: JIR1.6 RC345.1 UC1.AW7
IRQ_SERIRQ: RC21.2 UC1.AY11 UE1.B21 UE2.A28
ISH_I2C2_SCL: RZ76.1 UC1.AD12
ISH_I2C2_SCL_R: JNGFF2.32 RZ76.2
ISH_I2C2_SDA: RZ77.1 UC1.AD11
ISH_I2C2_SDA_R: JNGFF2.34 RZ77.2
ISH_UART0_CTS#: RZ80.1 UC1.U4
ISH_UART0_CTS#_R: JNGFF1.54 RZ80.2
ISH_UART0_RTS#: RZ81.1 UC1.U3
ISH_UART0_RTS#_R: JNGFF1.56 RZ81.2
ISH_UART0_RXD: RZ78.1 UC1.U1
ISH_UART0_RXD_R: JNGFF1.50 RZ78.2
ISH_UART0_TXD: RZ79.1 UC1.U2
ISH_UART0_TXD_R: JNGFF1.52 RZ79.2
ISUMN_GT: PC624.2 PC626.2 PC641.1 PH602.2 PR632.1 PR633.2 PR638.1 PR673.2
ISUMN_IA: PC642.2 PC645.1 PC646.2 PH605.2 PL603.2 PR640.2 PR644.2 PR656.2
ISUMP_GT: PC624.1 PC626.1 PR628.1 PR633.1 PR658.2 PR674.1 PU602.7
ISUMP_IA: PC642.1 PC646.1 PR653.2 PR656.1 PR657.1 PR661.2 PU602.19
ISUMP_VSA: PC633.1 PC637.1 PR624.2 PR642.1 PR643.2 PR654.2 PU602.27
ITP_PMODE: JXDP1.46 RC115.1 UC1.E8
JDIMM1_EVENT#: JDIMM1.134 RD61.1
JDIMM2_EVENT#: JDIMM2.134 RD4.1
JTAG_CLK: JDEG1.4 RPE7.3 UE2.B56
JTAG_RST#: CE30.1 JTAG1.1 RE63.2 RE65.1 UE2.B47
JTAG_TDI: JDEG1.2 RPE7.1 UE2.A51
JTAG_TDO: JDEG1.5 RPE7.4 UE2.B55
JTAG_TMS: JDEG1.3 RPE7.2 UE2.A53
KB_DET#: JKBTP1.1 RC288.1 UC1.BB7
LAN_ACTLED_YEL#: QL1.6 RL14.1
LAN_ACTLED_YEL_R#: JLOM1.10 RL14.2
LAN_DISABLE#_R: RL5.2 RL7.2 RL9.1 UE1.B53 UL1.3
LAN_MDIN0: RL72.1 UL1.14
LAN_MDIN0_L: RL72.2 UL4.11
LAN_MDIN1: RL74.1 UL1.18
LAN_MDIN1_L: RL74.2 UL4.9
LAN_MDIN2: RL76.1 UL1.21
LAN_MDIN2_L: RL76.2 UL4.6
LAN_MDIN3: RL78.1 UL1.24
LAN_MDIN3_L: RL78.2 UL4.2
LAN_MDIP0: RL71.1 UL1.13
LAN_MDIP0_L: RL71.2 UL4.12
LAN_MDIP1: RL73.1 UL1.17
LAN_MDIP1_L: RL73.2 UL4.10
LAN_MDIP2: RL75.1 UL1.20
LAN_MDIP2_L: RL75.2 UL4.7
LAN_MDIP3: RL77.1 UL1.23
LAN_MDIP3_L: RL77.2 UL4.3
LAN_TEST_EN: RL12.1 UL1.30
LAN_WAKE#: RC323.2 RL70.2 UC1.AM15 UE2.B27 UL1.2
LCD_CBL_DET#: JEDP1.40 RC287.1 UC1.AC3
LCD_TST: JEDP1.29 RE20.2 UE1.A36
LCD_VCC_TEST_EN: DV3.2 UE1.A40
LED_10_GRN#: QL2.6 RL19.1
LED_10_GRN_R#: JLOM1.11 RL19.2
LED_100_ORG#: QL1.3 RL20.1
LED_100_ORG_R#: JLOM1.13 RL20.2
LED_SATA_DIAG_OUT#: DZ4.1 UE1.A10
LID_CL#: JLED1.7 RE26.1 UZ10.2
LID_CL_SIO#: CE8.1 RE25.2 RE26.2 UE1.B54
LOM_ACTLED_YEL#: UL1.26 UL4.15
LOM_SPD10LED_GRN#: UL1.25 UL2.2 UL4.42
LOM_SPD100LED_ORG#: UL1.27 UL2.1 UL4.16
LPC_AD0: JLPDE1.3 UC1.AY13 UE1.A27 UE2.A30
LPC_AD1: JLPDE1.4 UC1.BA13 UE1.A26 UE2.B32
LPC_AD2: JLPDE1.5 UC1.BB13 UE1.B26 UE2.A31
LPC_AD3: JLPDE1.6 UC1.AY12 UE1.B25 UE2.B33
LPC_FRAME#: JLPDE1.7 UC1.BA12 UE1.A21 UE2.B31
LPC_LDRQ1#: RPE8.1 UE1.A22
LX_1.8VALW: PL501.1 PR502.1 PU501.3
LX_1V_PRIM: PL404.1 PR409.1 PU402.2 PU402.3
LX_1VS_VCCIO: PL402.1 PR405.1 PU401.2 PU401.3
LX_3V: PC102.2 PL100.1 PR106.1 PU100.6 PU100.19 PU100.20
LX_5V: PC114.2 PL101.1 PR112.1 PU102.6 PU102.19 PU102.20
M2_DEVSLP: JNGFF3.38 RN37.2 UC1.J3
MASK_BASE_LEDS#: QZ7.5 UZ10.4
MASK_SATA_LED#: QZ3.5 UE1.B9
MCARD_PCIE#_SATA: T131.1(TP-1) UE2.B8
ME_FWP: RC221.1 RC223.1 SW1.3
ME_FWP_EC: RC221.2 SW1.1 UE1.A64
ME_RESET#: RC225.2 RC227.1 UC12.2
ME_SUS_PWR_ACK: RC74.2 UC1.AR13 UE2.A8
MEC_XTAL1: CE28.1 UE2.A61 YE1.1
MEC_XTAL2: CE29.1 RE290.2 YE1.2
MEC_XTAL2_R: RE290.1 UE2.A62
MEDIACARD_IRQ#: RR19.2 UC1.M1 UR2.32
MEM_SMBCLK: QC2.6 RC12.1 UC1.R7
MEM_SMBDATA: QC2.3 RC14.1 UC1.R8
MIC1_L: CA43.1 UA1.19
MIC1_R: CA44.1 UA1.20
MPHYP_PWR_EN: PR301.2 RZ83.2 UC1.AM10
MSCLK: JDEG1.6 RE72.2 UE2.B43
MSDATA: JDEG1.7 RE75.2 RE86.2 UE2.A40
NB_PSID: PD6.2 PD6.3 PJPDC1.1 PL4.2
NB_PSID_TS5A63157: PR6.1 PR7.2 PU1.3
NRB_BIT: RC186.2 UC1.AR7
NTC_IA: PR635.2 PU602.15
NVME_LED#: JNGFF3.10 RZ118.1
ONE_DIMM#: RC267.2 RC268.1 UC1.M2
P33ALW: PR931.1 PU901.18
P33ALW2: PR932.2 PU901.9
PANEL_BKEN_EC: DV2.2 UE1.B38
PANEL_BKLEN: DV2.3 UC1.R12
PANEL_ID: CE47.1 RE300.2 UE2.A10
PBAT_PRES#: PD3.2 PD4.1 PR3.2 PR828.1 PRP1.1 PU902.1 UE2.A49
PBAT_PRES#_C: PBATT1.6 PRP1.8
PBAT_SMBCLK: PD2.2 PRP1.3 RPE6.4 UE2.A56
PBAT_SMBCLK_C: PBATT1.4 PRP1.6
PBAT_SMBDAT: PD2.3 PRP1.2 RPE6.3 UE2.B59
PBAT_SMBDAT_C: PBATT1.5 PRP1.7
PBATT+_C: PBATT1.1 PBATT1.2 PBATT1.3 PC3.1 PL2.1 PL3.1
PCH_ALW_ON: RPE10.4 RZ65.1 UE2.A34
PCH_BATLOW#: RC72.1 UC1.AU13
PCH_CL_CLK1: JNGFF1.34 UC1.G3
PCH_CL_DATA1: JNGFF1.32 UC1.G2
PCH_CL_RST1#: JNGFF1.30 UC1.G1
PCH_DPWROK: CC266.1 RC215.1 RC220.1 UC1.BB20 UE2.A36
PCH_JTAG_TCK: JXDP1.55 RC86.2 UC1.B56
PCH_JTAG_TDI: CC304.1 RC81.2 RC229.2 UC1.D59
PCH_JTAG_TDO: CC303.1 RC82.2 RC230.2 UC1.A56
PCH_JTAG_TMS: RC130.2 RC228.2 UC1.C59
PCH_PCIE_WAKE#: RC67.2 RE274.2 UC1.BB15 UE2.B46
PCH_PLTRST#: RC60.2 RC61.2 RC62.2 RC64.2 RC244.2 UC1.AN10 UC7.1 UC7.2
PCH_PLTRST#_AND: CZ68.1 JNGFF1.44 JNGFF1.58 JNGFF2.42 JNGFF3.50 RC65.1 RC325.2 RZ114.1 UC7.4 UR2.1
PCH_PLTRST#_EC: JLPDE1.8 RC244.1 UE2.B30
PCH_POPIRCOMP: RC89.1 UC1.AU16
PCH_PWROK: PR614.1 UC1.BA20
PCH_RSMRST#: RE88.1 UE2.A45 UZ6.1
PCH_RSMRST#_Q: RC75.2 RC124.1 RC215.2 UC1.AY17 UZ6.4
PCH_RTCRST#: CC25.1 CMOS1.1 JAPS1.9 RC57.1 UC1.AM16
PCH_RTCX1: CC23.1 RC54.2 UC1.AM18 YC2.1
PCH_RTCX2: RC54.1 RC296.1 UC1.AM20
PCH_RTCX2_R: CC26.1 RC296.2 YC2.2
PCH_SATA_LED#: QZ3.4 RPC4.2 RZ118.2 UC1.H1
PCH_SMB_ALERT#: RC23.1 UC1.R10
PCH_SPI_CLK: JSPI1.13 RC35.2 UC1.AV2
PCH_SPI_CLK_0_R: RC29.2 RPC1.6 UC5.6
PCH_SPI_CLK_1_R: RC28.2 RPC2.7 UC6.6
PCH_SPI_CLK_2_R: RZ60.2 RZ63.2 UZ12.19
PCH_SPI_CLK_R1: JSPI1.14 RC35.1 RPC1.3 RPC2.2 RZ60.1
PCH_SPI_CS#0: JSPI1.11 RC36.2 UC1.AU3
PCH_SPI_CS#0_R1: JSPI1.12 RC36.1 RC37.1
PCH_SPI_CS#0_R2: RC37.2 UC5.1
PCH_SPI_CS#1: JSPI1.19 RC32.2 UC1.AU2
PCH_SPI_CS#1_R1: JSPI1.20 RC32.1 RC42.1
PCH_SPI_CS#1_R2: RC42.2 UC6.1
PCH_SPI_CS#2: RZ61.1 UC1.AU1
PCH_SPI_CS#2_R: RZ61.2 RZ110.1 RZ113.1 UZ12.20
PCH_SPI_D0: JSPI1.17 RC10.2 RC33.2 UC1.AV3
PCH_SPI_D0_0_R: RPC1.7 UC5.5
PCH_SPI_D0_1_R: RPC2.6 UC6.5
PCH_SPI_D0_2_R: RZ59.2 UZ12.21
PCH_SPI_D0_R1: JSPI1.18 RC33.1 RPC1.2 RPC2.3 RZ59.1
PCH_SPI_D1: JSPI1.15 RC34.2 UC1.AW3
PCH_SPI_D1_0_R: RPC1.8 UC5.2
PCH_SPI_D1_1_R: RPC2.5 UC6.2
PCH_SPI_D1_2_R: RZ58.2 UZ12.24
PCH_SPI_D1_R1: JSPI1.16 RC34.1 RPC1.1 RPC2.4 RZ58.1
PCH_SPI_D2: JSPI1.9 RC11.2 RC38.2 UC1.AW2
PCH_SPI_D2_0_R: RC39.2 UC5.3
PCH_SPI_D2_1_R: RC43.2 UC6.3
PCH_SPI_D2_R1: JSPI1.10 RC30.2 RC38.1 RC39.1 RC43.1
PCH_SPI_D3: JSPI1.7 RC40.2 UC1.AU4
PCH_SPI_D3_0_R: RPC1.5 UC5.7
PCH_SPI_D3_1_R: RPC2.8 UC6.7
PCH_SPI_D3_R1: JSPI1.8 RC31.2 RC40.1 RC316.2 RPC1.4 RPC2.1
PCH_SPI_DO2_XDP: JXDP1.60 RC11.1
PCH_SPI_DO_XDP: RC10.1 RC128.1 RC133.2
PCI_CLK_LPC0: RC16.1 RC18.1 UC1.AW9
PCI_CLK_LPC1: RC22.1 RC24.1 UC1.AY9
PCIE_PRX_C_DTX_N9: CL2.1 UL1.39
PCIE_PRX_C_DTX_N10: CR27.2 UR2.8
PCIE_PRX_C_DTX_N11: JNGFF3.29 RN78.1
PCIE_PRX_C_DTX_N12: JNGFF3.43 RN82.1
PCIE_PRX_C_DTX_P9: CL1.1 UL1.38
PCIE_PRX_C_DTX_P10: CR26.2 UR2.7
PCIE_PRX_C_DTX_P11: JNGFF3.31 RN77.1
PCIE_PRX_C_DTX_P12: JNGFF3.41 RN81.1
PCIE_PRX_C_RD_DTX_N11: CN24.2 UN4.4
PCIE_PRX_C_RD_DTX_N12: CN34.2 UN5.4
PCIE_PRX_C_RD_DTX_P11: CN23.2 UN4.5
PCIE_PRX_C_RD_DTX_P12: CN33.2 UN5.5
PCIE_PRX_DTX_N3: JNGFF2.33 UC1.H16
PCIE_PRX_DTX_N5: JNGFF1.35 UC1.F16
PCIE_PRX_DTX_N6: JNGFF1.59 UC1.G18
PCIE_PRX_DTX_N9: CL2.2 UC1.E22
PCIE_PRX_DTX_N10: CR27.1 UC1.F25
PCIE_PRX_DTX_N11: CN24.1 UC1.E28
PCIE_PRX_DTX_N12: CN34.1 UC1.E30
PCIE_PRX_DTX_P3: JNGFF2.35 UC1.G16
PCIE_PRX_DTX_P5: JNGFF1.33 UC1.E16
PCIE_PRX_DTX_P6: JNGFF1.57 UC1.F18
PCIE_PRX_DTX_P9: CL1.2 UC1.E23
PCIE_PRX_DTX_P10: CR26.1 UC1.E25
PCIE_PRX_DTX_P11: CN23.1 UC1.E27
PCIE_PRX_DTX_P12: CN33.1 UC1.F30
PCIE_PRX_RD_DTX_N11: RN78.2 UN4.15
PCIE_PRX_RD_DTX_N12: RN82.2 UN5.15
PCIE_PRX_RD_DTX_P11: RN77.2 UN4.14
PCIE_PRX_RD_DTX_P12: RN81.2 UN5.14
PCIE_PTX_C_DRX_N3: CZ58.2 JNGFF2.39
PCIE_PTX_C_DRX_N5: CZ14.2 JNGFF1.29
PCIE_PTX_C_DRX_N6: CZ22.2 JNGFF1.53
PCIE_PTX_C_DRX_N9: CL6.2 UL1.42
PCIE_PTX_C_DRX_N10: CR25.2 UR2.4
PCIE_PTX_C_DRX_N11: CN26.1 JNGFF3.35
PCIE_PTX_C_DRX_N12: CN36.1 JNGFF3.47
PCIE_PTX_C_DRX_P3: CZ59.2 JNGFF2.41
PCIE_PTX_C_DRX_P5: CZ13.2 JNGFF1.27
PCIE_PTX_C_DRX_P6: CZ21.2 JNGFF1.51
PCIE_PTX_C_DRX_P9: CL5.2 UL1.41
PCIE_PTX_C_DRX_P10: CR24.2 UR2.3
PCIE_PTX_C_DRX_P11: CN25.1 JNGFF3.37
PCIE_PTX_C_DRX_P12: CN35.1 JNGFF3.49
PCIE_PTX_C_RD_DRX_N11: CN22.2 UN4.2
PCIE_PTX_C_RD_DRX_N12: CN31.2 UN5.2
PCIE_PTX_C_RD_DRX_P11: CN21.2 UN4.1
PCIE_PTX_C_RD_DRX_P12: CN32.2 UN5.1
PCIE_PTX_DRX_N3: CZ58.1 UC1.D17
PCIE_PTX_DRX_N5: CZ14.1 UC1.C19
PCIE_PTX_DRX_N6: CZ22.1 UC1.D20
PCIE_PTX_DRX_N9: CL6.1 UC1.B23
PCIE_PTX_DRX_N10: CR25.1 UC1.D23
PCIE_PTX_DRX_N11: CN22.1 UC1.D24
PCIE_PTX_DRX_N12: CN31.1 UC1.A25
PCIE_PTX_DRX_P3: CZ59.1 UC1.C17
PCIE_PTX_DRX_P5: CZ13.1 UC1.D19
PCIE_PTX_DRX_P6: CZ21.1 UC1.C20
PCIE_PTX_DRX_P9: CL5.1 UC1.A23
PCIE_PTX_DRX_P10: CR24.1 UC1.C23
PCIE_PTX_DRX_P11: CN21.1 UC1.C24
PCIE_PTX_DRX_P12: CN32.1 UC1.B25
PCIE_PTX_RD_DRX_N11: CN26.2 UN4.17
PCIE_PTX_RD_DRX_N12: CN36.2 UN5.17
PCIE_PTX_RD_DRX_P11: CN25.2 UN4.18
PCIE_PTX_RD_DRX_P12: CN35.2 UN5.18
PCIE_RCOMPN: RC45.1 UC1.F5
PCIE_RCOMPP: RC45.2 UC1.E5
PCIE_WAKE#: JNGFF1.47 JNGFF1.62 JNGFF2.46 JNGFF3.54 RE274.1 RE275.1
PCIE_WAKE#_R: RE35.2 RE275.2 UE1.B10
PECI_EC: RE60.2 UC1.A54
PECI_EC_R: RE60.1 UE2.A48
PGOOD_3V: PR107.2 PR120.1 PU100.9 PU101.1
PGOOD_5V: PR113.2 PR119.1 PU101.2 PU102.9
PLTRST_5048#: RC64.1 UE1.B22
PLTRST_LAN#: RC62.1 UL1.36
PLTRST_TPM#: RC60.1 RC325.1 UZ12.17
PLTRST_VMM2320#: RC61.1 UV8.A13
PM_LANPHY_ENABLE: RL7.1 UC1.AW17
PME#: T115.1(TP-1) UC1.AU11
POA_WAKE#: JUSH1.23 RPE5.3 UE2.B68
POWER_SW#_MB: CE10.1 JAPS1.11 RE33.2 SW3.2 SW3.4
POWER_SW_IN#: CE12.1 RE31.2 RE33.1 UE2.B67
PS_ID: PU1.4 UE2.B24
PSID_DISABLE#: PR11.2 UE1.A37
PWM1_GT: PR680.1 PU602.12 PU605.8
PWM_IA: PR662.1 PU602.22 PU603.8
PWM_VSA: PU602.30 PU606.3
RD1_A_DE0: RN25.2 RN38.1 UN4.6
RD1_A_DE1: RN26.2 RN39.1 UN4.8
RD1_A_EQ0: RN42.2 RN45.1 UN4.23
RD1_A_EQ1: RN43.2 RN46.1 UN4.22
RD1_A_EQ2: RN44.2 RN47.1 UN4.19
RD1_B_DE0: RN27.2 RN40.1 UN4.13
RD1_B_DE1: RN28.2 RN41.1 UN4.9
RD1_B_EQ0: RN49.2 RN52.1 UN4.11
RD1_B_EQ1: RN50.2 RN53.1 UN4.21
RD1_B_EQ2: RN51.2 RN54.1 UN4.16
RD1_REXT: RN30.1 UN4.10
RD2_A_DE0: RN55.2 RN59.1 UN5.6
RD2_A_DE1: RN56.2 RN60.1 UN5.8
RD2_A_EQ0: RN63.2 RN66.1 UN5.23
RD2_A_EQ1: RN64.2 RN67.1 UN5.22
RD2_A_EQ2: RN65.2 RN68.1 UN5.19
RD2_B_DE0: RN57.2 RN61.1 UN5.13
RD2_B_DE1: RN58.2 RN62.1 UN5.9
RD2_B_EQ0: RN69.2 RN72.1 UN5.11
RD2_B_EQ1: RN70.2 RN73.1 UN5.21
RD2_B_EQ2: RN71.2 RN74.1 UN5.16
RD2_REXT: RN31.1 UN5.10
REM_DIODE1_N: CE24.1 CE35.1 QE3.3 UE2.B13
REM_DIODE1_P: CE24.2 CE35.2 QE3.1 QE3.2 UE2.A13
REM_DIODE2_N: CE26.1 CE37.2 CE46.2 QE5.3 QE7.1 QE7.2 UE2.B14
REM_DIODE2_P: CE26.2 CE37.1 CE46.1 QE5.1 QE5.2 QE7.3 UE2.A14
REM_DIODE4_N: CE27.1 CE39.1 QE6.3 UE2.A16
REM_DIODE4_P: CE27.2 CE39.2 QE6.1 QE6.2 UE2.B17
RES_BIAS: RL13.1 UL1.12
RESET_OUT#: RC129.1 RE56.2 UC1.B6 UE2.B39
RESET_OUT#_R: CC33.1 JXDP1.47 RC128.2 RC129.2
RING2: LA10.1 RA5.1 UA1.28
RING2_R: CA4.1 CA13.2 DA3.2 JHP1.4 LA10.2
RJ45_MDIN0: JLOM1.2 TL1.14
RJ45_MDIN1: JLOM1.6 TL1.20
RJ45_MDIN2: JLOM1.5 TL1.18
RJ45_MDIN3: JLOM1.8 TL1.24
RJ45_MDIP0: JLOM1.1 TL1.13
RJ45_MDIP1: JLOM1.3 TL1.19
RJ45_MDIP2: JLOM1.4 TL1.17
RJ45_MDIP3: JLOM1.7 TL1.23
RUN_ON: PR402.1 QE2.2 RE280.2 RE292.2 RPE10.1 UE5.4 UZ3.3 UZ4.3
RUN_ON#: QE2.5 QE2.6 RE68.2
RUN_ON_EC: RE292.1 UE2.B9 UE5.2
RUNPWROK: QE2.3 RE67.2 UC8.1 UC8.4 UC8.10 UC8.13 UE1.A4 UE2.B26
S5_1.2V: PC214.1 PR208.2 PU201.8
SA_SNUB: PC622.1 PR627.2
SA_SW: PL601.1 PQ501.9 PR619.2 PR624.1 PR627.1 PU606.8
SATA_LED: JLED1.3 QZ4.3
SATA_LED#: QZ3.6 QZ4.2
SATA_PRX_C_DTX_N1: C313.2 JDOCK1.56
SATA_PRX_C_DTX_P1: C312.2 JDOCK1.54
SATA_PRX_DTX_N1: C313.1 UC1.G21
SATA_PRX_DTX_P1: C312.1 UC1.F21
SATA_PTX_C_DRX_N1: C315.1 JDOCK1.62
SATA_PTX_C_DRX_P1: C314.1 JDOCK1.60
SATA_PTX_DRX_N1: C315.2 UC1.D21
SATA_PTX_DRX_P1: C314.2 UC1.C21
SATAGP0: RPC4.3 UC1.H2
SATAGP1: RPC4.1 UC1.H3
SD/MMCCD#: JSD1.18 UR2.30
SD/MMCCLK: RR1.1 UR2.17
SD/MMCCLK_R: CR23.1 JSD1.5 RR1.2
SD/MMCCMD: RR23.1 UR2.19
SD/MMCCMD_R: JSD1.2 RR23.2
SD/MMCDAT0/RCLK+: RR22.1 UR2.16
SD/MMCDAT0/RCLK+_R: JSD1.7 RR22.2
SD/MMCDAT1/RCLK-: RR21.1 UR2.15
SD/MMCDAT1/RCLK-_R: JSD1.8 RR21.2
SD/MMCDAT2: RR18.1 UR2.21
SD/MMCDAT2_R: JSD1.9 RR18.2
SD/MMCDAT3: RR17.1 UR2.20
SD/MMCDAT3_R: JSD1.1 RR17.2
SD_GPIO: RR16.2 UR2.28
SD_RCOMP: RC96.1 UC1.AB7
SD_UHS2_D0N: JSD1.12 UR2.25
SD_UHS2_D0P: JSD1.11 UR2.26
SD_UHS2_D1N: JSD1.15 UR2.23
SD_UHS2_D1P: JSD1.16 UR2.22
SDWP: QR1.1 UR2.29
SDWP_Q: JSD1.19 QR1.3
SIM_DET: JNGFF2.58 RI31.2
SIM_DET_R: JSIM1.9 RI31.1
SIO_EXT_SCI#: RC237.1 UC1.AN7 UE2.A33
SIO_EXT_SMI#: RC346.2 UC1.A6 UE2.A6
SIO_EXT_WAKE#: RC283.2 UC1.AD3 UE2.B5
SIO_PWRBTN#: CC269.1 JXDP1.41 RC241.2 UC1.BA15 UE2.B58
SIO_RCIN#: RC13.2 UC1.AW13 UE2.A27
SIO_SLP_A#: JAPS1.6 RC339.2 UC1.AN16 UE2.B28
SIO_SLP_LAN#: RC68.1 RC344.1 UC1.AW15 UE2.B37 UZ2.5
SIO_SLP_S0#: JAPS1.15 PR425.1 PR426.1 RZ112.1 UC1.AT11 UC13.1
SIO_SLP_S3#: JAPS1.2 PR511.1 QE11.2 RC320.1 RE280.1 RZ120.1 UC1.AP15 UC13.2 UE2.A35 UE3.2 UE5.1
SIO_SLP_S4#: JAPS1.5 PR208.1 PR1500.1 UC1.BA16 UC14.2 UE2.B36 UZ21.4
SIO_SLP_S5#: JAPS1.4 UC1.AY16 UE2.A18
SIO_SLP_SUS#: PR312.2 PR406.1 PR504.1 RC76.2 RC340.2 RZ64.1 RZ82.2 UC1.AN15 UC14.1
SIO_SLP_SUS#_R: RC76.1 UE2.B52
SIO_SLP_WLAN#: RZ71.1 UC1.BB17 UE1.A14
SL_BAT_PRES#: PR926.1 PU901.21
SLEEVE: LA11.1 QA2.3 RA6.1 UA1.29
SLEEVE_R: CA1.1 CA12.1 DA1.3 JHP1.3 LA11.2
SLICE_BAT_ON: PR930.2 RE17.2 UE1.A31
SLICE_BAT_PRES#: JDOCK1.141 JDOCK1.143 PR4.1 PR926.2 RE5.2 UE1.B33
SLOT2_CONFIG_0: JNGFF2.13 RPE11.1 UE1.B12
SLOT2_CONFIG_1: JNGFF2.61 RPE11.2 UE1.A18
SLOT2_CONFIG_2: JNGFF2.67 RPE11.3 UE1.A44
SLOT2_CONFIG_3: JNGFF2.1 RPE11.4 UE1.B34
SM_RCOMP0: RC5.1 UC1.AR18
SM_RCOMP1: RC6.1 UC1.AT18
SM_RCOMP2: RC7.1 UC1.AU18
SML0_SMBCLK: RC19.1 RC347.1 UC1.R9 UL1.28
SML0_SMBDATA: RC20.1 RC348.1 UC1.W2 UL1.31
SML1_SMBCLK: RC15.1 UC1.W3 UE2.B6
SML1_SMBDATA: RC17.1 UC1.V3 UE2.A5
SNB_+1VALWP: PC302.1 PR303.2
SNUB_1.2V: PC211.1 PR204.2
SNUB_1.8VALW: PC506.1 PR502.2
SNUB_1V_PRIM: PC419.1 PR409.2
SNUB_1VS_VCCIO: PC401.1 PR405.2
SOFT_START_GC: PR14.2 PU901.2
SPKR: RA12.2 RC183.2 UC1.AW5
SRTCRST#: CC24.1 RC56.1 UC1.AN18
SS_1V_PRIM: PC420.1 PR428.1 PU402.7
SS_1VS_VCCIO: PC410.1 PR427.1 PU401.7
STSTART_DCBLOCK_GC: PR906.2 PU901.16
SUS_STAT#: RC26.1 UC1.BA11
SUSACK#: UC1.AP11 UE2.B7
SUSCLK: RC48.1 RN99.2 RZ56.1 UC1.BA17
SUSCLK_R: JNGFF3.60 RN99.1
SW1_DP1_AUXN: RV69.2 UV7.27 UV26.23 UV26.25
SW1_DP1_AUXP: RV70.2 UV7.26 UV26.22 UV26.24
SW1_DP1_CADET: RV67.2 UV7.43 UV26.4
SW1_DP1_HPD: UV7.48 UV26.3
SW1_DP1_N0: CV607.1 UV7.49
SW1_DP1_N0_C: CV607.2 UV26.7
SW1_DP1_N1: CV609.1 UV7.46
SW1_DP1_N1_C: CV609.2 UV26.10
SW1_DP1_N2: CV611.1 UV7.44
SW1_DP1_N2_C: CV611.2 UV26.13
SW1_DP1_N3: CV613.1 UV7.41
SW1_DP1_N3_C: CV613.2 UV26.16
SW1_DP1_P0: CV606.1 UV7.50
SW1_DP1_P0_C: CV606.2 UV26.6
SW1_DP1_P1: CV608.1 UV7.47
SW1_DP1_P1_C: CV608.2 UV26.9
SW1_DP1_P2: CV610.1 UV7.45
SW1_DP1_P2_C: CV610.2 UV26.12
SW1_DP1_P3: CV612.1 UV7.42
SW1_DP1_P3_C: CV612.2 UV26.15
SW1_DP2_AUXN: JMDP1.18 RV501.2 UV7.29
SW1_DP2_AUXP: JMDP1.16 RV502.2 UV7.28
SW1_DP2_CADET: JMDP1.4 RV68.2 UV7.33
SW1_DP2_HPD: JMDP1.2 UV7.38
SW1_DP2_N0: CV508.2 UV7.39
SW1_DP2_N0_C: CV508.1 JMDP1.5
SW1_DP2_N1: CV506.2 UV7.36
SW1_DP2_N1_C: CV506.1 JMDP1.11
SW1_DP2_N2: CV504.2 UV7.34
SW1_DP2_N2_C: CV504.1 JMDP1.17
SW1_DP2_N3: CV502.2 UV7.31
SW1_DP2_N3_C: CV502.1 JMDP1.12
SW1_DP2_P0: CV507.2 UV7.40
SW1_DP2_P0_C: CV507.1 JMDP1.3
SW1_DP2_P1: CV505.2 UV7.37
SW1_DP2_P1_C: CV505.1 JMDP1.9
SW1_DP2_P2: CV503.2 UV7.35
SW1_DP2_P2_C: CV503.1 JMDP1.15
SW1_DP2_P3: CV501.2 UV7.32
SW1_DP2_P3_C: CV501.1 JMDP1.10
SW1_DP2_P14: JMDP1.6 RV503.2
SW1_PS8338_CFG0: RV51.2 UV7.59
SW1_PS8338_P0: RV60.2 UV7.60
SW1_PS8338_P1: RV53.2 RV100.1 UV7.1
SW1_PS8338_PC10: RV58.2 RV65.1 UV7.56
SW1_PS8338_PC11: RV57.2 RV63.1 UV7.55
SW1_PS8338_PC20: RV56.2 RV64.1 UV7.54
SW1_PS8338_PC21: RV55.2 RV62.1 UV7.53
SW1_PS8338_PEQ: RV54.2 RV61.1 UV7.8
SW1_PS8338_SW: RV52.2 UV7.18
SW2_DP1_AUXN: CV150.1 RV605.2 UV26.27
SW2_DP1_AUXN_C: CV150.2 JNGFF1.12
SW2_DP1_AUXP: CV149.1 RV609.2 UV26.26
SW2_DP1_AUXP_C: CV149.2 JNGFF1.14
SW2_DP1_CADET: RV606.2 UV26.43
SW2_DP1_HPD: JNGFF1.23 UV26.48
SW2_DP1_N0: CV156.1 UV26.49
SW2_DP1_N0_C: CV156.2 JNGFF1.24
SW2_DP1_N1: CV152.1 UV26.46
SW2_DP1_N1_C: CV152.2 JNGFF1.18
SW2_DP1_N2: CV148.1 UV26.44
SW2_DP1_N2_C: CV148.2 JNGFF1.17
SW2_DP1_N3: CV145.1 UV26.41
SW2_DP1_N3_C: CV145.2 JNGFF1.11
SW2_DP1_P0: CV157.1 UV26.50
SW2_DP1_P0_C: CV157.2 JNGFF1.26
SW2_DP1_P1: CV153.1 UV26.47
SW2_DP1_P1_C: CV153.2 JNGFF1.20
SW2_DP1_P2: CV147.1 UV26.45
SW2_DP1_P2_C: CV147.2 JNGFF1.19
SW2_DP1_P3: CV146.1 UV26.42
SW2_DP1_P3_C: CV146.2 JNGFF1.13
SW2_DP2_AUXN: CV111.1 RV604.2 UV26.29
SW2_DP2_AUXN_C: CV111.2 UV8.H2
SW2_DP2_AUXP: CV110.1 RV608.2 UV26.28
SW2_DP2_AUXP_C: CV110.2 UV8.H1
SW2_DP2_CADET: RV607.2 UV26.33
SW2_DP2_HPD: UV8.J1 UV26.38
SW2_DP2_N0: CV103.1 UV26.39
SW2_DP2_N0_C: CV103.2 UV8.G2
SW2_DP2_N1: CV105.1 UV26.36
SW2_DP2_N1_C: CV105.2 UV8.F2
SW2_DP2_N2: CV107.1 UV26.34
SW2_DP2_N2_C: CV107.2 UV8.E2
SW2_DP2_N3: CV109.1 UV26.31
SW2_DP2_N3_C: CV109.2 UV8.D2
SW2_DP2_P0: CV102.1 UV26.40
SW2_DP2_P0_C: CV102.2 UV8.G1
SW2_DP2_P1: CV104.1 UV26.37
SW2_DP2_P1_C: CV104.2 UV8.F1
SW2_DP2_P2: CV106.1 UV26.35
SW2_DP2_P2_C: CV106.2 UV8.E1
SW2_DP2_P3: CV108.1 UV26.32
SW2_DP2_P3_C: CV108.2 UV8.D1
SW2_PS8338_CFG0: RV601.2 UV26.59
SW2_PS8338_P0: RV615.2 UV26.60
SW2_PS8338_P1: RV603.2 RV621.1 UV26.1
SW2_PS8338_PC10: RV614.2 RV620.1 UV26.56
SW2_PS8338_PC11: RV613.2 RV619.1 UV26.55
SW2_PS8338_PC20: RV612.2 RV618.1 UV26.54
SW2_PS8338_PC21: RV611.2 RV617.1 UV26.53
SW2_PS8338_PEQ: RV610.2 RV616.1 UV26.8
SW2_PS8338_SW: RV602.2 UV26.18
SW_1.2V: PC205.2 PL201.2 PQ201.7 PR204.1 PU201.16
SW_+1VALWP: PL301.1 PR303.1 PR304.2 PU301.10
SW_LAN0_10_GRN#: QL2.1 RL30.2 UL4.41
SW_LAN0_100_ORG#: QL1.4 RL29.2 UL4.18
SW_LAN0_ACTLED_YEL#: QL1.1 UL4.17
SW_LAN0_MDIN0: TL1.11 UL4.25
SW_LAN0_MDIN1: TL1.5 UL4.29
SW_LAN0_MDIN2: TL1.7 UL4.34
SW_LAN0_MDIN3: TL1.1 UL4.38
SW_LAN0_MDIP0: TL1.12 UL4.24
SW_LAN0_MDIP1: TL1.6 UL4.28
SW_LAN0_MDIP2: TL1.8 UL4.33
SW_LAN0_MDIP3: TL1.2 UL4.37
SW_LAN1_10_GRN#: JDOCK1.3 UL4.40
SW_LAN1_100_ORG#: JDOCK1.4 UL4.20
SW_LAN1_ACTLED_YEL#: JDOCK1.100 UL4.19
SW_LAN1_MDIN0: JDOCK1.106 UL4.23
SW_LAN1_MDIN1: JDOCK1.112 UL4.27
SW_LAN1_MDIN2: JDOCK1.124 UL4.32
SW_LAN1_MDIN3: JDOCK1.130 UL4.36
SW_LAN1_MDIP0: JDOCK1.104 UL4.22
SW_LAN1_MDIP1: JDOCK1.110 UL4.26
SW_LAN1_MDIP2: JDOCK1.122 UL4.31
SW_LAN1_MDIP3: JDOCK1.128 UL4.35
SW_USB20_N1: LI7.1 UI3.11
SW_USB20_P1: LI7.4 UI3.10
SYS_LED_MASK#: QL1.2 QL1.5 QL2.2 QZ3.2 RE21.2 UE1.B48 UZ10.1
SYS_RESET#: CC302.1 JAPS1.13 RC224.2 RC291.2 UC1.B5
SYS_RESET#_R: RC224.1 RC290.2 UC12.4
TDI_XDP: JXDP1.56 RC229.1 UC8.5
TDO_XDP: CC306.1 JXDP1.52 RC230.1 UC8.2
THERMATRIP2#: CE36.1 QE4.1 RE69.2 UE2.B34
THERMATRIP3#: RE301.1 UE2.A2
THSEL_STRAP: RE78.1 UE2.B29
TOUCH_SCREEN_DET#: JEDP1.32 RV623.2 UC1.AY5
TOUCH_SCREEN_PD#: JEDP1.5 RPC5.7 UC1.A7
TOUCHPAD_INTR#: JKBTP1.16 RC272.2 UC1.BA5
TP_LAN_JTAG_TCK: RL2.2 UL1.35
TP_LAN_JTAG_TDI: T88.1(TP-1) UL1.32
TP_LAN_JTAG_TDO: T89.1(TP-1) UL1.34
TP_LAN_JTAG_TMS: RL1.2 UL1.33
TPM_GPIO4: RZ110.2 UZ12.13
TPM_LPM#: QZ9.1 RZ111.1 UZ12.3
TPM_PIRQ#: RZ69.2 UC1.M3 UZ12.18
TPM_TYPE: RC349.1 UC1.AY7
TRST#_XDP: JXDP1.54 UC8.12
UART0_TXD: RE306.1 UC1.AB2
UART2_RXD: RC330.2 UC1.AD1
UART2_TXD: RC331.2 UC1.AD2
UIM_CLK: CZ66.1 JNGFF2.24 JSIM1.3
UIM_DATA: CZ65.1 JNGFF2.26 JSIM1.7
UIM_RESET: CZ67.1 JNGFF2.22 JSIM1.2
USB2_ID: RC337.1 UC1.AG3
USB2_VBUSSENSE: RC338.1 UC1.AG4
USB3_PRX_DTX_N1: RI16.1 UC1.H8
USB3_PRX_DTX_N2: JDOCK1.84 UC1.J6
USB3_PRX_DTX_N3: RI20.1 UC1.J10
USB3_PRX_DTX_N4: RI24.1 UC1.E10
USB3_PRX_DTX_N5: RI28.1 UC1.H13
USB3_PRX_DTX_P1: RI15.1 UC1.G8
USB3_PRX_DTX_P2: JDOCK1.86 UC1.H6
USB3_PRX_DTX_P3: RI19.1 UC1.H10
USB3_PRX_DTX_P4: RI23.1 UC1.F10
USB3_PRX_DTX_P5: RI27.1 UC1.G13
USB3_PRX_L_DTX_N1: DI4.1 DI4.9 JUSB3.5 RI16.2
USB3_PRX_L_DTX_N3: DI1.1 DI1.9 JUSB1.5 RI20.2
USB3_PRX_L_DTX_N4: DI6.1 DI6.9 JUSB2.5 RI24.2
USB3_PRX_L_DTX_N5: DI7.1 DI7.9 JNGFF2.21 RI28.2
USB3_PRX_L_DTX_P1: DI4.2 DI4.8 JUSB3.6 RI15.2
USB3_PRX_L_DTX_P3: DI1.2 DI1.8 JUSB1.6 RI19.2
USB3_PRX_L_DTX_P4: DI6.2 DI6.8 JUSB2.6 RI23.2
USB3_PRX_L_DTX_P5: DI7.2 DI7.8 JNGFF2.23 RI27.2
USB3_PTX_C_DRX_N1: CI13.1 RI18.1
USB3_PTX_C_DRX_N3: CI5.1 RI22.1
USB3_PTX_C_DRX_N4: CI27.1 RI26.1
USB3_PTX_C_DRX_N5: CI29.1 RI30.1
USB3_PTX_C_DRX_P1: CI16.1 RI17.1
USB3_PTX_C_DRX_P3: CI4.1 RI21.1
USB3_PTX_C_DRX_P4: CI28.1 RI25.1
USB3_PTX_C_DRX_P5: CI30.1 RI29.1
USB3_PTX_DRX_N1: CI13.2 UC1.C13
USB3_PTX_DRX_N2: JDOCK1.90 UC1.B13
USB3_PTX_DRX_N3: CI5.2 UC1.B15
USB3_PTX_DRX_N4: CI27.2 UC1.C15
USB3_PTX_DRX_N5: CI29.2 UC1.B17
USB3_PTX_DRX_P1: CI16.2 UC1.D13
USB3_PTX_DRX_P2: JDOCK1.92 UC1.A13
USB3_PTX_DRX_P3: CI4.2 UC1.A15
USB3_PTX_DRX_P4: CI28.2 UC1.D15
USB3_PTX_DRX_P5: CI30.2 UC1.A17
USB3_PTX_L_DRX_N1: DI4.4 DI4.7 JUSB3.8 RI18.2
USB3_PTX_L_DRX_N3: DI1.4 DI1.7 JUSB1.8 RI22.2
USB3_PTX_L_DRX_N4: DI6.4 DI6.7 JUSB2.8 RI26.2
USB3_PTX_L_DRX_N5: DI7.4 DI7.7 JNGFF2.27 RI30.2
USB3_PTX_L_DRX_P1: DI4.5 DI4.6 JUSB3.9 RI17.2
USB3_PTX_L_DRX_P3: DI1.5 DI1.6 JUSB1.9 RI21.2
USB3_PTX_L_DRX_P4: DI6.5 DI6.6 JUSB2.9 RI25.2
USB3_PTX_L_DRX_P5: DI7.5 DI7.6 JNGFF2.29 RI29.2
USB20_N1: UC1.AB9 UI3.2
USB20_N1_R: DI5.2 JUSB3.2 LI7.2
USB20_N2: LZ1.1 UC1.AD6
USB20_N2_R: JEDP1.12 LZ1.2
USB20_N3: LI3.4 UC1.AH3
USB20_N3_R: DI2.3 JUSB1.2 LI3.3
USB20_N4: LI4.4 UC1.AD9
USB20_N4_R: DI3.3 JUSB2.2 LI4.3
USB20_N5: JDOCK1.74 UC1.AJ1
USB20_N6: JDOCK1.68 UC1.AF6
USB20_N7: JUSH1.19 UC1.AH1
USB20_N8: JNGFF1.5 UC1.AF8
USB20_N9: LV27.3 UC1.AG1
USB20_N9_R: DV4.2 JEDP1.2 LV27.4
USB20_N10: JNGFF2.9 UC1.AH7
USB20_P1: UC1.AB10 UI3.3
USB20_P1_R: DI5.3 JUSB3.3 LI7.3
USB20_P2: LZ1.4 UC1.AD7
USB20_P2_R: JEDP1.13 LZ1.3
USB20_P3: LI3.1 UC1.AJ3
USB20_P3_R: DI2.2 JUSB1.3 LI3.2
USB20_P4: LI4.1 UC1.AD10
USB20_P4_R: DI3.2 JUSB2.3 LI4.2
USB20_P5: JDOCK1.72 UC1.AJ2
USB20_P6: JDOCK1.66 UC1.AF7
USB20_P7: JUSH1.18 UC1.AH2
USB20_P8: JNGFF1.3 UC1.AF9
USB20_P9: LV27.2 UC1.AG2
USB20_P9_R: DV4.3 JEDP1.3 LV27.1
USB20_P10: JNGFF2.7 UC1.AH8
USB_OC0#: RPC3.3 UC1.A9 UI3.13
USB_OC1#: RPC3.2 UC1.C9 UI1.3
USB_OC2#: RPC3.1 UC1.D9 UI2.3
USB_OC3#: RPC3.4 UC1.B9
USB_PWR_EN1#: RPE9.2 UE1.B44 UI1.4
USB_PWR_EN2#: RPE9.3 UE1.A33 UI2.4
USB_PWR_SHR_EN#: RPE9.4 UE1.A8 UI3.6
USB_PWR_SHR_VBUS_EN: RPE9.1 UE1.B50 UI3.5
USBCOMP: RC44.1 UC1.AB6
USH_DET#: DZ7.2 RC281.2 RZ87.1 UE1.A16
USH_DET#_R: DZ7.1 JUSH1.1 RZ87.2
USH_PWR_STATE#: JUSH1.5 RZ10.2 UE1.A34
USH_RST#: RZ115.1 UE1.A62
USH_RST#_R: JUSH1.6 RZ114.2 RZ115.2
USH_SMBCLK: JUSH1.16 RZ8.2 UE2.A50
USH_SMBDAT: JUSH1.15 RZ9.2 UE2.B53
VCI_IN2#: RPE5.4 UE2.B63
VCT_LAN_R1: RL3.2 UL1.6
VGA_ID: RE84.1 RE85.1 UE1.B59
VID0_PRIM_CORE: PR408.2 PR418.2 PR420.1 PU402.9
VID0_VCCIO: PR414.2 PR416.1 PU401.9
VID1_PRIM_CORE: PR411.2 PR417.2 PR419.1 PU402.8
VID1_VCCIO: PR413.2 PR415.1 PU401.8
VIDALERT_N: PR607.1 RC152.2 RC153.2
VIDSCLK: PR606.1 UC1.A63
VIDSOUT: PR609.1 RC157.2 UC1.D64
VMM3320_LPM_DIS: RV79.1 RV516.1 UC1.BA8 UV8.B2
VRALERT#: RC73.1 UC1.AM11
VSA_SEN+: PC640.2 PC650.1 PC652.1 PR649.2 RC168.2 UC1.H20
VSA_SEN-: PC649.1 PC650.2 PU602.26 RC166.1 UC1.H21
VSET_5085: CE38.1 RE77.1 UE2.A17
WIGIG_32KHZ: JNGFF1.42 RZ56.2
WLAN_DISBL#: UE1.B68 UL2.4
WLAN_WIGIG60GHZ_DIS#: DZ1.1 RE8.2 UE1.A1
WLAN_WIGIG60GHZ_DIS#_R: DZ1.2 JNGFF1.48
WWAN_PWR_EN: JNGFF2.6 RZ43.2
WWAN_RADIO_DIS#: DZ5.1 RE10.2 UE1.A53
WWAN_RADIO_DIS#_R: DZ5.2 JNGFF2.8
WWAN_WAKE#: JNGFF2.15 RE38.2 UE1.B43
XCLK_BIASREF: RC52.1 RC324.1 UC1.E42
XDP_DBRESET#: CC32.1 JXDP1.48 RC137.2 RC290.1 UC12.1
XDP_JTAGX: CC305.1 RC87.1 RC328.1 UC1.A59
XDP_OBS0: JXDP1.21 RC239.2
XDP_OBS0_R: RC239.1 UC1.C55
XDP_OBS1: JXDP1.23 RC240.2
XDP_OBS1_R: RC240.1 UC1.D55
XDP_OBS2_R: T10.1(TP-1) UC1.B54
XDP_OBS3_R: T11.1(TP-1) UC1.C56
XDP_PRSNT_PIN1: JXDP1.1 RC121.1 RC122.1
XDP_TMS: JXDP1.58 RC228.1 UC8.9
XTAL24_IN: CC21.1 RC46.2 UC1.E37 YC1.3
XTAL24_OUT: RC46.1 RC295.1 UC1.E35
XTAL24_OUT_R: CC22.1 RC295.2 YC1.1
XTALI: CL14.2 RL11.2 UL1.10 YL1.1
XTALO: RL11.1 RL34.2 UL1.9
XTALO_R: CL13.2 RL34.1 YL1.3
Z2805: RL18.1 TL1.22
Z2806: RL16.1 TL1.16
Z2807: RL17.1 TL1.21
Z2808: RL15.1 TL1.15
N40459: QV2.1 RV5.2
N46665: CA29.1 UA1.35
N46669: CA29.2 UA1.36
N46677: CA25.1 UA1.31
N46697: CA27.1 RA12.1
N46705: CA28.1 RA13.1
N46713: QA2.5 QA2.6 RA21.2
N46735: CA33.1 RA17.2
N70739: JDEG1.1 RE71.2
N70745: RE64.1 UE2.B61
N70747: CE34.1 RE66.2
N70757: RE57.1 RE58.1 UE2.A59
N75571: DZ3.2 DZ4.2 QZ3.1 RZ24.2
N75591: QZ4.1 RZ27.1
N75595: DZ3.1 QZ3.3
N13388109: PQ906.2 PR916.2
N13388133: PQ906.1 PQ909.2 PR915.2
N13388149: PD901.2 PQ909.1
N13388161: PQ909.3 PR913.2 PR915.1
N15438178: PD801.1 PD802.1 PD803.1 PR811.1
N15438627: PC815.1 PR812.1 PR813.1 PU801.6
N15439163: PR815.2 PU801.5
N15439291: PC823.2 PR816.2 PU801.7
N15439295: PC824.2 PR819.2 PU801.8
N15439512: PR820.2 PR822.2 PU801.9
N15440461: PR818.2 PU801.10
N15440728: PR827.2 PR829.1 PU801.16
N15441413: PR825.1 PU801.18
N15441884: PC828.1 PR826.1 PU801.17
N15442134: PC829.2 PC830.1 PR823.3 PU801.20
N15442185: PC830.2 PC831.1 PR823.2 PU801.19
N15443707: PR814.1 PU801.25
N17156946: PC5.1 PQ1.4 PQ5.4 PR1.2 PR14.1 PR15.1
N17156948: PQ1.1 PQ1.2
N17252180: PC902.2 PQ904.4 PR906.1
N17252838: PQ911.5 PR919.2
N18325201: CL16.1 TL1.3
N18325205: CL17.1 TL1.4
N18325209: CL20.1 TL1.9
N18325213: CL21.1 TL1.10
N18339814: DA5.1 RA25.2
N18339816: DA4.1 RA24.2
N18364501: RV50.1 UV7.20
N18366912: CV60.1 UV7.17
N18431888: DA2.2 JHP1.5 RA1.2
N18490882: RI14.2 UI3.16
N18609334: QV7.1 QV8.2 RV6.2
N18754440: QA3.3 RA27.2
N18754442: QA3.6 RA28.2
N18779977: C319.1 R273.2
N18779979: C43.1 R41.2
N18779981: C42.1 R6.2
N18894766: PC640.1 PR646.2
N18894780: PC601.1 PR652.2
N18894855: PC632.1 PR636.1 PU602.28
N18894856: PC632.2 PR641.1
N18894871: PH604.1 PR642.2
N19651849: CE9.1 RE27.2
N19651850: RE24.1 UE1.B19
N19817114: PC904.1 PQ901.1 PQ901.2 PQ901.3 PQ905.1 PQ905.2 PQ905.3 PR910.2
N19957038: PC904.2 PD904.1 PQ901.4 PQ905.4 PR910.1 PR912.1
N20360585: CA49.2 UA1.34
N20361305: CA35.2 UA1.25
N20363962: CA51.1 RA44.1 UA1.21
N20363967: CA52.1 UA1.39
N20363972: CA53.1 UA1.7
N20880735: PC307.2 PR308.1
N20899585: RV600.1 UV26.20
N20899609: CV605.1 UV26.17
N20987678: PD905.1 PQ910.3 PR911.2
N20987955: PQ902.5 PQ902.6 PR903.2
N20987996: PQ902.3 PR902.2 PR904.1
N20988471: PQ907.6 PR909.1 PU903.1
N21009123: PC207.2 PR201.1 PU201.12
N21135665: PR821.1 PU801.21
N24606174: PC313.1 PU301.5
N25124064: RA45.1 UA1.22
N26452800: PL4.1 PQ3.1 PR5.1 PR8.2
N26505659: PR601.2 PR606.2 PR618.1
N26505661: PR604.2 PR607.2 PR625.1
N26505677: PR605.2 PR609.2 PR626.1
N26506003: PR616.2 PU602.40
N26506037: PR612.2 PR614.2 PU602.39
N26506182: PR626.2 PU602.35
N26506196: PR625.2 PU602.36
N26506209: PR618.2 PU602.37
N26506689: PR678.2 PU602.38
N26508248: PC603.1 PR602.1 PU602.34
N26508256: PC604.1 PR603.1 PU602.33
N26509112: PR608.1 PU602.32
N26509117: PR611.1 PU602.31
N26518420: PC630.1 PR640.1 PU602.20
N26519264: PH605.1 PR657.2
N26522108: PC639.2 PR645.1
N26523008: PC647.2 PR650.2
N26523611: PC629.2 PR639.1
N26526626: PC627.1 PR632.2
N26527807: PH602.1 PR628.2
N26528911: PC627.2 PR638.2 PU602.8
N26532119: PC621.2 PR623.1
N26532121: PR621.2 PR622.2 PR623.2 PU602.5
N26533060: PC616.2 PR617.2 PU602.4
N26533062: PC614.2 PR617.1
N26533293: PR610.2 PU602.3
N26533871: PC613.2 PR613.2 PU602.2
N26535263: PL603.3 PR661.1
N26554964: PC617.2 PR621.1
N26566701: PC631.1 PR630.2
N26570644: PC630.2 PR644.1
N26661962: PC510.1 PR507.2 PR509.1 PR511.2 PU502.8
N26661997: PC509.2 PR508.2 PR510.1 PU502.2
N27447034: QE4.2 RE70.2
N27829830: CZ77.1 RZ63.1
N27958885: RZ62.1 UZ12.27
N28424999: T113.1(TP-1) UC1.AW71
N28425002: T114.1(TP-1) UC1.AW70
N28489601: RC222.2 SW1.2
N28712229: PC671.2 PU605.7
N28712232: PR672.2 PU605.6
N28712235: PC671.1 PR672.1
N28713556: PR671.1 PU605.1
N28714854: PC655.2 PU603.7
N28714856: PR660.2 PU603.6
N28714858: PC655.1 PR660.1
N28714920: PR659.1 PU603.1
N28718522: PC611.2 PU606.2
N28718526: PC611.1 PR619.1
N28742882: PR835.2 PU801.12
N28742885: PR836.2 PU801.11
N28769860: PR421.2 PR422.1 PU401.5
N28771761: PR404.2 PR425.2 PU401.14
N28771835: PR410.2 PR426.2 PU402.14
N28810563: CZ23.1 UZ2.10
N28856399: T16.1(TP-1) UC1.BA70
N28856402: T17.1(TP-1) UC1.BA68
N28857231: T12.1(TP-1) UC1.BB68
N28857234: T13.1(TP-1) UC1.BB69
N28857237: T14.1(TP-1) UC1.AK13
N28857240: T15.1(TP-1) UC1.AK12
N28861827: RC120.1 UC1.C64
N28891648: RC245.2 UC1.BB11
N28938912: CC8.2 RC29.1
N28938914: CC7.2 RC28.1
N29198215: RZ82.1 RZ83.1 UZ20.4
N29207759: PH601.2 PR610.1 PR631.2
N29263363: PR423.1 PR424.1 PU402.5
N29270847: PH603.2 PR635.1 PR647.2
N29708559: T126.1(TP-1) UC1.AY4
N29708561: T127.1(TP-1) UC1.BB3
N29708599: T128.1(TP-1) UC1.AU5
N29708601: T129.1(TP-1) UC1.AT5
N29708639: T130.1(TP-1) UC1.BB5
N30342894: QV4.2 RV19.2
N30404696: CZ90.1 UZ5.12
N30404698: CZ91.1 UZ5.10
N31877076: JEDP1.21 LV1.1
N32011565: PQ501.8 PU606.5
N32011581: PQ501.1 PU606.1
N32015249: PR679.1 PU606.7
N32114561: PC821.2 PR814.2
N32198964: PC1504.1 PR1500.2 PR1502.1 PU1500.8
N32198997: PC1502.2 PR1501.2 PR1503.1 PU1500.2
N32427314: CZ46.1 UZ3.12
N32427416: CZ37.1 UZ3.10
N32452041: CZ45.1 UZ4.12
N32452300: CZ38.1 UZ2.12
N32454707: RZ70.2 RZ71.2 UZ3.5
N32495700: PC4.1 PQ2.2 PR4.2
N32497274: PC111.1 PR104.1 PR105.1 PU100.16 PU100.17
N32507374: PR620.2 PU602.1
N32519648: PC802.2 PQ801.2 PQ803.2 PR804.2
N32519741: PC808.2 PC809.1 PR806.2 PU801.2
N32519935: PC809.2 PC810.1 PR807.2 PU801.1
N32604731: CZ42.1 UZ8.6
N32630676: CZ69.1 UZ4.10
N32631320: CZ41.1 UZ22.6
N32631640: RZ64.2 RZ65.2 UZ22.3
N33047472: RC320.2 UC13.4 UZ19.4
N33199734: JDIMM1.162 T50.1(TP-1)
N33199744: JDIMM1.165 T51.1(TP-1)
N33290988: CD54.2 RD25.1
N33298469: JDIMM2.162 T54.1(TP-1)
N33298471: JDIMM2.165 T55.1(TP-1)
N33612393: CD36.2 RD21.1
N34495988: QC3.2 RC339.1 RC340.1
N34678942: RZ90.2 RZ112.2 UZ12.29
N35256471: QZ9.2 RZ113.2
N36256403: QE11.3 RE70.1 RE90.2
N36518352: RZ120.2 UC14.4 UZ26.4
N36519029: RV661.2 UV29.1
N36519054: CV619.2 RV662.1 UV29.10
N39381354: PC102.1 PR100.2
N39381542: PC119.1 PU102.16 PU102.17
N39381565: PC114.1 PR111.2
N39381572: PC113.2 PR108.1
N39381889: PC127.2 PR117.1
N39382318: PR101.1 PU101.4
N48705653: PQ3.3 PR5.2 PR7.1
N48705663: PQ4.2 PR8.1 PR10.2
N48705665: PQ3.2 PQ4.1 PR9.2 PR11.1
N48708347: PC205.1 PR202.1
N48708367: PR210.2 PU201.7
N48708425: PR207.2 PU201.9
N48716673: PR933.1 PU901.28
N48716693: PR930.1 PU901.26
N49522215: PQ804.2 PQ805.2 PR808.2 PR809.2 PR810.1
N49522729: PQ803.1 PR802.2
N49522731: PQ801.1 PR802.3
N49522780: PQ802.4 PR803.1
N78957489: PQ908.1 PR912.2
N78967043: PQ908.2 PU903.4
N78985854: PR905.2 PR907.2 PU902.2
N79002827: PQ902.2 PU902.4
N79023703: PR927.1 PU901.19
N79030038: PQ911.2 PQ911.3 PR917.2
N79030087: PQ911.6 PR936.2
N79030091: PQ910.2 PR911.1 PR936.1
N79030745: PD904.2 PQ910.1
N79114801: PD4.2 PQ2.1

Pads without a net: FD1 1; FD2 1; FD3 1; FD4 1; JAPS1 16 17 18; JDIMM1 87 88 91 92 95 97 100 101 104 105; JDIMM2 87 88 91 92 95 97 100 101 104 105; JEDP1 16 20; JHDMI1 14; JIR1 3; JKBTP1 4 11; JNGFF1 6 8 9 36 38 40; JNGFF2 10 12 14 16 17 20 30 36 38 40 48 50 51 52 53 54 55 56 57 59 60; JNGFF3 5 6 7 8 11 13 17 19 20 22 23 24 25 26 28 30 32 34 36 40 42 44 46 48 56 58 59; JSIM1 4 6 8; JSPI1 4; PBATT1 11 12; PD3 3; PRP1 4 5; PU100 10 15; PU102 10; PU201 10; PU301 2; PU401 4; PU402 4; PU501 5; PU502 7; PU602 13; PU801 4; PU901 20 29 30 31 35 36; PU1500 7; QL2 3 4 5; QZ7 1 2 6; RPC5 1 3 6 8; RPE5 1 8; UA1 4; UC1 A3 A4 A11 A19 A21 A26 A27 A29 A31 A33 A36 A38 A45 A47 A52 A65 A69 AB1 AB4 AB12 AB13 AB62 AC1 AC2 AC63 AD4 AE62 AE63 AF11 AF12 AF13 AG62 AH9 AH10 AH11 AH12 AJ62 AK6 AK7 AK9 AK10 AK62 AK70 AL25 AL27 AL61 AL63 AM1 AM2 AM3 AM4 AN1 AN2 AN3 AN8 AP1 AP2 AP3 AP4 AP7 AP8 AP13 AP56 AR56 AU56 AU58 AU63 AW1 AW20 AW41 AW48 AW68 AW69 AY1 AY2 AY20 AY21 B2 B3 B7 B11 B19 B21 B26 B27 B29 B31 B33 B36 B38 B45 B47 B52 B69 B70 BA3 BA4 BA9 BB2 BB4 BB9 BB57 BB66 C2 C4 C7 C8 C11 C12 C16 C27 C28 C29 C31 C32 C33 C36 C37 C38 C54 C70 C71 D1 D3 D4 D5 D7 D8 D12 D16 D27 D28 D29 D31 D32 D33 D36 D37 D38 D54 D71 E1 E2 E3 E20 E61 F6 F11 F15 F20 F52 F60 F61 F65 G11 G15 G61 G65 H5 H11 H63 J1 J2 J4 J5 J68 J71 K45 K46 L6 M4 N1 N2 N3 N9 N11 P1 P3 P4 P62 U6 U7 V1 V2 V62 W4 W7 W8 W10 W12; UD1 1; UE1 A3 A5 A9 A11 A12 A23 A32 A42 A45 A46 A47 A48 A49 A52 A55 A56 A57 A58 A59 A60 A61 B1 B3 B4 B6 B7 B11 B13 B14 B16 B17 B18 B32 B39 B40 B45 B47 B49 B52 B55 B56 B57 B58 B61 B63 B64 B65 B66; UE2 A15 A23 B15 B16 B23 B38; UE4 1; UI3 9 15; UL4 5; UN4 3; UN5 3; UR2 31; UV7 2 4 14 58; UV8 E10 H3 H11 K2 L2 L10 L11 L12 L13 M1 M2 M10 M11; UV24 3; UV26 2 14 58; UZ12 2 4 5 6 7 10 11 12 15 25 26 28 30 31; YC1 2 4

## Via types
v1: diameter 0.457, hole 0.203, TOP to BOTTOM, 5889 vias
v2: diameter 0.305, hole 0.152, TOP to BOTTOM, 768 vias
v3: diameter 0.406, hole 0.203, TOP to BOTTOM, 149 vias
v4: diameter 0.559, hole 0.254, TOP to BOTTOM, 81 vias
v5: diameter 0.508, hole 0.254, TOP to BOTTOM, 105 vias
v6: diameter 0.61, hole 0.305, TOP to BOTTOM, 5 vias

## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point)
0.6V_DDR_VTT_ON: length 53.3
  TOP w0.102: v1(80.74,45.18) 81.06,44.87 v2(81.06,44.61) 81.06,40.85 81.32,40.6 RD30.1 81.63,40 81.87,39.76 82.47,39.76 82.7,39.99 UD1.4
  IN1 w0.102: v1(84.33,77.47) 84.33,76.73 85.43,75.62 85.43,73.01 84.27,71.85 84.27,65.96 84.44,65.79 84.44,53.54 80.74,49.85 v1(80.74,45.18)
  BOTTOM w0.102: PR210.1 76.17,81.01 76.9,81.73 79.05,81.73 83.16,77.62 84.17,77.62 v1(84.33,77.47)
1.2V_B+: length 23.3
  IN4 w0.254: v1(77.95,81) 77.95,78.46 77,77.5 74.84,77.5 74.2,76.87 74.2,76.17 73,74.96 73,68.36 69.76,65.12 v1(69.76,62.96)
  BOTTOM w0.254: PR207.1 v1(77.95,81)
  vias: v2(68.92,66.19)
1.2V_FB: length 4.7
  TOP w0.102: v2(74.22,78.2) PR209.1
  TOP w0.254: PR206.1 PC212.1 75.47,79.49 75.23,79.24 v1(75.23,78.84) 75.16,78.76 PR209.1
  BOTTOM w0.203: v1(75.23,78.84) 75.23,78.44 75.27,78.4 PU201.6
1.5VSP: length 1
  TOP w0.102: 295.44,20.91 295.44,21.52 v3(295.15,21.81)
2.5VSP:
  vias: v1(250.73,39.34) v1(251.37,39.34) v1(258.59,40.48) v1(258.61,39.92) v2(259.24,39.15)
3.3V_CAM_EN#: length 204.6
  TOP w0.102: v1(78.93,94.28) 79.48,94.83 81.64,94.83 85.16,98.36 90.67,98.36 94.97,102.65 94.97,104.94 v2(95.58,105.55) 97.25,107.22 97.25,108.05 97.64,108.43 99.1,108.43 101.7,111.03 101.7,111.47 QZ1.2
  TOP w0.254: RC311.2 164.95,78.01 166.1,79.17 168.86,79.17 169.1,79.42 169.1,80.79 167.22,82.67 165.47,82.67 165.01,83.13 165.01,83.69 165.31,83.99 v1(165.47,83.99)
  IN2 w0.254: v1(165.47,83.99) 165.7,83.99 165.92,83.76 165.92,82.8 165.59,82.47 165.59,70.52 161.13,66.06 83.62,66.06 78.68,61.12 75.87,61.12 74.59,59.84 74.04,59.84 73.66,60.22 68.41,60.22 v1(67.26,61.38)
  BOTTOM w0.102: v1(78.93,94.28) 78.55,93.9 78.55,93.13 77.52,92.11 76.48,92.11 75.49,91.11 75.49,82.11 69.8,76.42 69.8,70.95 67.59,68.74 67.59,61.71 v1(67.26,61.38)
  BOTTOM w0.254: UC1.AT15 v1(165.47,83.99)

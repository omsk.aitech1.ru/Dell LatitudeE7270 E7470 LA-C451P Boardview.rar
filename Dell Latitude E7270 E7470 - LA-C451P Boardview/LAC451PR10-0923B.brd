# Allegro board LAC451PR10-0923B.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
SW2_DP1_N1: length 74.9
  TOP w0.094: UV26.46 235.98,106.8 236.09,106.69 236.09,106.22 236.54,105.77 237.1,105.77 237.23,105.64 237.23,105.43 v1(237.06,105.26) ; v1(249.81,53.93) 250.01,53.73 250.01,53.3 CV152.1
  IN2 w0.122: v1(237.06,105.26) 237.24,105.07 237.24,104.61 238.56,103.29 242.24,103.29 250.18,95.35 250.18,89.75 249.67,89.24 249.67,87.35 250.18,86.84 250.18,82.67 249.55,82.04 245.74,82.04 244.11,80.41 244.11,73.97 243.7,73.56 243.7,72.98 244.1,72.58 244.1,65.08 245.06,64.11 245.06,58.97 245.37,58.66 245.37,57.73 244.42,56.77 244.42,55.3 245.15,54.57 246.84,54.57 247.18,54.91 249.39,54.91 249.98,54.31 249.98,54.11 v1(249.81,53.93)
SW2_DP1_N1_C: length 2.9
  TOP w0.094: CV152.2 250.01,51.67 250.01,51.18 v1(249.81,50.98)
  BOTTOM w0.094: JNGFF1.18 249.85,51.57 250.01,51.41 250.01,51.19 v1(249.81,50.98)
SW2_DP1_N2: length 87
  TOP w0.094: v1(235.15,105.91) 235.29,106.05 235.29,106.54 235.18,106.65 UV26.44
  IN2 w0.122: v1(235.15,105.91) 235.29,105.77 235.29,104.74 238.07,101.96 241.71,101.96 248.68,95 248.68,90.06 247.84,89.22 247.84,86.52 248.9,85.46 248.9,84.65 248.59,84.34 244.63,84.34 241.68,81.39 241.68,77.21 242.28,76.61 242.28,70.9 242.81,70.36 242.81,64.54 243.78,63.58 243.78,59.85 242.55,58.62 242.55,56.56 242.39,56.4 242.39,54.48 243.61,53.26 245.05,53.26 248.78,49.53 248.78,44.9 249.86,43.82 249.86,41.04 v1(249.68,40.87)
  BOTTOM w0.094: v1(249.68,40.87) 249.88,41.07 249.88,41.46 CV148.1
SW2_DP1_N2_C: length 2.4
  BOTTOM w0.094: CV148.2 249.88,43.08 249.88,43.34 249.76,43.46 249.76,43.82 249.6,43.98 JNGFF1.17
SW2_DP1_N3: length 87.6
  TOP w0.094: v1(233.89,105.82) 234.09,106.02 234.09,106.54 233.98,106.65 UV26.41
  IN2 w0.122: v1(233.89,105.82) 234.07,105.64 234.07,105.05 237.81,101.32 241.45,101.32 247.93,94.84 247.93,90.21 247.2,89.49 247.2,85.81 246.87,85.48 244.46,85.48 241.04,82.06 241.04,76.94 241.58,76.4 241.58,69.05 242.17,68.45 242.17,64.26 243.14,63.29 243.14,60.27 242.75,59.88 240.61,59.88 240.15,59.42 240.15,57.73 241.73,56.15 241.73,54.23 243.34,52.62 244.78,52.62 248.09,49.31 248.09,44.03 248.21,43.91 248.21,41.18 v1(247.9,40.87)
  BOTTOM w0.094: v1(247.9,40.87) 248.06,41.03 248.06,41.5 CV145.1
SW2_DP1_N3_C: length 2.4
  BOTTOM w0.094: JNGFF1.11 248.1,43.98 248.26,43.82 248.26,43.49 248.1,43.34 248.1,43.08 CV145.2
SW2_DP1_P0: length 73.2
  TOP w0.094: UV26.50 237.58,106.7 237.48,106.6 237.48,106.49 237.7,106.27 238.38,106.27 238.66,105.98 238.66,105.55 v1(238.87,105.35) ; CV157.1 251.82,53.45 v1(251.82,53.95)
  IN2 w0.122: v1(238.87,105.35) 238.71,105.19 238.71,104.57 239.13,104.15 242.66,104.15 251.04,95.76 251.04,82.14 249.67,80.77 245.75,80.77 244.97,80 244.97,74.29 245.27,73.99 245.27,71.55 244.97,71.24 244.97,70.63 245.45,70.16 245.45,64.98 245.92,64.5 245.92,59.38 246.3,59 246.3,57.34 245.92,56.96 245.92,56.36 246.36,55.91 250.07,55.91 251.6,54.39 251.6,54.16 v1(251.82,53.95)
SW2_DP1_P0_C: length 3.1
  TOP w0.094: CV157.2 251.67,51.38 251.67,51.1 v1(251.85,50.92)
  BOTTOM w0.094: JNGFF1.26 251.85,51.53 251.69,51.37 251.69,51.08 v1(251.85,50.92)
SW2_DP1_P1: length 74.9
  TOP w0.094: v1(250.39,53.93) 250.19,53.73 250.19,53.3 CV153.1 ; v1(237.64,105.26) 237.42,105.48 237.42,105.72 237.14,105.99 v5(236.87,105.99) 236.58,105.99 236.27,106.3 236.27,106.67 236.38,106.78 UV26.47
  IN2 w0.122: v1(237.64,105.26) 237.46,105.07 237.46,104.7 238.65,103.51 242.33,103.51 250.4,95.44 250.4,89.66 249.89,89.15 249.89,87.44 250.4,86.92 250.4,82.58 249.64,81.82 245.83,81.82 244.33,80.32 244.33,73.88 243.91,73.47 243.91,73.07 244.31,72.67 244.31,65.17 245.28,64.2 245.28,59.06 245.59,58.75 245.59,57.64 244.63,56.68 244.63,55.39 245.24,54.78 246.75,54.78 247.09,55.13 249.48,55.13 250.2,54.4 250.2,54.12 v1(250.39,53.93)
SW2_DP1_P1_C: length 2.9
  TOP w0.094: v1(250.39,50.98) 250.19,51.19 250.19,51.67 CV153.2
  BOTTOM w0.094: JNGFF1.20 250.35,51.53 250.19,51.37 250.19,51.19 v1(250.39,50.98)
SW2_DP1_P2: length 87.1
  TOP w0.094: UV26.45 235.58,106.64 235.47,106.54 235.47,106.18 v1(235.73,105.91)
  IN2 w0.122: v1(235.73,105.91) 235.51,105.69 235.51,104.83 238.16,102.18 241.8,102.18 248.89,95.09 248.89,89.97 248.06,89.13 248.06,86.61 249.12,85.55 249.12,84.56 248.68,84.12 244.72,84.12 241.9,81.3 241.9,77.3 242.49,76.7 242.49,70.99 243.03,70.45 243.03,64.63 243.99,63.67 243.99,59.76 242.77,58.54 242.77,56.47 242.61,56.31 242.61,54.57 243.7,53.48 245.14,53.48 248.99,49.62 248.99,44.99 250.07,43.91 250.07,41.06 v1(250.26,40.87)
  BOTTOM w0.094: CV147.1 250.06,41.46 250.06,41.07 v1(250.26,40.87)
SW2_DP1_P2_C: length 2.4
  BOTTOM w0.094: CV147.2 250.06,43.08 250.06,43.41 249.94,43.54 249.94,43.82 250.1,43.98 JNGFF1.19
SW2_DP1_P3: length 87.5
  TOP w0.094: UV26.42 234.38,106.64 234.27,106.54 234.27,106.02 v1(234.47,105.82)
  IN2 w0.122: v1(248.49,40.87) 248.42,40.93 248.42,44 248.31,44.12 248.31,49.4 244.87,52.84 243.43,52.84 241.95,54.32 241.95,56.24 240.37,57.82 240.37,59.33 240.7,59.66 242.83,59.66 243.35,60.18 243.35,63.38 242.38,64.35 242.38,68.54 241.79,69.13 241.79,76.49 241.25,77.03 241.25,81.97 244.55,85.26 246.96,85.26 247.41,85.72 247.41,89.4 248.14,90.13 248.14,94.93 241.54,101.53 237.9,101.53 234.29,105.14 234.29,105.64 v1(234.47,105.82)
  BOTTOM w0.094: CV146.1 248.25,41.43 248.25,41.11 v1(248.49,40.87)
SW2_DP1_P3_C: length 2.4
  BOTTOM w0.094: CV146.2 248.28,43.08 248.28,43.26 248.44,43.42 248.44,43.82 248.6,43.98 JNGFF1.13
SW2_DP2_AUXN: length 17.8
  TOP w0.094: CV111.1 219.9,106.76 220.01,106.65 220.01,106.41 v1(219.71,106.1) ; UV26.29 228.66,108.36 228.55,108.47 228.35,108.47 228.09,108.21 227.87,108.21 v1(227.67,108.01) 227.47,108.21 227.35,108.21 RV604.2
  IN2 w0.122: v1(227.67,108.01) 227.83,108.17 228.01,108.17 228.13,108.05 228.13,107.64 227.94,107.45 227.16,107.45 226.5,108.11 226.5,109.33 225.94,109.89 224.09,109.89 223.2,109 220.74,109 220.29,108.56 220.29,108.12 219.9,107.73 219.9,106.29 v1(219.71,106.1)
SW2_DP2_AUXN_C: length 7.5
  TOP w0.094: UV8.H2 217.61,112.89 217.61,111.76 218.25,111.13 v5(218.9,111.13) 219.57,111.13 219.8,110.9 219.8,109.71 219.77,109.67 219.77,109.09 219.8,109.05 219.8,107.93 CV111.2
SW2_DP2_AUXP: length 17.8
  TOP w0.094: CV110.1 220.2,106.52 220.2,106.2 v1(220.29,106.1) ; UV26.28 228.66,108.76 228.55,108.65 228.28,108.65 228.01,108.39 227.87,108.39 v1(227.67,108.59) 227.47,108.39 227.35,108.39 RV608.2
  IN2 w0.122: v1(227.67,108.59) 227.87,108.39 228.1,108.39 228.34,108.14 228.34,107.55 228.03,107.23 227.07,107.23 226.29,108.02 226.29,109.24 225.85,109.67 224.18,109.67 223.29,108.78 220.83,108.78 220.51,108.47 220.51,108.03 220.11,107.64 220.11,106.28 v1(220.29,106.1)
SW2_DP2_AUXP_C: length 7.4
  TOP w0.094: UV8.H1 217.79,112.43 217.79,111.84 218.32,111.31 218.63,111.31 218.64,111.32 219.16,111.32 219.17,111.31 219.65,111.31 219.99,110.97 v5(219.99,109.38) 219.99,107.51 220.06,107.44 220.2,107.44 CV110.2
SW2_DP2_CADET: length 6.6
  TOP w0.102: RV607.2 v2(227.91,105.04) 228.23,104.72 230.38,104.72 230.64,104.99 230.64,106.51 230.78,106.65 UV26.33
SW2_DP2_HPD: length 23.1
  TOP w0.089: UV8.J1 218.56,112.54 218.25,112.23 v1(218.25,112.2)
  TOP w0.102: UV26.38 v1(232.78,106.41)
  IN3 w0.102: v1(232.78,106.41) 231.83,107.36 230.17,107.36 229.92,107.62 229.92,112.38 229.58,112.72 225.79,112.72 225.36,112.29 225.36,111.86 224.71,111.21 219.24,111.21 v1(218.25,112.2)
  BOTTOM w0.102: v1(232.78,106.41) v2(232.78,106.92)
SW2_DP2_N0: length 22.8
  TOP w0.094: v1(218.36,108.5) 218.56,108.7 218.56,108.77 CV103.1 ; UV26.39 233.18,106.74 233.29,106.63 233.29,106.16 233.21,106.09 233.21,105.52 v1(233.01,105.32)
  IN2 w0.122: v1(233.01,105.32) 233.19,105.5 233.19,106.57 231.9,107.87 229.69,107.87 228.55,109.01 227.59,109.01 225.83,110.77 222.99,110.77 221.65,109.43 220.53,109.43 219.83,108.73 219.83,108.34 219.31,107.82 218.78,107.82 218.54,108.06 218.54,108.32 v1(218.36,108.5)
SW2_DP2_N0_C: length 4.1
  TOP w0.094: CV103.2 218.41,110.34 218.41,110.52 218.3,110.62 217.95,110.62 216.95,111.62 216.95,112.88 UV8.G2
SW2_DP2_N1: length 20.2
  TOP w0.094: CV105.1 217.24,106.41 217.24,106.3 v1(217.04,106.1) ; UV26.36 231.98,106.76 232.08,106.66 232.08,105.17 v1(231.9,105)
  IN2 w0.122: v1(217.04,106.1) 217.22,105.92 217.22,105.62 217.59,105.25 218.72,105.25 219.3,104.67 227.91,104.67 228.77,105.52 230.45,105.52 230.77,105.2 231.42,105.2 231.74,105.52 231.95,105.52 232.09,105.38 232.09,105.19 v1(231.9,105)
SW2_DP2_N1_C: length 6.1
  TOP w0.094: CV105.2 217.14,107.93 217.14,108.2 217.23,108.29 217.23,110.48 216.98,110.72 216.98,110.72 216.87,110.83 216.81,110.89 v5(216.68,111.03) 216.33,111.37 216.33,112.72 216.61,113 UV8.F2
SW2_DP2_N2: length 20.2
  TOP w0.094: UV26.34 231.18,106.76 231.3,106.64 231.3,106.57 v1(231.1,106.37) ; CV107.1 215.88,108.91 215.88,108.68 v1(215.68,108.48)
  IN2 w0.122: v1(231.1,106.37) 231.28,106.56 231.28,106.72 231.1,106.9 229.11,106.9 227.52,105.31 219.57,105.31 217.57,107.31 217.27,107.62 216.15,107.62 215.86,107.91 215.86,108.3 v1(215.68,108.48)
SW2_DP2_N2_C: length 3.4
  TOP w0.094: UV8.E2 215.67,112.9 215.67,111.46 215.87,111.26 215.87,110.34 CV107.2
SW2_DP2_N3: length 22.9
  TOP w0.094: UV26.31 229.98,106.73 230.08,106.63 230.08,106.47 229.8,106.19 229.8,105.32 v1(229.6,105.12) ; CV109.1 214.19,107.81 214.19,106.95 v1(214.01,106.76)
  IN2 w0.122: v1(214.01,106.76) 214.18,106.94 214.18,107.18 214.44,107.44 215.09,107.44 215.78,106.74 215.78,105.69 216.64,104.83 218.54,104.83 219.13,104.25 229.35,104.25 229.78,104.67 229.78,104.94 v1(229.6,105.12)
SW2_DP2_N3_C: length 4.8
  TOP w0.094: CV109.2 214.09,109.33 214.09,109.9 214.35,110.16 214.35,110.21 214.76,110.63 214.81,110.63 214.94,110.76 214.94,112.82 UV8.D2
SW2_DP2_P0: length 22.8
  TOP w0.094: CV102.1 218.74,108.88 218.74,108.7 v1(218.95,108.5) ; UV26.40 233.58,106.76 233.47,106.65 233.47,106.09 233.39,106.01 233.39,105.52 v1(233.59,105.32)
  IN2 w0.122: v1(233.59,105.32) 233.41,105.5 233.41,106.66 231.99,108.09 229.78,108.09 228.64,109.23 227.67,109.23 225.92,110.98 222.9,110.98 221.57,109.65 220.44,109.65 219.62,108.82 219.62,108.43 219.22,108.03 218.87,108.03 218.75,108.15 218.75,108.31 v1(218.95,108.5)
SW2_DP2_P0_C: length 4.1
  TOP w0.094: UV8.G1 217.24,112.54 217.13,112.44 217.13,111.69 218.02,110.8 218.38,110.8 218.59,110.59 218.59,109.91 218.67,109.84 218.79,109.84 CV102.2
SW2_DP2_P1: length 20.3
  TOP w0.094: v1(217.62,106.1) 217.42,106.3 217.42,106.41 CV104.1 ; v1(232.48,105) 232.26,105.22 232.26,106.64 232.38,106.76 UV26.37
  IN2 w0.122: v1(232.48,105) 232.31,105.18 232.31,105.47 232.04,105.74 231.65,105.74 231.33,105.42 230.86,105.42 230.54,105.74 228.68,105.74 227.82,104.89 219.39,104.89 218.81,105.47 217.68,105.47 217.43,105.71 217.43,105.91 v1(217.62,106.1)
SW2_DP2_P1_C: length 6.1
  TOP w0.094: UV8.F1 216.51,112.44 216.51,111.45 216.62,111.35 ; 216.83,111.15 217,110.98 217,110.96 217.41,110.55 217.41,108.22 217.32,108.12 217.32,107.51 217.4,107.44 217.54,107.44 CV104.2
  TOP w0.095: 216.62,111.35 216.63,111.35 216.83,111.15
SW2_DP2_P2: length 20.3
  TOP w0.094: v1(231.68,106.37) 231.48,106.57 231.48,106.66 231.58,106.76 UV26.35 ; v1(216.27,108.48) 216.07,108.68 216.07,108.74 CV106.1
  IN2 w0.122: v1(231.68,106.37) 231.5,106.56 231.5,106.81 231.19,107.12 229.02,107.12 227.43,105.53 219.66,105.53 217.36,107.83 216.24,107.83 216.08,108 216.08,108.29 v1(216.27,108.48)
SW2_DP2_P2_C: length 3.4
  TOP w0.094: CV106.2 216.25,109.84 216.13,109.84 216.05,109.91 216.05,111.34 215.85,111.54 215.85,112.43 UV8.E1
SW2_DP2_P3: length 22.9
  TOP w0.094: v1(214.59,106.76) 214.38,106.98 214.38,107.81 CV108.1 ; v1(230.18,105.12) 229.98,105.32 229.98,106.11 230.26,106.39 230.26,106.61 230.38,106.73 UV26.32
  IN2 w0.122: v1(214.59,106.76) 214.4,106.95 214.4,107.09 214.53,107.22 215,107.22 215.57,106.66 215.57,105.6 216.55,104.61 218.45,104.61 219.04,104.03 229.44,104.03 230,104.58 230,104.94 v1(230.18,105.12)
SW2_DP2_P3_C: length 4.7
  TOP w0.094: UV8.D1 215.25,112.54 215.13,112.43 215.13,111.48 215.12,111.48 215.12,110.68 v5(214.71,110.26) 214.27,109.83 214.27,108.91 214.36,108.82 214.48,108.82 CV108.2
SW2_PS8338_CFG0: length 5.6
  TOP w0.102: RV601.2 242.08,112.19 241.58,112.7 v2(239.77,112.7) 239.27,112.19 239.27,111.43 239,111.16 UV26.59
SW2_PS8338_P0: length 5
  TOP w0.102: UV26.60 238.91,111.56 239.06,111.72 239.06,112.49 239.7,113.13 v2(241.16,113.13) 241.89,113.13 RV615.2
SW2_PS8338_P1: length 3.3
  TOP w0.102: RV603.2 RV621.1 237.21,113.8 v2(237.58,113.43) UV26.1
SW2_PS8338_PC10: length 4.2
  TOP w0.102: UV26.56 239,109.96 239.38,110.35 240.79,110.35 RV620.1 RV614.2
SW2_PS8338_PC11: length 4.2
  TOP w0.102: RV613.2 RV619.1 240.79,110.14 239.67,110.14 v2(239.41,109.88) 239.09,109.56 UV26.55
SW2_PS8338_PC20: length 4.3
  TOP w0.102: UV26.54 239.14,109.16 239.94,108.37 240.79,108.37 RV618.1 RV612.2
SW2_PS8338_PC21: length 5.5
  TOP w0.102: UV26.53 239.25,108.76 239.85,108.16 240.79,108.16 RV617.1 RV611.2 242.08,107.48 v2(242.81,106.75)
SW2_PS8338_PEQ: length 12.8
  TOP w0.102: v1(236.78,117.02) 236.86,116.94 238.65,116.94 v2(240.87,114.72) RV616.1 RV610.2 ; UV26.8 v1(234.78,113.28)
  BOTTOM w0.102: v1(236.78,117.02) 234.78,115.02 v1(234.78,113.28)
SW2_PS8338_SW: length 3.7
  TOP w0.102: UV26.18 230.78,112.74 229.5,114.02 228.81,114.02 RV602.2
SW_1.2V: length 7.4
  TOP w0.102: v1(77.76,73.76) v2(78.29,73.76)
  IN1 w1.016: 78.01,72.93 78.01,72.23 75.03,69.25 75.03,67.34
  vias: v1(72.83,66.14) v1(72.83,65.5) v1(72.83,64.87) v1(72.83,64.23) v1(73.47,66.39) v1(73.47,65.76) v1(73.47,65.12) v1(73.47,64.49) v1(74.1,66.14) v1(74.1,65.5) v1(74.1,64.87) v1(74.1,64.23) v1(74.74,66.39) v1(74.74,65.76) v1(74.74,65.12) v1(74.74,64.49) v1(77.32,74.14)
SW_+1VALWP:
  vias: v1(225.78,87.28) v1(225.78,86.65) v1(226.41,87.28) v1(226.41,86.65) v1(227.05,87.28) v1(227.05,86.65) v1(227.68,87.28) v1(227.68,86.65) v2(226.93,86.01)
SW_LAN0_10_GRN#: length 35.8
  TOP w0.102: v1(255.93,108.26) 256.16,108.5 UL4.41 ; QL2.1 285.22,115.45 284.79,115.02 282.28,115.02 RL30.2 281.24,114.89 280.63,114.89 279.18,113.45 279.18,111.96 277.19,109.97 v2(272.54,109.97) 271.59,109.97 v1(270.18,108.56)
  IN3 w0.102: v1(255.93,108.26) 256.65,108.99 269.75,108.99 v1(270.18,108.56)
SW_LAN0_100_ORG#: length 33.5
  TOP w0.102: RL29.2 287.2,120.53 287.2,118.22 287.41,118 QL1.4 288.65,118 288.95,117.7 288.95,116.65 288.47,116.16 287.09,116.16 286.47,115.54 286.47,115.31 285.85,114.69 280.71,114.69 279.38,113.36 279.38,111.74 277.23,109.58 v2(274.58,109.58) 271.83,109.58 270.24,108 UL4.18
SW_LAN0_ACTLED_YEL#: length 38.1
  TOP w0.102: v1(288.49,120.02) 288.8,120.02 289.18,119.64 289.18,116.49 288.64,115.96 287.18,115.96 286.67,115.46 286.67,115.23 285.93,114.49 285.78,114.49 280.8,114.49 279.59,113.28 279.59,111.65 277.14,109.2 272.07,109.2 v2(271.19,108.33) 268.09,105.23 266.21,105.23 265.47,105.98 UL4.17 ; QL1.1 v1(285.92,120.02)
  BOTTOM w0.102: v1(288.49,120.02) 288.49,120.02 v1(285.92,120.02)
SW_LAN0_MDIN0: length 9.2
  TOP w0.089: UL4.25 263.97,111.05 264.07,111.15 264.07,111.6 v1(263.94,111.72)
  IN1 w0.084: v1(267.95,111.97) 267.87,111.88 267.87,111.26 267.17,110.56 264.27,110.56 263.94,110.89 v1(263.94,111.72)
  BOTTOM w0.089: TL1.11 268.28,112.62 268.17,112.51 268.17,112.32 267.95,112.1 v1(267.95,111.97)
SW_LAN0_MDIN1: length 19.6
  TOP w0.089: UL4.29 261.97,111.03 262.05,111.11 262.05,111.3 v1(261.93,111.42)
  IN1 w0.084: v1(261.93,111.42) 261.93,112.26 262.61,112.94 266.25,112.94 266.39,113.07 268.21,113.07 268.65,112.64 270.11,112.64 271.18,111.57 273.17,111.57 274.24,112.63 275.19,112.63 275.56,112.26 v1(275.56,111.78)
  BOTTOM w0.089: TL1.5 275.9,112.62 275.71,112.43 275.71,112.27 275.56,112.11 275.56,111.79 v1(275.56,111.78)
SW_LAN0_MDIN2: length 19.1
  TOP w0.089: UL4.34 259.47,111.04 259.55,111.12 259.55,111.56 v1(259.43,111.67)
  IN1 w0.084: v1(273.02,112.08) 273.02,112.68 272.08,113.62 269.06,113.62 268.6,114.08 265.98,114.08 265.82,113.91 261.22,113.91 259.43,112.13 v1(259.43,111.67)
  BOTTOM w0.089: v1(273.02,112.08) 273.02,112.22 273.21,112.4 273.21,112.47 273.36,112.63 TL1.7
SW_LAN0_MDIN3: length 30.4
  TOP w0.089: UL4.38 257.46,110.47 257.46,111.04 257.55,111.12 257.55,111.3 v1(257.43,111.42)
  IN1 w0.084: v1(280.63,111.53) 280.63,112.47 279.46,113.63 273.46,113.63 272.47,114.62 269.47,114.62 269.03,115.07 260.51,115.07 257.43,111.99 v1(257.43,111.42)
  BOTTOM w0.089: TL1.1 280.98,112.55 280.98,112.54 280.98,112.13 280.62,111.77 280.62,111.54 v1(280.63,111.53)
SW_LAN0_MDIP0: length 9.2
  TOP w0.089: v1(264.53,111.72) 264.38,111.58 264.38,111.13 264.47,111.05 UL4.24
  IN1 w0.084: v1(264.53,111.72) 264.39,111.72 264.32,111.65 264.32,111.05 264.43,110.94 267.01,110.94 267.49,111.42 267.49,111.85 v1(267.37,111.97)
  BOTTOM w0.089: TL1.12 267.01,112.63 267.1,112.54 267.36,112.54 267.56,112.75 267.74,112.75 267.85,112.63 267.85,112.45 v1(267.37,111.97)
SW_LAN0_MDIP1: length 19.7
  TOP w0.089: v1(262.51,111.42) 262.36,111.27 262.36,111.11 262.47,111.01 UL4.28
  IN1 w0.084: v1(274.98,111.78) 275.1,111.78 275.18,111.86 275.18,112.11 275.04,112.25 274.4,112.25 273.33,111.18 271.02,111.18 269.95,112.26 268.49,112.26 268.06,112.69 266.55,112.69 266.41,112.56 262.76,112.56 262.31,112.1 262.31,111.48 262.37,111.42 v1(262.51,111.42)
  BOTTOM w0.089: TL1.6 274.63,112.59 274.71,112.52 274.97,112.52 275.14,112.7 275.26,112.7 275.4,112.56 275.4,112.4 275.24,112.25 275.24,112 275.02,111.78 v1(274.98,111.78)
SW_LAN0_MDIP2: length 19.1
  TOP w0.089: UL4.33 259.97,111.02 259.86,111.12 259.86,111.53 v1(260.01,111.67)
  IN1 w0.084: v1(260.01,111.67) 259.89,111.67 259.81,111.76 259.81,111.97 261.38,113.53 265.97,113.53 266.14,113.7 268.45,113.7 268.91,113.24 271.93,113.24 272.64,112.53 272.64,112.29 v1(272.44,112.08)
  BOTTOM w0.089: v1(272.44,112.08) 272.89,112.53 272.89,112.66 272.77,112.78 272.63,112.78 272.43,112.58 272.18,112.58 272.09,112.67 TL1.8
SW_LAN0_MDIP3: length 30.4
  TOP w0.089: UL4.37 257.97,111.02 257.86,111.12 257.86,111.27 v1(258.01,111.42)
  IN1 w0.084: v1(280.05,111.53) 280.16,111.53 280.25,111.62 280.25,112.31 279.31,113.25 273.3,113.25 272.31,114.24 269.32,114.24 268.87,114.69 260.67,114.69 257.81,111.83 257.81,111.51 257.9,111.42 v1(258.01,111.42)
  BOTTOM w0.089: TL1.2 279.71,112.63 279.83,112.52 280.55,112.52 280.66,112.41 280.66,112.26 280.31,111.9 280.31,111.79 v1(280.05,111.53)
SW_LAN1_10_GRN#: length 145.7
  TOP w0.102: UL4.40 249.74,109 242.57,101.82 v2(242,101.82) 234.5,101.82 233.96,102.37 232.88,102.37 v1(232.47,101.96)
  IN2 w0.102: v1(199.17,101.57) 200.46,102.86 213.3,102.86 213.9,102.26 213.9,101.6 215.06,100.44 230.95,100.44 v1(232.47,101.96)
  BOTTOM w0.102: v1(199.17,101.57) 199.17,101.84 196.85,104.16 190.43,104.16 181.15,113.44 181.15,114.33 179.46,116.02 178.66,116.02 173.01,121.67 172.24,121.67 170.56,123.35 162.87,123.35 161.4,124.82 158.05,124.82 157.64,124.42 145.22,124.42 143.86,123.06 140.1,123.06 139.97,122.93 136.91,122.93 136.63,123.21 136.62,123.21 134.63,125.21 134.63,129.19 134.5,129.32 JDOCK1.3
SW_LAN1_100_ORG#: length 175.1
  TOP w0.102: UL4.20 268.92,109 269.35,109.43 v2(269.35,110.03) 269.35,111.53 265.21,115.67 v1(262.99,115.67)
  IN4 w0.102: v1(262.99,115.67) 259.97,115.67 258.86,116.77 258.86,125.43 252.9,131.39 244.78,131.39 244.08,130.69 224.85,130.69 223.23,129.08 205.53,129.08 202.58,126.13 192.58,126.13 189,129.71 182.94,129.71 180.62,132.03 180.62,138.89 179.89,139.62 171.97,139.62 168.57,136.22 138.65,136.22 136.91,137.96 133.49,137.96 v1(132.67,138.77)
  BOTTOM w0.102: v1(132.67,138.77) 132.67,139.85 133.14,140.32 134.54,140.32 134.8,140.06 134.8,139.8 134.5,139.51 JDOCK1.4
SW_LAN1_ACTLED_YEL#: length 137.5
  TOP w0.102: UL4.19 v1(266.84,108.5)
  IN2 w0.102: v1(160.51,140.29) 160.51,136.65 165.77,131.39 165.77,128.73 165.62,128.58 165.62,126.58 167.42,124.78 177.49,124.78 177.93,124.34 186.27,124.34 188.67,121.94 189.54,121.94 190,121.48 191.45,121.48 192.16,122.2 195.06,122.2 195.64,121.62 202.63,121.62 204.32,123.31 210.85,123.31 211.82,124.28 218.12,124.28 218.78,124.94 227.58,124.94 229.93,127.29 237.28,127.29 237.51,127.06 239.48,127.06 239.71,127.29 245.94,127.29 246.39,127.73 247.01,127.73 247.43,127.31 255.54,127.31 259.85,123 259.85,117.67 266.16,111.36 266.16,109.17 v1(266.84,108.5)
  BOTTOM w0.102: JDOCK1.100 160.5,140.28 v1(160.51,140.29)
SW_LAN1_MDIN0: length 136.8
  TOP w0.089: UL4.23 264.97,111.13 265.06,111.22 265.06,112.51 261.47,116.1 261.47,128.59 261.78,128.9 262.21,128.9 v1(262.25,128.95)
  IN2 w0.102: v1(262.25,128.95) 262.15,128.85 246.28,128.85 245.59,128.15 229.55,128.15 227.43,126.03 211.83,126.03 210.05,124.26 202.27,124.26 200.53,122.51 195.97,122.51 194.94,123.54 191.5,123.54 189.84,125.21 178.29,125.21 177.85,125.65 171.3,125.65 168.84,128.1 167.46,128.1 167.08,128.48 167.08,131.31 161.88,136.51 161.88,140.14 v1(162.04,140.3)
  BOTTOM w0.089: v1(162.04,140.3) 161.91,140.17 161.91,139.67 162,139.57 JDOCK1.106
SW_LAN1_MDIN1: length 135.1
  TOP w0.089: v1(262.24,130.14) 262.1,130.01 261.27,130.01 260.54,129.27 260.54,115.56 263.06,113.04 263.06,111.14 262.97,111.05 UL4.27
  IN2 w0.102: v1(163.54,140.3) 163.38,140.14 163.38,136.23 169.26,130.34 169.26,129.7 170.13,128.84 170.13,128.33 171.95,126.51 178.6,126.51 179.04,126.07 190.2,126.07 191.87,124.4 195.3,124.4 195.73,123.97 200.77,123.97 202.02,125.23 209.52,125.23 211.18,126.9 227.07,126.9 229.19,129.02 245.22,129.02 245.94,129.74 260.47,129.74 260.83,130.09 262.19,130.09 v1(262.24,130.14)
  BOTTOM w0.089: v1(163.54,140.3) 163.41,140.17 163.41,139.67 163.5,139.57 JDOCK1.112
SW_LAN1_MDIN2: length 128.8
  TOP w0.089: UL4.32 260.47,111.11 260.56,111.21 260.56,112.05 258.78,113.83 258.78,130.56 259.04,130.83 259.55,130.83 v1(259.56,130.84)
  IN2 w0.102: v1(166.54,140.3) 166.38,140.14 166.38,134.45 173.02,127.81 189.69,127.81 192.23,125.27 200.84,125.27 203.33,127.76 226.72,127.76 228.84,129.88 244.85,129.88 245.67,130.69 259.41,130.69 v1(259.56,130.84)
  BOTTOM w0.089: v1(166.54,140.3) 166.41,140.17 166.41,139.67 166.5,139.57 JDOCK1.124
SW_LAN1_MDIN3: length 126.7
  TOP w0.089: UL4.36 258.47,111.07 258.56,111.17 258.56,112.25 257.04,113.78 257.04,131.48 257.42,131.85 257.94,131.85 v1(257.99,131.9)
  IN2 w0.102: v1(168.04,140.3) 167.88,140.14 167.88,134.17 173.38,128.67 190.05,128.67 192.59,126.13 200.48,126.13 203.06,128.71 211.03,128.71 211.17,128.85 223.5,128.85 225.4,130.74 244.49,130.74 245.3,131.56 256.97,131.56 257.2,131.78 257.87,131.78 v1(257.99,131.9)
  BOTTOM w0.089: JDOCK1.130 168,139.57 167.91,139.67 167.91,140.17 v1(168.04,140.3)
SW_LAN1_MDIP0: length 136.8
  TOP w0.089: UL4.22 265.47,111.1 265.38,111.18 265.38,112.64 261.79,116.23 261.79,128.46 261.91,128.59 262.03,128.59 v1(262.25,128.36)
  IN2 w0.102: v1(161.46,140.3) 161.62,140.14 161.62,136.4 166.82,131.2 166.82,128.37 167.35,127.85 168.74,127.85 171.19,125.39 177.74,125.39 178.18,124.95 189.73,124.95 191.4,123.28 194.84,123.28 195.86,122.26 200.63,122.26 202.37,124 210.16,124 211.94,125.78 227.54,125.78 229.66,127.9 245.69,127.9 246.39,128.6 262.02,128.6 v1(262.25,128.36)
  BOTTOM w0.089: JDOCK1.104 161.5,139.58 161.59,139.67 161.59,140.17 161.52,140.24 v1(161.46,140.3)
SW_LAN1_MDIP1: length 135.1
  TOP w0.089: v1(262.24,129.56) 262.11,129.69 261.4,129.69 260.86,129.14 v5(260.86,125.22) 260.86,115.69 263.38,113.17 263.38,111.14 263.47,111.05 UL4.26
  IN2 w0.102: v1(262.24,129.56) 261.96,129.84 260.94,129.84 260.58,129.49 246.05,129.49 245.32,128.76 229.3,128.76 227.18,126.64 211.29,126.64 209.62,124.98 202.13,124.98 200.87,123.72 195.62,123.72 195.2,124.15 191.77,124.15 190.1,125.81 178.94,125.81 178.5,126.26 171.84,126.26 169.87,128.22 169.87,128.73 169.01,129.6 169.01,130.24 163.12,136.12 163.12,140.14 v1(162.96,140.3)
  BOTTOM w0.089: JDOCK1.110 163,139.58 163.09,139.67 163.09,140.17 163.02,140.24 v1(162.96,140.3)
SW_LAN1_MDIP2: length 128.8
  TOP w0.089: UL4.31 260.97,111.12 260.88,111.21 260.88,112.18 259.1,113.96 259.1,130.43 259.17,130.51 259.31,130.51 v1(259.56,130.26)
  IN2 w0.102: v1(165.96,140.3) 166.12,140.14 166.12,134.34 172.92,127.55 189.58,127.55 192.12,125.01 200.94,125.01 203.44,127.51 226.82,127.51 228.94,129.62 244.96,129.62 245.77,130.44 259.38,130.44 v1(259.56,130.26)
  BOTTOM w0.089: v1(165.96,140.3) 166.02,140.24 166.09,140.17 166.09,139.67 166,139.58 JDOCK1.122
SW_LAN1_MDIP3: length 126.7
  TOP w0.089: v1(257.99,131.31) 257.76,131.54 257.55,131.54 257.36,131.35 257.36,113.91 258.88,112.39 258.88,111.17 258.97,111.08 UL4.35
  IN2 w0.102: v1(257.99,131.31) 257.77,131.53 257.3,131.53 257.07,131.3 245.4,131.3 244.59,130.49 225.5,130.49 223.61,128.6 211.27,128.6 211.13,128.46 203.16,128.46 200.58,125.88 192.48,125.88 189.94,128.42 173.27,128.42 167.62,134.07 167.62,140.14 v1(167.46,140.3)
  BOTTOM w0.089: v1(167.46,140.3) 167.52,140.24 167.59,140.17 167.59,139.67 167.5,139.58 JDOCK1.128
SW_USB20_N1: length 6.6
  TOP w0.094: UI3.11 279.48,102.14 279.64,101.98 279.98,101.98 280.32,101.65 280.37,101.65 280.78,101.23 280.78,101.18 281.25,100.71 v5(282.43,100.71) 283.38,100.71 284.01,100.08 284.17,100.08 284.38,100.3 LI7.1
SW_USB20_P1: length 6.6
  TOP w0.094: LI7.4 284.4,99.7 284.19,99.9 283.93,99.9 283.31,100.53 282.76,100.53 282.73,100.49 282.14,100.49 282.1,100.53 281.18,100.53 v5(280.42,101.28) 280.19,101.52 279.91,101.8 279.61,101.8 279.45,101.64 UI3.10
SYS_LED_MASK#: length 221.7
  TOP w0.102: QZ3.2 280.49,17.56 v1(280.72,17.33) 280.72,15.82 280.57,15.67 UZ10.1 ; v1(224.8,57.6) 224.8,58.49 RE21.2 ; QL2.2 286.52,116.1 286.79,116.37 288.07,116.37 v1(288.47,116.76) ; QL1.2 v1(286.59,118.65) ; UE1.B48 v1(229.26,64.48) ; QL1.5 v1(288.47,118.65)
  IN2 w0.102: v1(288.47,118.65) v1(288.47,116.76) 287.46,115.76 286.38,115.76 282.15,111.53 281.47,111.53 280.12,110.18 280.12,102.84 278.19,100.91 277.56,100.91 275.64,98.98 275.64,97.74 278.27,95.11 278.27,93.28 279.36,92.19 279.36,88.88 277.81,87.33 277.81,75.38 276.5,74.08 275.32,74.08 273.17,71.93 273.17,61.11 271.89,59.82 271.89,58.5 271.36,57.97 271.36,52.85 271.09,52.59 271.09,48.28 271.47,47.9 271.47,42.6 276.2,37.88 276.2,31.34 278.31,29.23 278.31,21.95 279.71,20.54 279.71,18.33 v1(280.72,17.33) ; v1(229.26,64.48) 224.8,60.02 v1(224.8,57.6)
  IN4 w0.102: v1(224.8,57.6) 224.8,57.24 226.05,55.99 228.48,55.99 229.27,55.2 239.52,55.2 241.75,52.98 251.34,52.98 252.84,51.48 252.84,50.72 254.2,49.36 254.96,49.36 256.92,47.41 256.92,45.87 257.15,45.64 263.18,45.64 263.87,44.95 266.71,44.95 270.4,41.27 272.67,41.27 275.88,38.06 275.88,23.83 280.31,19.39 280.31,17.74 v1(280.72,17.33)
  BOTTOM w0.102: v1(286.59,118.65) v1(288.47,118.65)
SYS_RESET#: length 83.2
  TOP w0.102: JAPS1.13 189.56,66.27 193.15,69.87 193.15,72.58 194.76,74.19 197.46,74.19 200.9,77.63 200.9,78.29 202.02,79.41 202.02,84.29 200.58,85.73 200.58,87.15 199.48,88.25 196.67,88.25 195.53,89.39 195.53,93.68 194.9,94.31 194.9,97.21 193.15,98.97 193.15,100.63 v1(191.68,102.1) ; v1(173.49,104.19) v2(174.37,104.19) 175.66,104.19 v1(175.73,104.25)
  IN3 w0.102: v1(191.68,102.1) 185.86,107.92 181.65,107.92 180.02,106.29 177.77,106.29 v1(175.73,104.25)
  BOTTOM w0.076: v1(173.49,104.19) 173.49,103.11 173.28,102.89 172.14,102.89 UC1.B5
  BOTTOM w0.102: v1(175.73,104.25) 175.73,104.39 CC302.1 178.09,106.75 178.09,107.6 177.65,108.05 RC291.2 RC224.2
SYS_RESET#_R: length 3.4
  BOTTOM w0.102: UC12.4 178.55,109.22 RC224.1 RC290.2 v2(180.39,109.2)
TDI_XDP: length 15.9
  TOP w0.102: v1(139.47,120.49) 138.47,120.49 v2(138.15,120.18)
  IN3 w0.102: v1(131.8,118.42) 132,118.63 132,119.47 134.24,121.7 136.29,121.7 137.18,120.81 139.15,120.81 v1(139.47,120.49)
  BOTTOM w0.102: RC229.1 139.39,120.49 v1(139.47,120.49) 139.67,120.3 UC8.5 ; v1(131.8,118.42) 132,118.62 132,119.16 131.89,119.27 JXDP1.56
TDO_XDP: length 17.9
  TOP w0.102: v2(138.15,118.6) 139.06,118.6 v1(139.51,118.16)
  IN2 w0.102: v1(139.51,118.16) 137.84,119.82 133.69,119.82 133.27,119.4 131.16,119.4 130.97,119.21 130.97,119.01 v1(130.39,118.42)
  BOTTOM w0.102: JXDP1.52 130.89,118.97 130.78,118.87 130.78,118.04 CC306.1 130.39,117.83 v1(130.39,118.42) ; RC230.1 139.41,118.06 v1(139.51,118.16) 140.15,118.8 UC8.2
THERMATRIP2#: length 6.5
  TOP w0.102: UE2.B34 258.37,62.07 258.59,61.84 v2(258.59,60.27) 258.3,59.97 CE36.1 RE69.2 257.72,57.83 QE4.1
THERMATRIP3#: length 14
  TOP w0.102: RE301.1 256.66,74.51 v1(256.77,74.41) ; UE2.A2 248.54,70.29 248.04,70.79 248.04,71.09 247.95,71.18 v2(247.95,72.14) 247.95,73.27 248.26,73.58 v1(248.63,73.58)
  IN4 w0.084: v1(248.63,73.58) 248.73,73.68 254.27,73.68 255.54,74.95 256.22,74.95 v1(256.77,74.41)
THSEL_STRAP: length 13.1
  TOP w0.102: v1(255.42,63.66) 255.87,63.21 UE2.B29 ; v1(254.53,56.7) 255.14,56.7 RE78.1
  BOTTOM w0.102: v1(255.42,63.66) 255.21,63.66 254.99,63.43 254.99,62.56 255.94,61.6 256.77,61.6 257.13,61.24 257.13,59.52 255.78,58.17 254.92,58.17 254.53,57.78 v1(254.53,56.7)
TOUCH_SCREEN_DET#: length 208
  IN1 w0.102: v1(63.89,62.53) 63.89,58.48 v1(64,58.37)
  IN2 w0.102: v1(177.03,79.58) 172.95,79.58 171.96,80.58 169.78,80.58 169,79.79 169,78.5 170.34,77.16 170.34,71.38 170.57,71.14 170.57,68.63 164.68,62.73 99.73,62.73 99.32,63.14 93.53,63.14 91.41,61.03 84.79,61.03 79.76,56 77.64,56 77.5,55.86 71.75,55.86 70.55,57.05 68.35,57.05 68.22,56.92 65.42,56.92 64,58.34 v1(64,58.37)
  IN4 w0.102: v1(90.59,99.41) 90.14,98.97 83.39,98.97 80.35,95.93 80.35,94.31 76.96,90.92 76.96,84.65 69.3,76.99 69.3,74.51 63.33,68.54 63.33,63.09 v1(63.89,62.53)
  BOTTOM w0.076: v1(177.03,79.58) 176.51,80.1 173,80.1 172.65,80.45 172.65,80.66 172.41,80.9 172.01,80.9 171.86,81.05 171.86,81.5 171.42,81.93 UC1.AY5
  BOTTOM w0.102: JEDP1.32 93.29,104.64 93.29,104.25 95.15,102.4 RV623.2 93.49,101.38 92.07,99.96 91.13,99.96 v1(90.59,99.41)
TOUCH_SCREEN_PD#: length 113.1
  TOP w0.102: v1(175.61,110.15) v2(176.18,110.15)
  IN3 w0.102: v1(175.61,110.15) 175.61,109.77 175.94,109.44 179.87,109.44 180.77,110.35 180.77,114.09 178.17,116.7 170.88,116.7 165.59,121.99 163,121.99 162.02,121.01 158.79,121.01 155.46,124.34 136.97,124.34 135.14,122.51 133.9,122.51 131.95,120.57 122.08,120.57 116.47,114.96 107.58,114.96 106.54,113.91 102.08,113.91 v1(101.2,114.79)
  BOTTOM w0.076: UC1.A7 170.55,104.42 170.99,104.86 173.61,104.86 174.79,106.05
  BOTTOM w0.102: v1(101.2,114.79) 101.2,115.6 JEDP1.5 ; v1(175.61,110.15) 174.65,109.19 174.65,108.12 174.86,107.91 175.41,107.91 175.49,107.83 RPC5.7 175.49,106.74 174.79,106.05
TOUCHPAD_INTR#: length 167.3
  TOP w0.102: v1(217.85,67.05) 218.06,67.05 v2(218.5,66.61)
  IN2 w0.102: v1(187.14,77.28) 187.09,77.22 187.09,71.51 192.64,65.97 213.82,65.97 214.34,66.49 217.38,66.49 217.85,66.96 v1(217.85,67.05)
  IN4 w0.102: v1(217.85,67.05) 218.08,67.05 221.03,64.1 221.03,63.57 227.36,57.25 228.96,57.25 229.78,56.43 238.17,56.43 238.55,56.81 239.98,56.81 240.38,56.41 241.37,56.41 241.99,55.79 244.19,55.79 245.14,54.83 246.75,54.83 247.8,55.89 253.49,55.89 256.82,52.56 266.97,52.56 269.27,50.26 v1(270.71,50.26)
  BOTTOM w0.076: 178.49,78.47 178.41,78.47 178.1,78.77 177.28,78.77 176.16,79.89 172.59,79.89 171.94,80.54 171.94,80.63 171.47,81.1 UC1.BA5
  BOTTOM w0.102: v1(270.71,50.26) 270.74,50.24 270.99,50.24 275.38,45.85 275.38,24.99 276.54,23.83 277.14,23.83 278.27,22.7 278.27,20.94 275.59,18.27 275.59,11.91 276.23,11.27 JKBTP1.16 ; v1(187.14,77.28) 186.37,78.05 184.3,78.05 184.13,77.89 183.15,77.89 182.13,78.9 181.74,78.9 181.48,79.16 179.11,79.16 178.64,78.69 RC272.2 178.49,78.47
TP_LAN_JTAG_TCK: length 3.2
  TOP w0.102: UL1.35 256.55,92.09 256.39,91.92 256.39,91.46 255.64,90.71 RL2.2
TP_LAN_JTAG_TDI: length 1.8
  TOP w0.102: T88.1 256.33,93.11 256.54,93.11 256.71,93.29 UL1.32
TP_LAN_JTAG_TDO: length 2.3
  TOP w0.102: T89.1 256.18,91.7 256.18,92.18 256.49,92.49 UL1.34
TP_LAN_JTAG_TMS: length 3.2
  TOP w0.102: UL1.33 256.6,92.89 255.98,92.27 255.98,91.88 255.7,91.6 RL1.2
TPM_GPIO4: length 1.6
  TOP w0.102: UZ12.13 215.49,73.43 RZ110.2
TPM_LPM#: length 13.4
  TOP w0.102: UZ12.3 220.18,69.51 221.5,70.84 221.5,71.7 221.32,71.88 221.32,73.74 v2(221.79,74.21) 221.79,75.88 RZ111.1 221.28,76.97 219.83,78.42 QZ9.1
TPM_PIRQ#: length 67.1
  TOP w0.102: v1(195.72,95.55) 196.48,94.79 v2(196.48,94.36) 196.48,90.42 197.01,89.89 197.83,89.89 198.06,90.12 199.49,90.12 201.27,88.34 201.72,88.34 203.95,86.11 203.95,82.16 203.5,81.72 203.5,76.43 205.33,74.61 206.82,74.61 208.12,75.9 210.11,75.9 210.96,76.75 211.68,76.75 212.32,76.12 RZ69.2 212.79,74.95 212.79,72.91 212.58,72.7 212.58,71.66 212.73,71.51 UZ12.18
  IN3 w0.102: v1(195.72,95.55) 195.26,95.55 193.82,94.1 192.22,94.1 191.69,94.64 190.23,94.64 189.54,95.32 184.78,95.32 183.8,96.3 182.09,96.3 181.25,97.14 180.41,97.14 179.4,96.12 177.75,96.12 177.31,96.55 175,96.55 v1(174.88,96.68)
  BOTTOM w0.076: v1(174.88,96.68) 174.31,96.12 173.59,96.12 173.44,96.28 173.44,96.55 172.94,97.05 UC1.M3
TPM_TYPE: length 23.1
  IN4 w0.076: v1(170.1,83.22) 170.1,82.33 171.35,81.09 176.03,81.09
  IN4 w0.102: v1(188.01,78.67) 187.93,78.75 183.05,78.75 182.64,79.16 181.96,79.16 180.03,81.09 176.03,81.09
  BOTTOM w0.076: UC1.AY7 170.31,82.09 170.03,82.37 170.03,82.69 170.1,82.76 v1(170.1,83.22)
  BOTTOM w0.102: RC349.1 187.89,78.56 v1(188.01,78.67) v2(188.01,79.19)
TRST#_XDP: length 21.3
  TOP w0.102: v2(131.09,118.96) 131.12,118.99 v1(131.57,118.99)
  IN3 w0.102: v1(131.57,118.99) 131.57,119.32 134.15,121.9 136.37,121.9 137.24,121.04 139.44,121.04 139.65,121.24 144.66,121.24 144.93,120.98 144.93,118.99 v1(144.73,118.8)
  BOTTOM w0.102: JXDP1.54 131.39,119.18 v1(131.57,118.99) ; UC8.12 144.23,119.3 v1(144.73,118.8)
UART0_TXD: length 94.8
  TOP w0.102: RE306.1 239.32,58.44 238.65,58.44 v1(238.65,58.44)
  IN1 w0.102: v1(189.11,85.42) 186.83,85.42 186.23,86.01 184.91,86.01 184.73,86.19 184.35,86.19 183.93,86.61 v1(183.93,86.62)
  IN2 w0.102: v1(207.64,70.27) 206.66,70.27 206.05,70.87 193.54,70.87 192.83,71.57 192.83,72.44 193.37,72.98 193.94,72.98 195.67,74.7 195.67,77.95 195.86,78.14 195.86,78.98 195.32,79.51 194.52,79.51 193.72,80.31 193.72,81.89 192.04,83.57 190.47,83.57 189.11,84.94 v1(189.11,85.42)
  IN3 w0.102: v1(238.65,58.44) 238.28,58.07 231.41,58.07 228.01,61.47 224.47,61.47 222.24,63.7 219.71,63.7 219.47,63.94 215.03,63.94 212.17,66.8 209.51,66.8 207.64,68.67 v1(207.64,70.27)
  BOTTOM w0.076: 178.51,91.93 178.38,91.93 177.84,91.39 177.23,91.39 177.09,91.52 174.57,91.52 174.5,91.46 174.05,91.46 173.85,91.51 173.83,91.52 173.64,91.52 UC1.AB2
  BOTTOM w0.102: 178.51,91.93 180.69,91.93 181.01,91.61 181.01,90.72 181.94,89.8 181.94,89.42 182.69,88.67 183.59,88.67 183.93,88.32 v1(183.93,86.62) 183.93,86.52 v2(183.51,86.1)
UART2_RXD: length 7.4
  BOTTOM w0.102: UC1.AD1 174.61,90.42 175.05,90.86 175.97,90.86 176.79,90.04 179.11,90.04 RC330.2 180.34,90.46 v2(180.64,90.76)
UART2_TXD: length 5.9
  BOTTOM w0.076: v2(176.46,90.97) 176.36,91.07 174.89,91.07 174.56,90.74 173.74,90.74 UC1.AD2
  BOTTOM w0.102: v2(176.46,90.97) 176.46,90.9 177.04,90.33 178.5,90.33 RC331.2
UIM_CLK: length 44.2
  IN2 w0.122: v1(270.22,96.31) 270.39,96.48 270.9,96.48 271.35,96.93 271.35,103.97 271.92,104.53 271.92,107.51 271.35,108.08 271.35,110.41 270.88,110.88 270.88,112.59 272.16,113.87 281.67,113.87 285.08,117.28 286.42,117.28 v1(286.59,117.12)
  BOTTOM w0.102: v1(270.22,96.31) 270.4,96.49 271.81,96.49 271.94,96.35 JNGFF2.24 ; CZ66.1 284.92,117.27 286.36,117.27 286.59,117.04 v1(286.59,117.12) 286.76,117.29 289.73,117.29 JSIM1.3
UIM_DATA: length 59.3
  TOP w0.102: v2(271.54,97.39) 271.04,96.89 v1(270.22,96.89)
  IN2 w0.122: v1(286.59,117.7) 286.42,117.53 284.98,117.53 281.57,114.12 272.06,114.12 270.63,112.7 270.63,110.78 271.1,110.31 271.1,107.97 271.67,107.41 271.67,104.63 271.1,104.07 271.1,97.04 270.79,96.72 270.39,96.72 v1(270.22,96.89)
  BOTTOM w0.102: JSIM1.7 291.51,116.94 290.81,117.64 289.74,117.64 289.62,117.52 286.76,117.52 v1(286.59,117.7) 286.38,117.5 284.92,117.5 CZ65.1 ; v1(270.22,96.89) 270.4,96.71 271.79,96.71 271.93,96.85 JNGFF2.26
UIM_RESET: length 47.1
  IN2 w0.122: v1(270.6,95.85) 270.98,95.85 271.86,96.72 271.86,103.55 272.43,104.12 272.43,110.05 271.39,111.09 271.39,112.39 272.37,113.37 281.88,113.37 284.77,116.25 287.21,116.25 287.91,116.95 287.91,118.86 288.49,119.44 v1(288.77,119.44)
  BOTTOM w0.102: CZ67.1 285.94,119.41 285.96,119.44 v1(288.77,119.44) 288.81,119.48 JSIM1.2 ; v1(270.6,95.85) JNGFF2.22
USB2_ID: length 2
  TOP w0.102: v1(172.54,89.51) 172.79,89.26 173.64,89.26 RC337.1
  BOTTOM w0.076: UC1.AG3 172.77,89.28 v1(172.54,89.51)
USB2_VBUSSENSE: length 2.2
  TOP w0.102: v1(171.7,89.44) v2(172.06,89.8) 172.39,90.13 RC338.1
  BOTTOM w0.076: v1(171.7,89.44) 172.05,89.09 UC1.AG4
USB3_PRX_DTX_N1: length 133.4
  IN4 w0.076: v1(169.13,98.82) 169.28,98.98 169.55,98.98 169.76,99.19 169.76,100.39 170.47,101.1 170.49,101.1
  IN4 w0.102: v4(283.29,99.91) 283.97,99.91 284.22,99.65 284.22,98.69 282.95,97.42 282.95,95.59 282.14,94.78 277.65,94.78 277.18,95.25 273.06,95.25 271.96,94.15 264.24,94.15 261.89,96.51 257.75,96.51 254.82,99.44 241.51,99.44 239.71,101.24 236.97,101.24 235.24,102.97 229.57,102.97 227.27,100.67 220.43,100.67 219.39,99.63 209.19,99.63 207.14,101.68 204.91,101.68 203.12,103.47 191.32,103.47 188.17,100.33 187.07,100.33 185.91,99.17 180.33,99.17 180.07,99.43 179.36,99.43 178.3,100.49 175.54,100.49 175.01,99.96 173.73,99.96 172.92,100.77 171.73,100.77 171.4,101.1 170.49,101.1
  BOTTOM w0.076: v1(169.13,98.82) 169.3,98.82 UC1.H8
  BOTTOM w0.094: v4(283.29,99.91) 283.54,99.66 283.79,99.66 RI16.1
USB3_PRX_DTX_N2: length 53.4
  TOP w0.094: v4(155.39,140.26) 155.45,140.21 155.45,135.17 v4(155.39,135.12)
  IN2 w0.122: v4(170.05,98.18) 169.57,98.65 169.57,99.79 169.52,99.84 169.52,104.49 171.05,106.03 171.05,107.2 170.48,107.77 170.48,109.44 166.57,113.36 165.31,113.36 159.61,119.06 159.61,121.18 154.58,126.22 154.58,130.31 155.39,131.12 v4(155.39,135.12)
  BOTTOM w0.076: v4(170.05,98.18) 170.3,98.18 170.5,97.97 UC1.J6
  BOTTOM w0.094: JDOCK1.84 155.5,139.44 155.62,139.56 155.62,140.03 v4(155.39,140.26)
USB3_PRX_DTX_N3: length 129.5
  TOP w0.094: v4(64.65,121.75) 64.88,121.98 64.88,122.44 RI20.1
  IN1 w0.076: 166.4,102.43 166.41,102.43 166.42,102.43 166.47,102.38 166.48,102.38 167.59,101.28 167.59,98.58 167.82,98.35 168.14,98.35 168.21,98.28 v4(168.21,98.16) ; 166.25,102.59 166.28,102.55
  IN1 w0.102: 166.25,102.59 166.22,102.62 166.22,102.63 164.36,104.49 164.36,106.18 162.95,107.59 162.95,109.11 160.49,111.57 159.45,111.57 155.63,115.39 150.97,115.39 149.01,117.35 149.01,120.81 147.23,122.59 146.01,122.59 145.46,123.15 140.5,123.15 140.13,123.51 140.13,123.55 139.54,124.14 136.19,124.14 135.41,123.36 132.3,123.36 131.86,122.92 125.57,122.92 125.14,122.49 119.77,122.49 116.32,119.03 109.97,119.03 109.67,119.33 93.92,119.33 93.19,118.6 90.17,118.6 89.75,118.18 87.12,118.18 85.75,119.55 81.52,119.55 78.55,116.58 73.82,116.58 73.3,117.1 67.45,117.1 65.29,119.26 65.29,120.55 64.7,121.13 64.7,121.7 v4(64.65,121.75) ; 166.28,102.55 166.4,102.43
  BOTTOM w0.076: v4(168.21,98.16) 168.49,97.89 UC1.J10
USB3_PRX_DTX_N4: length 102.2
  TOP w0.094: RI24.1 90.11,122.41 90.11,120.81 v4(89.86,120.56)
  IN1 w0.076: v1(168.21,100.75) 168.21,100.53 168.29,100.45 168.5,100.45 168.63,100.58 168.63,101.16 167.93,101.87 167.91,101.87 167.89,101.88
  IN1 w0.102: 167.89,101.88 165.02,104.75 165.02,106.44 164.36,107.1 164.36,109.21 163.76,109.82 163.13,109.82 160.57,112.37 159.66,112.37 157.66,114.37 157.66,117.88 157.25,118.28 157.25,120.07 154.25,123.07 151.79,123.07 150.95,122.22 149.36,122.22 148.33,123.25 146.42,123.25 145.53,124.14 140.44,124.14 139.81,124.76 135.91,124.76 135.13,123.98 132.04,123.98 131.6,123.54 125.3,123.54 124.87,123.11 119.5,123.11 116.05,119.66 110.22,119.66 109.93,119.95 93.55,119.95 92.85,119.25 90.73,119.25 90.26,119.72 90.26,120.16 v4(89.86,120.56)
  BOTTOM w0.076: UC1.E10 168.47,100.49 v1(168.21,100.75)
USB3_PRX_DTX_N5: length 124.2
  TOP w0.094: v4(276.31,94.62) 276.14,94.62 276.04,94.72 276.04,94.83 275.95,94.93 275.95,95.24 276.22,95.51 276.58,95.51 v5(276.59,95.51) 276.59,95.51 277.28,95.51 RI28.1
  IN4 w0.102: v4(166.38,98.83) 166.61,99.06 166.76,99.06 166.87,98.95 166.87,98.62 166.62,98.38 166.62,97.89 167,97.51 171.41,97.51 172.1,98.19 175.76,98.19 175.98,97.97 179.37,97.97 179.96,98.55 187.34,98.55 188.39,99.6 190.64,99.6 193.14,102.1 203.62,102.1 204.65,101.07 206.88,101.07 208.93,99.01 219.99,99.01 220.96,99.99 227.46,99.99 229.82,102.35 234.98,102.35 236.72,100.62 239.45,100.62 241.25,98.82 254.45,98.82 257.38,95.89 261.63,95.89 263.99,93.53 275.9,93.53 276.26,93.9 276.26,94.57 v4(276.31,94.62)
  BOTTOM w0.076: v4(166.38,98.83) 166.84,98.56 UC1.H13
USB3_PRX_DTX_P1: length 133.3
  IN4 w0.076: 170.49,101.31 170.42,101.31 169.57,100.47 169.57,99.27 169.47,99.17 169.36,99.17 169.11,99.42 v1(169.11,99.52)
  IN4 w0.102: v4(283.29,99.22) 283.51,99.22 283.55,99.26 283.55,99.56 283.69,99.69 283.88,99.69 284.01,99.56 284.01,98.78 282.74,97.5 282.74,95.67 282.05,94.99 277.74,94.99 277.27,95.46 272.97,95.46 271.88,94.37 264.33,94.37 261.97,96.72 257.84,96.72 254.91,99.65 241.59,99.65 239.8,101.45 237.06,101.45 235.33,103.19 229.48,103.19 227.18,100.88 220.34,100.88 219.3,99.85 209.28,99.85 207.23,101.9 205,101.9 203.21,103.69 191.23,103.69 188.08,100.54 186.98,100.54 185.82,99.39 180.41,99.39 180.16,99.64 179.45,99.64 178.38,100.7 175.45,100.7 174.92,100.17 173.82,100.17 173.01,100.99 171.82,100.99 171.49,101.31 170.49,101.31
  BOTTOM w0.076: v1(169.11,99.52) 169.44,99.19 UC1.G8
  BOTTOM w0.094: v4(283.29,99.22) 283.54,99.47 283.74,99.47 RI15.1
USB3_PRX_DTX_P2: length 53.3
  TOP w0.094: v4(156.08,140.26) 156.01,140.26 155.63,139.88 155.63,135.53 155.85,135.31 156.03,135.12 v4(156.08,135.12)
  IN2 w0.122: v4(156.08,135.12) 155.86,134.9 155.8,134.9 155.61,134.71 155.61,131.03 154.79,130.22 154.79,126.31 159.83,121.27 159.83,119.15 165.4,113.57 166.66,113.57 170.7,109.53 170.7,107.86 171.27,107.29 171.27,105.94 169.73,104.4 169.73,99.93 169.78,99.88 169.78,99.1 v4(170.02,98.86)
  BOTTOM w0.076: v4(170.02,98.86) 170.34,98.54 UC1.H6
  BOTTOM w0.094: v4(156.08,140.26) 156.03,140.26 155.81,140.03 155.81,139.59 156,139.4 JDOCK1.86
USB3_PRX_DTX_P3: length 129.4
  TOP w0.094: v4(65.34,121.75) 65.29,121.75 65.06,121.98 65.06,122.39 RI19.1
  IN1 w0.076: 166.55,102.59 167.78,101.36 167.78,98.66 167.9,98.54 168,98.54 168.22,98.76 168.22,98.81 v4(168.21,98.83)
  IN1 w0.102: 166.55,102.59 166.43,102.71 166.43,102.72 164.57,104.58 164.57,106.27 163.17,107.68 163.17,109.2 160.58,111.78 159.54,111.78 155.72,115.6 151.05,115.6 149.22,117.44 149.22,120.9 147.32,122.8 146.1,122.8 145.54,123.36 140.58,123.36 140.35,123.6 140.35,123.64 139.63,124.35 136.1,124.35 135.32,123.57 132.21,123.57 131.77,123.13 125.48,123.13 125.05,122.7 119.68,122.7 116.23,119.25 110.06,119.25 109.76,119.54 93.83,119.54 93.1,118.82 90.08,118.82 89.66,118.4 87.21,118.4 85.84,119.77 81.43,119.77 78.46,116.8 73.91,116.8 73.39,117.32 67.54,117.32 65.5,119.35 65.5,120.64 64.92,121.22 64.92,121.41 65.26,121.75 v4(65.34,121.75)
  BOTTOM w0.076: UC1.H10 168.5,98.54 v4(168.21,98.83)
USB3_PRX_DTX_P4: length 102.2
  TOP w0.094: RI23.1 90.3,122.41 90.3,120.81 v4(90.55,120.56)
  IN1 w0.076: v1(168.21,100.08) 168.39,100.26 168.58,100.26 168.82,100.5 168.82,101.24 168.06,102 168.06,102.02 168.05,102.03
  IN1 w0.102: v4(90.55,120.56) 90.47,120.48 90.47,119.81 90.82,119.46 92.76,119.46 93.46,120.16 110.02,120.16 110.31,119.87 115.96,119.87 119.41,123.32 124.78,123.32 125.21,123.75 131.52,123.75 131.96,124.19 135.04,124.19 135.82,124.97 139.9,124.97 140.52,124.35 145.62,124.35 146.51,123.46 148.42,123.46 149.45,122.44 150.86,122.44 151.71,123.28 154.34,123.28 157.47,120.16 157.47,118.37 157.87,117.97 157.87,114.46 159.75,112.58 160.66,112.58 163.21,110.03 163.85,110.03 164.58,109.3 164.58,107.18 165.23,106.53 165.23,104.84 168.05,102.03
  BOTTOM w0.076: v1(168.21,100.08) 168.45,99.84 UC1.F10
USB3_PRX_DTX_P5: length 124.3
  TOP w0.094: RI27.1 277.28,95.69 276.92,95.69 276.88,95.73 276.29,95.73 276.25,95.69 276.15,95.69 275.77,95.31 275.77,94.76 v4(275.62,94.62)
  IN4 w0.102: v4(166.38,99.54) 166.65,99.27 166.85,99.27 167.08,99.04 167.08,98.54 166.84,98.29 166.84,97.97 167.09,97.72 171.32,97.72 172.01,98.41 175.84,98.41 176.07,98.18 179.28,98.18 179.87,98.77 187.25,98.77 188.3,99.82 190.55,99.82 193.05,102.31 203.7,102.31 204.74,101.28 206.97,101.28 209.02,99.23 219.9,99.23 220.88,100.2 227.37,100.2 229.74,102.57 235.07,102.57 236.8,100.83 239.54,100.83 241.34,99.03 254.54,99.03 257.47,96.1 261.72,96.1 264.07,93.75 275.81,93.75 276.05,93.98 276.05,94.27 275.7,94.62 v4(275.62,94.62)
  BOTTOM w0.076: UC1.G13 v4(166.38,99.54)
USB3_PRX_L_DTX_N1: length 10.2
  BOTTOM w0.094: RI16.2 285.39,99.63 285.55,99.63 285.76,99.42 285.88,99.42 286.04,99.59 DI4.9 DI4.1 287.52,99.59 287.67,99.43 287.92,99.43 288.18,99.69 v5(288.18,100.88) 288.18,101.48 288.4,101.7 288.73,101.7 289.61,100.82 290.85,100.82 291.12,101.09 291.42,101.09 291.59,101.27 JUSB3.5
USB3_PRX_L_DTX_N3: length 9
  TOP w0.094: RI20.2 64.91,124.04 64.91,124.23 65.17,124.49 65.17,124.63 65.01,124.8 DI1.1 DI1.9 65.01,126.54 65.17,126.7 v5(65.17,127.26) 65.17,128.07 65.49,128.39 65.49,128.44 65.85,128.8 65.85,129.45 65.14,130.16 65.14,130.73 65.01,130.87 JUSB1.5
USB3_PRX_L_DTX_N4: length 9.3
  TOP w0.094: RI24.2 90.11,124.03 90.11,124.35 90.31,124.56 90.31,124.79 90.16,124.95 DI6.1 DI6.9 90.16,126.54 90.32,126.7 90.32,127.11 89.9,127.53 89.9,127.58 v5(89.16,128.32) 88.88,128.6 88.88,129.47 88.16,130.2 88.16,130.78 88.06,130.87 JUSB2.5
USB3_PRX_L_DTX_N5: length 5.5
  TOP w0.094: v4(281.87,95.47) 281.63,95.71 281.25,95.71 281.09,95.55 DI7.1 DI7.9 279.59,95.55 279.44,95.71 279.34,95.71 279.23,95.6 278.99,95.6 RI28.2
  BOTTOM w0.094: JNGFF2.21 281.11,95.6 281.23,95.72 281.62,95.72 v4(281.87,95.47)
USB3_PRX_L_DTX_P1: length 10.3
  BOTTOM w0.094: RI15.2 285.39,99.45 285.48,99.45 285.68,99.24 285.88,99.24 286.04,99.09 DI4.8 DI4.2 287.53,99.09 287.69,99.24 288.04,99.24 v5(288.19,99.39) 288.36,99.56 288.36,100.55 288.4,100.59 288.4,101.18 288.36,101.21 288.36,101.41 288.48,101.52 288.66,101.52 289.54,100.64 290.93,100.64 291.2,100.91 291.41,100.91 291.59,100.73 JUSB3.6
USB3_PRX_L_DTX_P3: length 9
  TOP w0.094: JUSB1.6 65.47,130.87 65.33,130.73 65.33,130.23 66.03,129.53 66.03,128.67 v5(65.85,128.49) 65.35,128 65.35,127.59 65.39,127.56 65.39,126.97 65.35,126.93 65.35,126.7 65.51,126.54 DI1.8 DI1.2 65.51,124.79 65.36,124.64 65.36,124.42 65.09,124.15 65.09,124.03 RI19.2
USB3_PRX_L_DTX_P4: length 9.3
  TOP w0.094: JUSB2.6 88.44,130.87 88.34,130.78 88.34,130.27 89.07,129.55 89.07,128.72 89.53,128.26 89.53,128.21 v5(90.26,127.47) 90.5,127.24 90.5,126.7 90.66,126.54 DI6.8 DI6.2 90.66,124.96 90.5,124.8 90.5,124.48 90.29,124.28 90.29,124.04 RI23.2
USB3_PRX_L_DTX_P5: length 5.5
  TOP w0.094: v1(281.87,96.15) 281.61,95.9 281.22,95.9 281.07,96.05 DI7.2 DI7.8 279.57,96.05 279.41,95.89 279.27,95.89 279.16,95.78 278.8,95.78 RI27.2
  BOTTOM w0.094: JNGFF2.23 281.06,96.1 281.25,95.9 281.62,95.9 v1(281.87,96.15)
USB3_PTX_C_DRX_N1: length 3.2
  BOTTOM w0.094: RI18.1 283.87,97.96 283.3,97.96 282.96,97.62 v5(282.96,97.06) 282.96,96.33 CI13.1
USB3_PTX_C_DRX_N3: length 0.9
  TOP w0.094: RI22.1 CI5.1
USB3_PTX_C_DRX_N4: length 1.5
  TOP w0.094: RI26.1 91.89,122.41 91.89,121.88 CI27.1
USB3_PTX_C_DRX_N5: length 1.6
  TOP w0.094: RI30.1 277.25,97.32 276.7,97.32 CI29.1
USB3_PTX_C_DRX_P1: length 3.2
  BOTTOM w0.094: RI17.1 284.12,97.63 283.98,97.77 283.37,97.77 283.14,97.54 283.14,97.39 283.18,97.36 283.18,96.75 283.14,96.72 283.14,96.36 CI16.1
USB3_PTX_C_DRX_P3: length 0.9
  TOP w0.094: RI21.1 CI4.1
USB3_PTX_C_DRX_P4: length 1.5
  TOP w0.094: CI28.1 92.08,121.87 92.08,122.42 RI25.1
USB3_PTX_C_DRX_P5: length 1.6
  TOP w0.094: RI29.1 277.31,97.51 276.64,97.51 CI30.1
USB3_PTX_DRX_N1: length 142.2
  IN4 w0.102: v4(282.75,94.02) 283.22,94.5 283.22,95.12 283.36,95.25 283.36,97.25 284.63,98.52 284.63,100.06 283.44,101.25 283.44,103.18 282.31,104.31 279.97,104.31 279.46,104.82 274.99,104.82 274.53,104.36 243.58,104.36 239.83,108.11 238.3,108.11 237.29,109.13 229.63,109.13 227.92,107.42 226.87,107.42 226.13,106.68 226.13,105.89 225.7,105.46 219.47,105.46 218.4,106.53 216.18,106.53 215.57,105.92 211.2,105.92 210.74,105.46 206.39,105.46 204.17,107.68 189.03,107.68 188.53,107.17 187.2,107.17 185.83,108.53 181.84,108.53 179.45,106.14 170.54,106.14 169.94,106.74 169.69,106.74 v4(169.34,106.39)
  BOTTOM w0.076: v4(169.34,106.39) 169.34,106.4 169.09,106.65 168.85,106.65 168.25,106.05 168.25,104.44 167.33,103.53 166.79,103.53 166.69,103.43 166.69,103.4 166.68,103.39 166.68,103.1 166.73,102.99 166.73,102.84 166.68,102.65 166.68,102.47 166.72,102.35 166.85,102.22 167.07,102.22 167.31,101.99 167.31,101.82 167.21,101.72 167.04,101.72 166.94,101.82 UC1.C13
  BOTTOM w0.094: CI13.2 282.95,94.75 282.95,94.23 v4(282.75,94.02)
USB3_PTX_DRX_N2: length 53.1
  TOP w0.094: v4(156.89,140.28) 157.26,139.91 157.26,134.9 156.53,134.17 154.65,134.17 154.54,134.28 154.54,134.46 v4(154.77,134.69)
  IN2 w0.122: v4(169.07,105.04) 169.33,105.29 169.58,105.29 170.03,105.74 170.03,109.13 167.22,111.93 165.62,111.93 158.71,118.85 158.71,121.48 154.15,126.04 154.15,131.03 154.43,131.31 154.43,134.35 v4(154.77,134.69)
  BOTTOM w0.076: UC1.B13 166.94,102.68 167.07,102.8 167.34,102.8 167.65,103.11 167.65,103.36 168.58,104.29 168.58,105.19 168.68,105.3 168.82,105.3 169.07,105.04 v4(169.07,105.04)
  BOTTOM w0.094: JDOCK1.90 157,139.5 157.16,139.66 157.16,140.01 v4(156.89,140.28)
USB3_PTX_DRX_N3: length 127.5
  TOP w0.094: v4(66.18,120.19) 66.43,119.94 66.56,119.94 66.79,120.17 66.79,120.91 66.71,120.99 CI5.2
  IN1 w0.102: v4(66.18,120.19) 66.23,120.14 67.8,120.14 69.66,118.28 71.11,118.28 71.4,118.57 73.86,118.57 77.3,122.01 82.16,122.01 83.57,120.61 86.26,120.61 86.78,120.08 88.2,120.08 89.51,121.4 112.44,121.4 114.74,123.69 115.77,123.69 117.91,125.83 131.92,125.83 132.28,125.47 134.53,125.47 135.27,126.21 140.44,126.21 141.06,125.59 146.33,125.59 147.2,124.73 154.65,124.73 158.71,120.67 158.71,118.93 159.18,118.46 159.18,115.82 163.73,111.27 164.96,111.27 166.55,109.69 166.55,106.15 166.71,105.99 167.12,105.99 167.31,106.18 v4(167.31,106.29)
  BOTTOM w0.076: v4(167.31,106.29) 167.26,106.23 166.41,106.23 165.28,105.1 165.28,103.09 165.59,102.78 UC1.B15
USB3_PTX_DRX_N4: length 96.9
  TOP w0.094: CI27.2 91.89,120.25 91.89,120.12 91.69,119.92 v4(91.64,119.92)
  IN1 w0.102: v4(166.63,105.09) 166.58,105.04 166.05,105.04 165.85,105.24 165.85,106.92 165.27,107.51 165.27,109.54 164.16,110.65 163.47,110.65 160.92,113.2 160,113.2 158.51,114.7 158.51,118.23 158.09,118.65 158.09,120.41 154.39,124.11 146.87,124.11 146,124.97 140.79,124.97 140.17,125.59 135.55,125.59 134.78,124.82 132.06,124.82 131.66,125.21 119.3,125.21 115.83,121.75 113.67,121.75 112.7,120.78 91.94,120.78 91.69,120.53 91.69,119.97 v4(91.64,119.92)
  BOTTOM w0.076: v4(166.63,105.09) 166.37,104.83 166.13,104.83 165.88,104.58 165.88,103.14 165.8,102.99 165.8,102.84 165.86,102.65 165.86,102.47 165.8,102.28 165.73,102.22 165.47,102.22 165.39,102.14 165.39,102.03 165.51,101.91 UC1.C15

# Allegro board LAC451PR10-0923B.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
+1.0V_MPHYGT on BOTTOM (solid shape): 169.58,115.92 169.58,115.48 169.7,115.36 173.04,115.36 173.11,115.3 173.11,114.43 174.34,113.19 174.34,111.77 174.06,111.49 173.31,111.49 173.13,111.31 172.19,111.31 172.16,111.31 172.11,111.31 172.08,111.31 171.99,111.31 171.89,111.42 171.89,111.48 170.97,112.39 170.97,113.05 170.93,113.09 171.23,113.09 171.23,113.04 171.25,112.98 171.27,112.93 171.29,112.89 171.33,112.85 171.36,112.81 171.41,112.78 171.46,112.76 171.51,112.74 171.56,112.73 171.61,112.73 171.67,112.74 171.72,112.76 171.77,112.78 171.81,112.81 171.85,112.85 171.88,112.89 171.91,112.93 171.93,112.98 171.94,113.04 171.94,113.09 171.94,113.14 171.93,113.19 171.91,113.24 171.88,113.29 171.85,113.33 171.81,113.37 171.77,113.4 171.72,113.42 171.67,113.44 171.61,113.45 171.56,113.45 171.51,113.44 171.46,113.42 171.41,113.4 171.36,113.37 171.33,113.33 171.29,113.29 171.27,113.24 171.25,113.19 171.23,113.14 171.23,113.09 170.93,113.09 170.64,113.38 168.25,113.38 167.93,113.7 167.93,115.92 168.12,116.11 169.39,116.11
+1.0V_MPHYGT on IN1 (solid shape): outline of 1249 points within 164.77,94.76 176.69,108.2
+1.0V_MPHYGT on IN2 (solid shape): outline of 1501 points within 164.69,95.16 175.14,113.43
+1.0V_PRIM on TOP (solid shape): 133.02,128.2 133.02,127.17 132.95,127.11 132.26,127.11 132.17,127.2 132.17,128.19 132.34,128.37 132.85,128.37
+1.0V_PRIM on TOP (solid shape): 194.01,95.86 194.01,93.44 193.56,92.99 192.11,92.99 191.95,93.15 191.95,93.99 191.27,94.66 191.27,95.35 191.39,95.46 191.9,95.46 192.23,95.79 192.23,95.79 192.38,95.94 193.92,95.94
+1.0V_PRIM on TOP (solid shape): 117.93,128.39 117.93,125.99 117.89,125.95 116.33,125.95 116.28,126 116.28,127.15 116.1,127.33 114.78,127.33 114.22,126.77 114.22,124.25 114.02,124.05 113.47,124.05 113.33,124.19 113.33,127.34 114.48,128.49 117.83,128.49
+1.0V_PRIM on TOP (solid shape): 169.38,119.39 169.38,118.61 169.9,118.61 169.9,118.11 169.38,118.11 169.38,117.41 169.9,117.41 169.9,116.92 169.38,116.92 169.38,116.06 171.04,114.4 171.33,114.4 171.59,114.14 171.59,113.45 171.54,113.44 171.25,113.2 171.34,112.84 171.59,112.59 171.59,112.34 171.35,112.1 170.39,112.1 170,112.49 170,112.57 170.05,112.66 170.15,112.66 170.63,113.14 169.96,113.02 169.96,112.98 169.24,112.98 169.12,113.1 169.11,113.1 169.04,113.2 168.95,113.27 168.94,113.27 168.63,113.59 168.63,115.01 168.06,115.58 166.02,115.58 165.76,115.31 165.76,114.49 165.92,114.32 165.95,114.29 165.98,114.26 166.44,113.8 166.44,113.25 166.38,113.19 165.66,113.19 165.51,113.34 165.29,113.34 164.5,114.13 164.5,119.35 164.79,119.64 169.14,119.64
+1.0V_PRIM on BOTTOM (solid shape): 226.86,95.09 226.86,93.57 226.6,93.32 225.84,93.32 225.84,93.84 225.11,93.84 225.11,93.32 224.67,93.32 224.67,93.84 223.93,93.84 223.93,93.32 222.86,93.32 222.73,93.45 222.73,95.19 222.89,95.35 226.6,95.35
+1.0V_PRIM on BOTTOM (solid shape): outline of 89 points within 158.38,111.54 170.34,120.05
+1.0V_PRIM on IN2 (solid shape): outline of 1819 points within 160.24,72.35 165.12,88.76
+1.0V_PRIM on IN3 (solid shape): outline of 2128 points within 160.06,82.53 193.77,100.55
+1.0V_PRIM on VCC: 193.75,86.78 182.2,98.33 174.49,98.33 173.71,97.55 173.71,90.31 172.59,89.19 162.53,89.19 162.53,102.14 161.01,103.67 161.01,105.14 161.72,105.86 161.72,107.91 157.71,111.92 157.71,113.57 163.42,119.29 179.95,119.29 203.19,96.05 225.16,96.05 226.29,94.92 226.29,89.8 223.26,86.78
+1.0V_PRIM_CORE on TOP (solid shape): 193.93,92.24 193.93,90.6 193.66,90.33 190.52,90.33 190.28,90.57 190.28,92.24 190.41,92.36 193.8,92.36
+1.0V_PRIM_CORE on TOP (solid shape): 234.6,93.79 234.6,91.49 234.09,91.49 234.09,90.99 234.6,90.99 234.6,90.69 234.09,90.69 234.09,90.19 234.6,90.19 234.6,89.44 234.41,89.25 232.83,89.25 232.09,89.99 232.09,93.54 232.5,93.95 234.44,93.95
+1.0V_PRIM_CORE on TOP (solid shape): outline of 141 points within 159.54,106.4 165.95,109.61
+1.0V_PRIM_CORE on BOTTOM (solid shape): 163.93,90.71 163.93,90.53 164.19,90.28 164.19,90.1 163.95,89.86 163.95,89.75 163.87,89.65 163.82,89.61 163.78,89.58 163.55,89.58 163.51,89.62 163.47,89.64 163.15,89.96 163.15,90.51 163.44,90.81 163.51,90.85 163.56,90.9 163.75,90.9
+1.0V_PRIM_CORE on IN1 (solid shape): outline of 1448 points within 190.22,90.43 234.74,106.3
+1.0V_PRIM_CORE on IN2 (solid shape): outline of 477 points within 158.91,93.05 161.93,108.7
+1.0V_PRIM_CORE on IN3 (solid shape): 192.06,107.23 192.06,105.84 191.89,105.67 190.95,105.67 190.8,105.83 190.8,107.12 191.06,107.37 191.92,107.37
+1.0V_PRIM_CORE on IN3 (solid shape): 167.38,110 167.38,108.14 167.26,108.02 165.58,108.02 165.49,108.11 165.49,109.03 165.95,109.49 166.69,110.23 167.14,110.23
+1.0V_PRIM_CORE on IN3 (solid shape): outline of 2323 points within 161.18,83.99 193.99,94.22
+1.0V_PRIM_COREP on TOP (solid shape): 236.76,90.97 238.99,90.97 239.68,90.27 239.68,88.55 239.62,88.49 238.99,88.49 238.61,88.87 236.89,88.87 236.12,88.1 235.11,88.1 234.74,88.47 234.74,90.29 234.73,90.29 234.73,90.31 234.26,90.31 234.21,90.35 234.21,90.57 234.73,90.57 234.73,90.59 234.74,90.59 234.74,91.09 234.73,91.09 234.73,91.11 234.21,91.11 234.21,91.37 234.73,91.37 234.73,91.39 234.74,91.39 234.74,91.95 234.9,92.11 235.62,92.11
+1.0V_RUN_VMM on BOTTOM (solid shape): outline of 588 points within 218.94,102.65 227.72,117.51
+1.0V_SRAM on TOP (solid shape): 176.42,111.75 177.42,111.75 177.49,111.67 177.49,110.95 177.42,110.88 175.82,110.88 175.65,111.05 175.65,111.93 175.8,112.09 176.08,112.09
+1.0V_SRAM on IN2 (solid shape): outline of 1620 points within 162.12,89.96 177.82,112.1
+1.0V_VCCST on TOP (solid shape): 122.26,130.44 122.26,130.42 122.27,130.42 122.34,130.36 122.94,130.36 123.12,130.18 123.12,128.46 123.03,128.37 122.72,128.37 122.26,128.82 122.26,128.93 122.08,129.57 121.77,128.99 121.78,128.88 121.69,128.82 120.55,128.82 119.91,129.46 119.91,129.8 120.45,129.8 120.45,130.24 119.91,130.24 119.91,130.54 120,130.63 122.07,130.63
+1.0V_VCCST on BOTTOM (solid shape): 134.12,109.69 136.14,109.69 136.34,109.89 136.91,109.89 136.99,109.8 138.17,109.8 138.33,109.65 138.33,109.08 138.26,109.01 137.65,109.01 137.54,109.13 137.54,109.42 137.46,109.5 136.7,109.5 136.62,109.41 136.62,108.85 136.53,108.77 135.84,108.77 135.78,108.83 135.78,109.16 135.71,109.23 134.9,109.23 134.86,109.19 134.86,108.71 134.63,108.48 132.39,108.48 132.27,108.61 132.27,108.95 132.53,109.2 132.57,109.2 132.99,109.62 132.99,109.7 133.35,110.05 133.75,110.05
+1.0V_VCCST on BOTTOM (solid shape): 161.67,111 161.67,109.99 162.81,108.85 163.62,108.85 163.77,108.69 164.09,108.69 164.24,108.85 165,108.85 165.38,108.47 165.38,108.09 165.48,107.97 165.58,107.88 165.58,107.39 165.5,107.32 165.5,106.56 164.69,105.75 164.25,105.75 164.1,105.89 164.1,106.4 164.17,106.47 164.68,106.47 164.82,106.61 164.82,107.37 164.72,107.46 164.43,107.46 163.95,107.94 163.65,107.94 163.45,107.73 163.45,107.57 163.27,107.4 162.6,107.4 160.55,109.44 160.55,110.99 160.7,111.14 161.53,111.14
+1.0V_VCCST on IN2 (solid shape): 150.66,124.18 150.66,123.08 150.21,122.64 149.77,122.64 149.62,122.79 149.62,124.07 149.86,124.32 150.52,124.32
+1.0V_VCCST on IN2 (solid shape): 124.25,128.01 124.25,127.11 124.04,126.89 123.61,126.89 123.31,127.19 123.31,127.78 123.09,128.01 122.69,128.01 122.51,128.19 122.51,128.74 122.72,128.95 123.32,128.95
+1.0V_VCCST on IN2 (solid shape): 164.06,103.99 164.06,102.65 163.29,101.89 163.29,100.84 163.28,100.73 163.29,100.63 163.29,100.62 163.29,100.2 163.28,100.09 163.29,100 163.29,99.99 163.29,98.16 162.83,97.7 162.19,97.7 162.02,97.53 162.02,97.32 161.83,97.13 161.62,97.13 161.48,97.27 161.48,97.47 161.64,97.63 161.64,98.14 162.15,98.65 162.15,99.34 162.23,99.42 162.33,99.45 162.4,99.37 162.43,99.29 162.48,99.22 162.51,99.15 162.48,99.08 162.72,98.52 162.97,99.08 162.94,99.15 162.97,99.22 163.04,99.55 162.78,99.77 162.78,103.03 163.42,103.67 163.42,104 163.51,104.09 163.95,104.09
+1.0V_VCCST on IN3 (solid shape): outline of 271 points within 161.06,96.88 163.99,104.09
+1.0V_VCCST_C on TOP (solid shape): 119.76,130.57 119.76,127.9 119.74,127.88 119.72,127.84 119.7,127.8 119.69,127.77 118.6,126.69 118.33,126.69 118.22,126.8 118.22,128.47 117.01,129.68 118.08,129.68 118.08,129.62 118.09,129.57 118.11,129.52 118.13,129.48 118.16,129.44 118.2,129.4 118.24,129.37 118.29,129.34 118.33,129.33 118.39,129.32 118.44,129.32 118.49,129.33 118.54,129.34 118.59,129.37 118.63,129.4 118.66,129.44 118.69,129.48 118.72,129.52 118.73,129.57 118.74,129.62 118.74,129.68 118.73,129.73 118.72,129.78 118.69,129.82 118.66,129.87 118.63,129.9 118.59,129.93 118.54,129.96 118.49,129.97 118.44,129.98 118.39,129.98 118.33,129.97 118.29,129.96 118.24,129.93 118.2,129.9 118.16,129.87 118.13,129.82 118.11,129.78 118.09,129.73 118.08,129.68 117.01,129.68 117,129.69 117,130.41 117.1,130.51 117.6,130.51 117.86,130.77 119.56,130.77
+1.0V_VCCSTG on BOTTOM (solid shape): 158.86,112.63 158.86,112.63 159.33,112.63 159.34,112.63 159.34,113.18 161.2,113.18 161.52,112.87 161.52,111.74 161.26,111.49 157.64,111.49 157.47,111.66 157.47,113.01 157.64,113.18 158.86,113.18
+1.0V_VCCSTG_C on BOTTOM (solid shape): 160.39,115.85 160.39,113.97 160.34,113.96 160.07,113.77 160.11,113.43 160.14,113.4 160.07,113.32 159.2,113.32 159.2,112.78 159.19,112.77 159.02,112.77 159.02,113.32 157.55,113.32 157.47,113.41 157.47,115.89 157.62,116.05 160.18,116.05
+1.0V_VMM_VDD on BOTTOM (solid shape): outline of 536 points within 212.2,108.81 218.77,118.36
+1.0V_VMM_VDD on IN1 (solid shape): outline of 1571 points within 213.21,110.14 221.02,121.32
+1.0V_VMM_VDDTX on BOTTOM (solid shape): 218.46,113.77 218.5,113.77 218.52,113.75 218.54,113.73 218.55,113.71 218.56,113.68 218.54,113.62 218.53,113.57 218.53,113.51 218.54,113.46 218.55,113.41 218.57,113.36 218.59,113.32 218.63,113.27 218.67,113.24 218.71,113.21 218.76,113.19 218.81,113.17 218.86,113.16 218.89,113.16 219.11,113.16 219.23,113.04 219.23,111.08 219.12,110.97 219.03,110.97 218.81,110.75 218.81,109.95 218.71,109.85 217.91,109.85 217.72,110.05 217.72,112.23 217.92,112.23 217.92,112.17 217.92,112.12 217.94,112.07 217.96,112.03 218,111.99 218.03,111.95 218.07,111.92 218.12,111.89 218.17,111.88 218.22,111.87 218.27,111.87 218.32,111.88 218.37,111.89 218.42,111.92 218.46,111.95 218.5,111.99 218.53,112.03 218.55,112.07 218.57,112.12 218.58,112.17 218.58,112.23 218.57,112.28 218.55,112.33 218.53,112.37 218.5,112.42 218.46,112.45 218.42,112.48 218.37,112.51 218.32,112.52 218.27,112.53 218.22,112.53 218.17,112.52 218.12,112.51 218.07,112.48 218.03,112.45 218,112.42 217.96,112.37 217.94,112.33 217.92,112.28 217.92,112.23 217.72,112.23 217.72,112.82 218.03,113.14 218.04,113.16 218.04,113.65 218.16,113.77
+1.0V_VMM_VDDTX on IN3 (solid shape): outline of 1369 points within 212.57,112.56 219.97,121.32
+1.0VS_VCCIO on TOP (solid shape): 149.77,89.51 149.77,87.24 149.98,87.03 150.68,87.03 150.71,86.99 150.71,86.81 150.73,86.79 150.93,86.79 151.08,86.64 151.08,86.43 150.98,86.33 149.77,86.33 149.2,86.9 148.5,86.9 148.24,87.16 148.24,89.51 148.31,89.57 149.71,89.57
+1.0VS_VCCIO on TOP (solid shape): 239.01,55.09 239.01,54.28 239.34,53.95 239.34,53.33 239.06,53.05 238.39,53.05 238.39,53.57 238.37,53.57 238.37,53.57 237.86,53.57 237.86,53.57 237.84,53.57 237.84,53.05 237.59,53.05 237.59,53.57 237.57,53.57 237.57,53.57 237.06,53.57 237.06,53.57 237.04,53.57 237.04,53.05 236.14,53.05 235.68,53.51 235.68,54.9 236.07,55.28 238.82,55.28
+1.0VS_VCCIO on TOP (solid shape): outline of 114 points within 155.31,86.15 158.79,89.08
+1.0VS_VCCIO on BOTTOM (solid shape): 225.65,121.04 225.65,119.6 225.84,119.41 226.98,119.41 227.05,119.35 227.05,117.83 226.98,117.76 224.57,117.76 223.96,117.15 223.96,114 223.24,113.28 222.05,113.28 221.87,113.46 221.87,114.44 222.29,114.86 222.29,118.08 223.75,119.54 223.75,121.1 224.18,121.53 225.16,121.53
+1.0VS_VCCIO on BOTTOM (solid shape): outline of 917 points within 236.07,53.88 244.87,76.88
+1.0VS_VCCIO on IN1 (solid shape): 151.32,88.32 151.39,88.29 151.42,88.21 151.75,87.88 152.08,88.21 152.11,88.29 152.18,88.32 152.23,88.32 152.31,88.29 152.33,88.21 152.67,87.88 153,88.21 153.03,88.29 153.1,88.32 153.15,88.32 153.22,88.29 153.25,88.21 153.58,87.88 153.91,88.21 153.94,88.29 154.01,88.32 154.06,88.32 154.13,88.29 154.16,88.21 154.49,87.88 154.83,88.21 154.85,88.29 154.93,88.32 154.98,88.32 155.05,88.29 155.08,88.21 155.41,87.88 155.74,88.21 155.77,88.29 155.84,88.32 155.9,88.32 155.98,88.28 156,88.19 156.32,87.78 156.65,88.19 156.66,88.28 156.74,88.32 157.37,88.32 157.54,88.15 157.54,86.41 157.38,86.25 154.87,86.25 154.79,86.3 154.79,86.4 154.49,86.89 154.2,86.4 154.2,86.3 154.11,86.25 153.96,86.25 153.87,86.3 153.87,86.4 153.58,86.89 153.29,86.4 153.29,86.3 153.2,86.25 153.05,86.25 152.96,86.3 152.96,86.4 152.67,86.89 152.37,86.4 152.37,86.3 152.29,86.25 152.13,86.25 152.04,86.3 152.04,86.4 151.75,86.89 151.46,86.4 151.46,86.3 151.37,86.25 149.88,86.25 149.65,86.48 149.65,87.5 150.47,88.32
+1.0VS_VCCIO on IN2 (solid shape): outline of 1280 points within 145.79,86.32 158.12,115.18
+1.0VS_VCCIO on IN3 (solid shape): outline of 7460 points within 144.83,49.64 239.24,88.45
+1.2V_LDO on TOP (solid shape): 269.02,78.9 269.02,78.15 269.17,78 269.17,77.76 270.19,76.74 270.48,76.74 270.55,76.68 270.55,76.11 270.48,76.04 268.83,76.04 268.64,76.23 268.64,76.96 268.85,77.17 268.85,77.47 268.77,77.55 268.77,78.9 268.83,78.96 268.96,78.96
+1.2V_MEM on TOP (solid shape): 115.37,53.82 100.37,53.82 100.37,63.82 115.37,63.82
+1.2V_MEM on TOP (solid shape): 146.62,61.03 138.62,61.03 138.62,69.03 146.62,69.03
+1.2V_MEM on TOP (solid shape): outline of 15182 points within 83.59,39.06 215.7,87.89
+1.2V_MEM on IN2 (solid shape): outline of 303 points within 205,50.35 226.9,51.85
+1.2V_MEM on IN3 (solid shape): outline of 384 points within 109.08,39.07 139.92,40.7
+1.2V_MEM on IN4 (solid shape): outline of 554 points within 192.33,39.02 221.92,40.75
+1.2V_MEM_CPUCLK on TOP (solid shape): 153.38,87.86 153.9,87.86 153.91,87.87 154.13,87.87 154.15,87.85 154.15,87.23 153.76,86.84 153.73,86.85 153.37,86.81 153.26,86.46 153.25,86.37 153.17,86.33 153.08,86.33 153,86.37 152.98,86.46 152.67,86.89 152.35,86.46 152.33,86.37 152.25,86.33 151.45,86.33 151.2,86.58 151.2,86.69 150.98,86.91 150.85,86.91 150.84,86.93 150.84,87.44 150.88,87.49 151.37,87.49 151.45,87.41 151.45,87.32 151.62,87.15 152.45,87.15 152.59,87.29 152.59,87.81 152.66,87.87 153.37,87.87
+1.2V_MEN_P on TOP (solid shape): 83.47,60.18 83.47,59.34 83.99,59.34 83.99,58.89 83.47,58.89 83.47,58.14 83.99,58.14 83.99,57.69 83.47,57.69 83.47,54.13 83.99,54.13 83.99,53.69 83.47,53.69 83.47,52.94 83.99,52.94 83.99,52.49 83.47,52.49 83.47,51.84 83.09,51.47 80.81,51.47 77.85,54.42 77.85,57.28 77.44,57.69 77.41,57.69 77.24,57.87 74.98,57.87 74.81,58.03 74.81,58.05 74.8,58.05 74.62,58.22 74.62,58.33 74.37,58.67 73.98,58.53 73.9,58.49 73.82,58.52 73.76,58.58 73.76,59.34 73.89,59.47 77.19,59.47 78.14,60.42 83.22,60.42
+1.2V_MEN_P on BOTTOM (solid shape): 75.47,71.41 75.47,70.2 75.35,70.07 73.95,70.07 73.82,70.2 73.82,71.28 74.01,71.47 75.41,71.47
+1.2V_MEN_P on BOTTOM (solid shape): 75.66,63.05 75.66,61.36 75.98,61.05 75.98,61.06 80.3,61.06 80.68,60.68 80.68,58.14 80.41,57.87 75.06,57.87 74.96,57.97 74.96,58.4 74.66,58.7 73,58.7 71.47,60.23 71.47,60.35 74.06,60.35 74.06,60.29 74.07,60.24 74.09,60.19 74.11,60.15 74.14,60.11 74.18,60.07 74.22,60.04 74.27,60.01 74.32,60 74.37,59.99 74.42,59.99 74.47,60 74.52,60.01 74.57,60.04 74.61,60.07 74.65,60.11 74.68,60.15 74.7,60.19 74.72,60.24 74.72,60.29 74.72,60.35 74.72,60.4 74.7,60.45 74.68,60.49 74.65,60.54 74.61,60.57 74.57,60.6 74.52,60.63 74.47,60.64 74.42,60.65 74.37,60.65 74.32,60.64 74.27,60.63 74.22,60.6 74.18,60.57 74.14,60.54 74.11,60.49 74.09,60.45 74.07,60.4 74.06,60.35 71.47,60.35 71.47,62.77 71.85,63.15 75.56,63.15
+1.5V_RUN on TOP (solid shape): 298.66,20.94 298.66,19.68 298.57,19.59 297.71,19.59 297.66,19.64 297.66,20.07 297.1,20.07 297.1,20.25 297.66,20.25 297.66,20.94 297.76,21.04 298.57,21.04
+1.5V_RUN_AUDIO on TOP (solid shape): 291.56,78.48 291.56,76.9 291.32,76.66 290.76,76.66 290.63,76.52 290.63,74.97 290.44,74.78 290.44,73.9 290.16,73.62 290.16,72.73 290.11,72.68 290.03,72.68 289.95,72.75 289.95,73.67 290.11,73.82 290.11,74.63 290.12,74.71 290.11,74.79 290.11,77.14 290.62,77.65 290.62,78.51 290.64,78.53 291.51,78.53
+1.5V_VIN on TOP (solid shape): 291.79,20.81 291.79,19.3 292.24,18.86 294.37,18.86 294.65,18.58 294.65,14.59 294.58,14.51 292.03,14.51 291.92,14.62 291.92,17.38 291.5,17.8 289.71,17.8 289.51,18 289.51,20.01 288.95,20.01 288.95,20.19 289.51,20.19 289.51,20.91 289.71,21.12 291.49,21.12
+1.8V_PRIM on TOP (solid shape): 192.06,73.34 192.06,71.91 191.88,71.74 189.04,71.74 188.86,71.92 188.86,73.42 188.98,73.54 191.86,73.54
+1.8V_PRIM on TOP (solid shape): 175.74,92.36 175.74,91.26 175.53,91.05 175.14,91.05 174.81,90.73 173.85,90.73 173.68,90.56 172.74,90.56 172.67,90.64 172.67,91.45 172.82,91.6 174.52,91.6 174.69,91.77 174.69,92.4 174.88,92.59 175.51,92.59
+1.8V_PRIM on TOP (solid shape): 280.21,5.15 280.21,4.61 279.66,4.61 279.66,4.06 280.2,4.06 280.2,3.81 279.66,3.81 279.66,3.26 280.21,3.26 280.21,2.57 279.79,2.15 276.67,2.15 276.48,2.35 276.48,4.51 278.69,4.51 278.69,4.45 278.69,4.4 278.71,4.35 278.73,4.31 278.76,4.26 278.8,4.23 278.84,4.2 278.89,4.17 278.94,4.16 278.99,4.15 279.04,4.15 279.09,4.16 279.14,4.17 279.19,4.2 279.23,4.23 279.27,4.26 279.3,4.31 279.32,4.35 279.34,4.4 279.35,4.45 279.35,4.51 279.34,4.56 279.32,4.61 279.3,4.65 279.27,4.69 279.23,4.73 279.19,4.76 279.14,4.79 279.09,4.8 279.04,4.81 278.99,4.81 278.94,4.8 278.89,4.79 278.84,4.76 278.8,4.73 278.76,4.69 278.73,4.65 278.71,4.61 278.69,4.56 278.69,4.51 276.48,4.51 276.48,5.2 276.83,5.56 279.8,5.56
+1.8V_PRIM on BOTTOM (solid shape): 184.25,91.27 184.25,90.57 184.06,90.38 182.54,90.38 182.44,90.48 182.44,91.25 182.64,91.45 184.07,91.45
+1.8V_PRIM on BOTTOM (solid shape): 189.98,108.07 189.98,107.3 189.76,107.08 187.96,107.08 187.46,107.58 187.46,108.02 187.61,108.17 189.88,108.17
+1.8V_PRIM on BOTTOM (solid shape): outline of 89 points within 209.97,102.61 217.06,105.14
+1.8V_PRIM on IN1 (solid shape): 185.56,91.11 185.56,90.51 185.34,90.29 183.92,90.29 183.77,90.44 183.77,91.36 183.88,91.47 185.19,91.47
+1.8V_PRIM on IN1 (solid shape): 189.18,107.48 189.18,106.78 188.88,106.49 188.44,106.49 187.53,107.4 187.53,108 187.72,108.19 188.47,108.19
+1.8V_PRIM on IN2 (solid shape): 184.71,90.88 185.19,90.88 185.32,90.75 185.32,90.03 185.15,89.86 183.7,89.86 183.09,90.47 183.09,91.32 183.18,91.41 184.17,91.41
+1.8V_PRIM on IN2 (solid shape): 193.04,73.94 193.04,73.02 192.49,72.48 192.49,72.24 192.03,71.78 190.03,71.78 189.79,72.01 189.79,73.67 190.24,74.11 192.86,74.11
+1.8V_PRIM on IN3 (solid shape): 192.08,72.14 192.08,70.27 191.73,69.91 190.54,69.91 189.66,70.79 189.66,71.97 190.03,72.34 191.88,72.34
+1.8V_PRIM on IN3 (solid shape): 278.7,4.59 278.7,4.56 278.69,4.43 278.74,4.3 278.74,2.9 278.48,2.65 276.02,2.65 275.4,3.27 275.4,4.39 275.77,4.76 278.53,4.76
+1.8V_PRIM on IN3 (solid shape): outline of 178 points within 174.66,90.08 184.46,92.92
+1.8V_PRIM on IN3 (solid shape): outline of 229 points within 237.07,52.4 245.46,57.88
+1.8V_RUN_CARD on TOP (solid shape): 301.86,58.57 302.01,58.57 302.13,58.45 302.13,56.65 301.98,56.5 301.98,55.15 301.72,54.9 301.22,54.9 301.09,55.03 301.09,58.2 301.47,58.58 301.85,58.58
+1.8V_RUN_CARD on BOTTOM (solid shape): 301.72,55.79 301.72,55.15 301.34,54.77 299.69,54.77 299.44,55.03 299.44,55.91 299.69,56.17 301.34,56.17
+1.8VALWP on TOP (solid shape): 285.52,5.52 285.52,2.78 285.39,2.65 284.52,2.65 284.43,2.74 284.43,3.53 284.15,3.81 282.06,3.81 281.77,3.51 281.77,2.8 281.52,2.55 280.49,2.55 280.35,2.69 280.35,3.41 279.82,3.41 279.8,3.42 279.8,3.65 280.34,3.65 280.35,3.67 280.35,4.21 279.8,4.21 279.8,4.44 279.82,4.45 280.35,4.45 280.35,5.08 280.64,5.37 281.33,5.37 281.63,5.67 285.37,5.67
+1VALWP on TOP (solid shape): 225.97,92.12 225.97,88.29 225.12,87.44 225.12,87.24 224.99,87.12 223.54,87.12 223.38,87.27 223.38,90.59 222.91,91.07 222.57,91.07 222.38,91.25 222.38,92.1 222.64,92.36 225.73,92.36
+1VALWP on BOTTOM (solid shape): 224.54,93.18 225.24,93.18 225.24,93.71 225.72,93.71 225.72,93.13 226.67,93.13 227.73,92.07 227.73,88.33 227.57,88.17 227.56,88.17 227.44,88.06 222.09,88.06 221.99,88.15 221.99,89.57 222.3,89.88 222.3,92.97 222.48,93.15 224.06,93.15 224.06,93.71 224.54,93.71
+1VALWP_B+ on TOP (solid shape): 226.86,81.12 227.68,80.3 227.68,79.54 227.45,79.31 227.03,79.31 227.03,79.83 226.52,79.83 226.52,79.31 226.23,79.31 226.23,79.83 225.72,79.83 225.72,79.31 225.1,79.31 224.13,78.33 223.43,78.33 223.37,78.39 223.37,81.25 222.73,81.89 222.73,82.33 222.79,82.39 224.32,82.39 224.76,82.84 226.86,82.84
+1VS_VCCIOP on TOP (solid shape): 237.46,52.92 237.97,52.92 237.97,53.44 238.26,53.44 238.26,52.92 239.58,52.92 239.75,52.75 239.75,49.12 239.68,49.06 236.7,49.06 235.68,50.07 235.68,52.64 235.97,52.92 237.17,52.92 237.17,53.44 237.46,53.44
+1VS_VCCIOP on BOTTOM (solid shape): 238.96,50.74 238.96,49.89 238.77,49.7 237.72,49.7 237.62,49.81 237.62,50.82 237.71,50.91 238.79,50.91
+2.5V_MEM on TOP (solid shape): 234.83,48.77 234.83,47.9 234.67,47.74 230.83,47.74 230.76,47.82 230.76,50.55 230.97,50.77 232.83,50.77
+2.5V_MEM on TOP (solid shape): 248.3,40.28 248.3,38.91 248.26,38.87 247.11,38.87 246.95,39.04 246.95,40.23 247.09,40.37 248.21,40.37
+2.5V_MEM on TOP (solid shape): 151.13,48.94 151.13,48.9 151.25,48.63 151.55,48.55 151.55,48.55 153.2,48.55 153.27,48.49 153.27,47.82 153.08,47.63 152.64,47.63 151.98,46.97 149.74,46.97 149.57,47.14 149.57,47.4 149.73,47.56 149.87,47.56 149.87,47.7 150.12,47.95 150.12,49.09 150.16,49.13 150.94,49.13
+2.5V_MEM on BOTTOM (solid shape): 231.97,50.55 231.97,48.7 231.75,48.48 230.87,48.48 230.41,48.94 229.91,48.94 229.82,49.03 229.82,50.62 229.96,50.76 231.77,50.76
+2.5V_MEM on BOTTOM (solid shape): 151.37,50.43 151.37,49.22 151.32,49.19 151.27,49.16 151.23,49.12 151.2,49.08 151.18,49.03 151.16,48.98 151.15,48.93 151.15,48.88 151.16,48.82 151.18,48.77 151.2,48.73 151.23,48.68 151.27,48.65 151.32,48.62 151.37,48.59 151.37,47.15 151.11,46.9 149.88,46.9 149.56,47.21 149.56,48.53 149.22,48.87 149.22,49.54 150.09,49.54 150.09,49.49 150.09,49.44 150.11,49.39 150.13,49.34 150.16,49.3 150.2,49.26 150.24,49.23 150.29,49.21 150.34,49.19 150.39,49.18 150.44,49.18 150.49,49.19 150.54,49.21 150.59,49.23 150.63,49.26 150.67,49.3 150.7,49.34 150.72,49.39 150.74,49.44 150.75,49.49 150.75,49.54 150.74,49.59 150.72,49.64 150.7,49.69 150.67,49.73 150.63,49.77 150.59,49.8 150.54,49.82 150.49,49.84 150.44,49.84 150.39,49.84 150.34,49.84 150.29,49.82 150.24,49.8 150.2,49.77 150.16,49.73 150.13,49.69 150.11,49.64 150.09,49.59 150.09,49.54 149.22,49.54 149.22,50.62 149.36,50.76 151.04,50.76
+2.5V_MEM on IN3 (solid shape): 152.29,47.94 152.29,47.02 152.18,46.91 149.63,46.91 149.49,47.05 149.49,47.87 149.73,48.12 152.11,48.12
+2.5V_MEM on IN3 (solid shape): 248.05,40.1 248.05,38.81 247.97,38.73 246.67,38.73 246.56,38.84 246.56,40.23 246.91,40.57 247.58,40.57
+2.5V_MEM on IN3 (solid shape): 231.93,50.57 231.93,50.08 232.01,50 232.88,50 232.99,49.88 232.99,49.08 232.88,48.97 230.98,48.97 230.8,49.15 230.8,50.56 230.96,50.72 231.79,50.72
+2.5V_VIN on TOP (solid shape): 261.71,46.44 261.71,44.42 260.94,43.66 259.98,43.66 259.92,43.6 259.64,43.5 259.54,43.22 258.39,42.07 257.95,42.07 257.73,41.85 257.73,40.99 257.7,40.96 254.85,40.96 254.7,40.99 254.54,40.96 254.22,40.96 254.2,40.97 254.2,43.58 254.23,43.61 257.21,43.61 257.4,43.79 257.4,45.45 257.4,45.45 257.4,45.56 257.68,45.84 258.75,45.84 258.76,45.83 259.21,45.83 259.27,45.84 260.24,45.84 260.44,45.64 260.72,45.64 261.03,45.96 261.03,46.33 261.17,46.47 261.68,46.47
+3.3V_1.8V_PGPPA on TOP (solid shape): 189.71,75.09 189.71,74 189.53,73.83 187.63,73.83 187.42,74.04 187.42,76.11 187.68,76.36 188.44,76.36
+3.3V_1.8V_PGPPA on IN3 (solid shape): outline of 982 points within 166.13,75.65 188.56,87.49
+3.3V_ALW on TOP (solid shape): 245.74,69.31 245.74,67.52 245.65,67.43 244.56,67.43 244.42,67.57 244.42,69.55 244.57,69.71 245.35,69.71
+3.3V_ALW on TOP (solid shape): 276.79,18.6 276.79,17.59 276.73,17.53 275.12,17.53 275.02,17.64 275.02,18.64 275.24,18.87 276.51,18.87
+3.3V_ALW on TOP (solid shape): 206.84,83.75 206.84,82.48 206.47,82.11 205.76,82.11 205.49,82.38 204.67,82.38 204.55,82.5 204.55,83.64 204.79,83.88 206.71,83.88
+3.3V_ALW on TOP (solid shape): 87.92,106.46 89.51,106.46 89.63,106.33 89.63,105.73 88.35,104.44 86.67,104.44 86.07,105.04 86.07,106.51 86.41,106.85 87.53,106.85
+3.3V_ALW on TOP (solid shape): 227.3,81.7 227.87,81.12 229.91,81.12 230.03,81 230.03,80.55 229.91,80.43 227.75,80.43 226.98,81.19 226.98,82.84 227.3,82.84
+3.3V_ALW on TOP (solid shape): 198.66,79.62 198.66,78.9 198.14,78.38 197.36,78.38 197.27,78.48 197.27,79.16 197.8,79.69 198.59,79.69
+3.3V_ALW on TOP (solid shape): 195.3,80.17 195.3,79.28 195.7,78.88 195.7,78.59 195.53,78.41 194.68,78.41 194.36,78.74 194.36,79.99 194.6,80.23 195.23,80.23
+3.3V_ALW on TOP (solid shape): 297.52,5.27 297.52,3.17 297.34,2.99 296.12,2.99 295.98,3.13 295.98,3.7 295.42,3.7 295.42,3.95 295.97,3.95 295.98,3.96 295.98,4.5 295.42,4.5 295.42,4.75 295.98,4.75 295.98,5.34 296.16,5.52 297.27,5.52
+3.3V_ALW on TOP (solid shape): 220.4,68.52 220.4,68.17 220.41,68.15 220.41,66.01 219.82,65.42 218.4,65.42 218.15,65.68 218.15,66.05 218.25,66.15 218.57,66.15 218.97,66.55 218.97,68.13 218.7,68.4 217.9,68.4 217.85,68.45 217.85,68.56 217.94,68.65 220.27,68.65
+3.3V_ALW on TOP (solid shape): 287.86,109.83 288.1,109.69 288.36,109.78 288.48,109.66 288.48,108.25 288.33,108.1 286.66,108.1 286.48,108.28 286.48,109.76 286.55,109.83
+3.3V_ALW on TOP (solid shape): 265.1,73.85 265.1,72.91 265.21,72.79 266.19,72.79 267.59,71.4 269.35,71.4 269.49,71.26 269.49,70.8 269.42,70.72 267.64,70.72 266.38,71.98 264.96,71.98 264.4,71.42 264.4,70.97 264.3,70.87 263.79,70.87 263.73,70.94 263.73,73.06 264.07,73.4 264.07,73.97 264.16,74.06 264.88,74.06
+3.3V_ALW on TOP (solid shape): 180.25,66.21 180.25,65.87 180.44,65.68 181.59,65.68 181.65,65.61 181.65,65.59 182.62,64.63 182.62,63.53 182.53,63.44 182.1,63.44 180.85,64.69 179.49,64.69 179.19,64.4 179.19,63.95 179.04,63.8 177.53,63.8 177.2,64.13 177.2,65.21 178.25,66.26 180.2,66.26
+3.3V_ALW on TOP (solid shape): 288.52,112.18 288.52,111.6 288.39,111.48 287.77,111.48 287.76,111.48 287.48,111.49 287.3,111.28 287.3,111.27 287.25,111.22 286.52,111.22 286.47,111.27 286.47,111.92 286.73,112.18 286.74,112.18 286.92,112.37 288.33,112.37
+3.3V_ALW on TOP (solid shape): 242.77,73.31 242.77,70.06 242.75,70.04 242.65,69.94 242.62,69.81 242.62,69.78 242.47,69.64 242.44,69.64 242.17,69.58 242.04,69.32 242.01,69.25 241.94,69.22 241.46,69.22 241.35,69.34 241.35,70.54 241.88,71.08 241.88,73.35 241.97,73.44 242.64,73.44
+3.3V_ALW on TOP (solid shape): 265.33,47.7 265.33,45.27 265.02,44.96 261.9,44.96 261.84,45.02 261.84,45.31 262.39,45.31 262.39,45.65 264.19,45.65 264.19,45.62 264.2,45.57 264.22,45.52 264.24,45.48 264.27,45.43 264.31,45.4 264.35,45.37 264.4,45.34 264.45,45.33 264.5,45.32 264.55,45.32 264.6,45.33 264.65,45.34 264.7,45.37 264.74,45.4 264.78,45.43 264.81,45.48 264.83,45.52 264.85,45.57 264.85,45.62 264.85,45.68 264.85,45.73 264.83,45.78 264.81,45.82 264.78,45.87 264.74,45.9 264.7,45.93 264.65,45.96 264.6,45.97 264.55,45.98 264.5,45.98 264.45,45.97 264.4,45.96 264.35,45.93 264.31,45.9 264.27,45.87 264.24,45.82 264.22,45.78 264.2,45.73 264.19,45.68 264.19,45.65 262.39,45.65 262.39,45.74 261.84,45.74 261.84,46.26 262.01,46.42 262.43,46.42 263.91,47.9 265.12,47.9
+3.3V_ALW on TOP (solid shape): 223.94,74.34 223.94,72.68 224.21,72.41 224.2,72.38 224.25,72.18 224.4,72.04 224.43,72.03 224.43,71.12 224.33,71.01 223.57,71.01 223.57,71 223.53,71 223.24,70.76 223.33,70.39 223.56,70.16 223.57,70.16 223.68,70.05 224.32,70.05 224.43,69.93 224.43,69.27 224.23,69.07 223.44,69.07 222.76,69.75 222.76,69.85 222.86,70.03 222.78,70.23 222.78,70.55 222.49,70.85 222.49,74.39 222.62,74.52 223.76,74.52
+3.3V_ALW on TOP (solid shape): 265.35,59.36 265.35,58.95 264.79,58.95 264.79,58.47 265.35,58.47 265.35,58.11 265.34,58.08 265.3,58.06 264.97,57.73 265.3,57.4 265.34,57.38 265.35,57.35 265.35,56.84 265.19,56.68 262.83,56.68 262.53,56.97 262.53,58.47 263.09,58.47 263.09,58.95 262.53,58.95 262.53,59.45 262.64,59.56 263.42,59.56 263.64,59.48 263.86,59.56 265.15,59.56
+3.3V_ALW on TOP (solid shape): 251.94,49.31 251.94,45.72 251.6,45.72 251.6,45.28 251.56,45.25 248.51,45.25 248.27,45.49 248.27,46.66 248.32,46.71 248.96,46.71 249.03,46.68 249.06,46.6 249.49,46.28 249.65,46.79 249.62,46.83 249.75,46.96 249.79,46.93 250.32,47.13 249.9,47.51 249.81,47.52 249.77,47.6 249.77,48.15 249.65,48.27 249.34,48.27 249.26,48.19 249.19,48.15 249.14,48.1 248.32,48.1 248.26,48.17 248.26,48.99 248.49,49.22 248.51,49.22 248.98,49.69 251.56,49.69
+3.3V_ALW on BOTTOM (solid shape): 87.61,117.46 87.61,117.45 87.98,117.08 87.98,115.86 87.67,115.54 86.52,115.54 86.21,115.86 86.21,117.66 86.26,117.71 87.36,117.71
+3.3V_ALW on BOTTOM (solid shape): 219.24,102.01 219.24,100.11 219.05,99.92 218.28,99.92 218.28,100.43 217.58,100.43 217.58,99.92 217.08,99.92 217.08,100.43 216.38,100.43 216.38,99.92 215.62,99.92 215.62,99.92 215.53,99.92 215.38,100.08 215.38,101.95 215.62,102.19 219.05,102.19
+3.3V_ALW on BOTTOM (solid shape): 292.06,9.42 292.06,7.34 294.4,5 297.23,5 297.41,4.82 297.41,3.54 297.11,3.25 292.82,3.25 290.74,5.33 290.74,8.94 290.67,9.01 290.67,9.69 291.06,10.08 291.4,10.08
+3.3V_ALW on IN3 (solid shape): 195.79,78.81 195.79,78.43 195.7,78.34 194.19,78.34 194.07,78.46 194.07,78.85 194.17,78.95 195.65,78.95
+3.3V_ALW on VCC: outline of 173 points within 61.07,1.27 302.88,127.16 ; 1 cut-out
+3.3V_ALW2_R on BOTTOM (solid shape): 286.31,10.99 286.31,10.5 285.58,9.77 285.4,9.77 285.17,9.54 285.17,9.01 285.06,8.91 285.06,7.98 284.95,7.87 284.83,7.87 284.74,7.96 284.74,9.85 284.97,10.08 284.97,10.61 285.39,11.03 286.27,11.03
+3.3V_ALW_DSW on TOP (solid shape): 182.27,70.34 182.27,69.81 182.25,69.78 181.81,69.78 181.6,69.57 181.6,67.43 182.55,66.47 184.57,66.47 184.9,66.14 184.9,64.47 184.71,64.27 184.71,62.25 184.82,62.14 186.28,62.14 186.41,62.26 186.41,63.16 186.49,63.23 186.63,63.23 186.7,63.17 186.7,61.79 186.41,61.5 184.69,61.5 184.4,61.79 184.4,64.11 183.3,65.21 182.33,65.21 181.58,65.96 180.66,65.96 180.47,66.14 180.47,69.67 180.64,69.84 180.64,70.4 180.68,70.43 182.18,70.43
+3.3V_ALW_DSW on TOP (solid shape): outline of 110 points within 163.81,79.51 168.83,90.96
+3.3V_ALW_PCH on TOP (solid shape): 221.93,64.14 221.93,62.46 221.83,62.35 221.31,62.35 221.18,62.48 221.18,64.23 221.21,64.26 221.81,64.26
+3.3V_ALW_PCH on TOP (solid shape): outline of 2176 points within 164.35,71.73 192.18,99.83
+3.3V_ALW_PCH on BOTTOM (solid shape): 188.67,88.87 188.67,88.45 186.72,88.45 186.55,88.27 186.05,88.27 185.9,88.43 185.9,88.68 186.18,88.96 188.58,88.96
+3.3V_ALW_PCH on BOTTOM (solid shape): 175.78,117.89 175.78,115.29 175.69,115.2 174.05,115.2 173.97,115.27 173.97,115.86 174.79,116.67 174.79,117.85 174.98,118.04 175.63,118.04
+3.3V_ALW_PCH on IN2 (solid shape): outline of 117 points within 160.47,88.59 163.33,93.39
+3.3V_ALW_PCH on IN3 (solid shape): outline of 141 points within 244.62,83.17 250.47,84.65
+3.3V_ALW_PCH on IN3 (solid shape): outline of 3456 points within 161.33,67.12 188.66,89.41
+3.3V_ALW_PCH_UZ22 on TOP (solid shape): 194.56,84.1 194.56,83.71 194.64,83.64 195.02,83.64 195.13,83.52 195.13,82.94 195.3,82.77 195.3,81.67 195.26,81.63 194.4,81.63 193.96,81.2 192.41,81.2 192.4,81.24 192.36,81.32 192.3,81.39 192.3,82.33 192.82,82.33 192.82,82.71 192.3,82.71 192.3,84.01 192.5,84.21 194.45,84.21
+3.3V_ALW_UE1 on TOP (solid shape): 266.69,59.26 266.69,58.17 266.53,58.01 265.63,58.01 265.5,58.14 265.5,58.62 264.94,58.62 264.94,58.8 265.5,58.8 265.5,59.32 265.64,59.46 266.49,59.46
+3.3V_ALW_UE1 on IN4 (solid shape): outline of 149 points within 226.15,63.71 230.36,66.07
+3.3V_ALW_UE2 on TOP (solid shape): 262.38,59.55 262.38,58.8 262.94,58.8 262.94,58.62 262.38,58.62 262.38,58.11 262.28,58.01 261.23,58.01 261.11,58.12 261.11,58.88 260.93,59.07 260.4,59.07 260.34,59.13 260.34,59.63 260.44,59.74 262.19,59.74
+3.3V_ALW_UE2 on BOTTOM (solid shape): outline of 114 points within 252.69,69.48 254.05,71.95
+3.3V_ALW_UE2 on IN1 (solid shape): outline of 327 points within 253.73,72.93 259.14,75.36
+3.3V_ALWP on TOP (solid shape): 221.41,102.04 221.41,95.36 221.21,95.16 219.63,95.16 219.37,95.42 219.37,102.07 219.59,102.29 221.15,102.29
+3.3V_ALWP on BOTTOM (solid shape): 215.38,86.68 216.2,86.68 216.26,86.62 216.26,86.49 216.19,86.42 215.23,86.42 214.34,85.52 213.02,85.52 212.95,85.59 212.95,86.23 213.07,86.35 213.87,86.35 214.15,86.63 214.15,86.81 214.4,87.05 215.01,87.05
+3.3V_ALWP on BOTTOM (solid shape): 221.35,101.85 221.35,95.3 221.02,94.97 214.77,94.97 214.46,95.28 214.46,99.48 214.74,99.76 216.5,99.76 216.5,99.79 216.51,99.79 216.51,100.31 216.96,100.31 216.96,99.79 216.98,99.79 216.98,99.79 217.68,99.79 217.68,99.79 217.71,99.79 217.71,100.31 218.16,100.31 218.16,99.79 218.18,99.79 218.18,99.73 219.3,99.73 219.61,100.03 219.61,101.74 219.94,102.08 221.12,102.08
+3.3V_HDD on TOP (solid shape): 29.12,44.05 29.12,40.62 28.19,39.7 27.03,39.7 27.03,40.23 26.52,40.23 26.52,39.7 26.23,39.7 26.23,40.23 25.72,40.23 25.72,39.7 23.18,39.7 23.18,40.23 22.67,40.23 22.67,39.7 22.38,39.7 22.38,40.23 21.87,40.23 21.87,39.7 21.2,39.7 21.08,39.82 21.08,40.67 21.07,40.67 21.07,42.38 23.16,44.46 28.71,44.46
+3.3V_HDD on BOTTOM (solid shape): 82.74,113.61 83.28,113.61 83.28,114.16 83.54,114.16 83.54,113.61 84.08,113.61 84.08,114.16 84.81,114.16 85.09,113.87 85.09,112.02 84.81,111.73 82.56,111.73 82.15,112.14 82.15,114 82.31,114.16 82.74,114.16
+3.3V_HDD on IN2 (solid shape): 83.98,112.97 83.98,112.18 82.6,110.79 82.6,110.2 82.37,109.98 79.66,109.98 79.28,110.36 79.28,112.77 79.79,113.28 83.67,113.28
+3.3V_HDD on IN2 (solid shape): 49.69,60.74 49.69,58.45 49.31,58.07 43.41,58.07 42.9,58.58 42.9,60.74 43.19,61.03 44.99,61.03 45.34,61.12 49.31,61.12
+3.3V_HDD on IN4 (solid shape): outline of 1793 points within 21.12,40.59 46.45,59.75
+3.3V_HDD_P on TOP (solid shape): outline of 101 points within 6.7,31.78 25.63,40.1
+3.3V_HDD_UZ4 on BOTTOM (solid shape): 84.94,117.63 84.94,114.58 84.66,114.3 83.93,114.3 83.93,113.76 83.69,113.76 83.69,114.3 83.13,114.3 83.13,113.76 82.89,113.76 82.89,114.3 82.33,114.3 82.19,114.44 82.19,115.17 82.42,115.4 82.44,115.4 82.76,115.68 82.57,116.07 82.55,116.09 82.55,116.67 83.58,117.7 84.87,117.7
+3.3V_LAN on TOP (solid shape): 267.5,91.13 267.5,89.57 267.37,89.44 266.48,89.44 266.35,89.57 266.35,89.82 266.58,90.05 266.58,91.13 266.64,91.18 267.44,91.18
+3.3V_LAN on TOP (solid shape): 282.19,113.32 282.19,112.9 282.75,112.9 282.75,112.72 282.2,112.72 282.19,112.71 282.19,112.16 281.82,111.79 280.98,111.79 280.65,112.12 280.65,113.13 281.04,113.51 282,113.51
+3.3V_LAN on BOTTOM (solid shape): outline of 807 points within 254.51,105.58 268.58,111.74
+3.3V_LAN on IN1 (solid shape): 267.5,90.65 267.5,88.05 266.35,86.9 266.1,86.9 265.91,87.09 265.91,87.85 266.35,88.3 266.35,90.71 266.55,90.9 267.24,90.9
+3.3V_LAN on IN1 (solid shape): outline of 532 points within 254.25,104.68 265.43,110.51
+3.3V_LAN on IN3 (solid shape): outline of 988 points within 260.65,109.2 288.7,122.7
+3.3V_LAN_OUT on TOP (solid shape): 265.41,92.22 265.9,92.22 265.99,92.13 265.99,90.24 265.9,90.15 265.33,90.15 265.22,90.25 265.22,91.52 264.11,92.64 263.82,92.64 263.67,92.78 262.71,92.78 262.65,92.85 262.65,93.34 262.7,93.39 264.25,93.39
+3.3V_LAN_OUT on TOP (solid shape): 256.16,94.59 256.34,94.53 256.53,94.59 257.68,94.59 257.74,94.52 257.74,94.45 257.68,94.38 256.51,94.38 256.37,94.24 255.99,94.24 255.75,94 255.75,93.62 255.25,93.12 254.31,93.12 254.22,93.21 254.22,94.52 254.29,94.59
+3.3V_LAN_OUT on BOTTOM (solid shape): outline of 92 points within 255.24,92.05 265.15,97.95
+3.3V_LAN_UZ2 on TOP (solid shape): 285.2,113.31 285.2,111.27 285.15,111.22 283.94,111.22 283.7,111.46 282.66,111.46 282.34,111.78 282.34,112.57 282.9,112.57 282.9,113.05 282.34,113.05 282.34,113.51 282.57,113.74 282.59,113.74 282.62,113.78 284.73,113.78
+3.3V_M on TOP (solid shape): 200.23,84.94 200.23,84.05 200.18,83.96 200.09,83.96 199.78,83.93 199.63,83.66 199.6,83.59 199.53,83.56 199.22,83.56 199.08,83.71 199.08,84.2 198.53,84.2 198.52,84.21 198.52,84.38 199.07,84.38 199.08,84.38 199.08,84.78 199.08,84.78 199.08,85.01 199.2,85.12 200.05,85.12
+3.3V_M_TPM on TOP (solid shape): 220.49,64.52 220.49,63.08 220.48,63.06 220.18,63.06 219.9,63.35 219.89,63.36 219.81,63.56 219.62,63.66 219.58,63.67 219.58,64.44 219.72,64.58 220.44,64.58
+3.3V_M_TPM on TOP (solid shape): 216.65,77.72 216.65,75.19 216.38,74.93 216.38,74.93 216.17,74.71 215.96,74.71 215.55,74.3 215.55,74.05 215.12,73.62 215.12,72.45 215.05,72.37 214.93,72.37 214.86,72.45 214.86,73.47 214.58,73.74 214.58,74.67 214.7,74.8 215,74.8 215.26,75.06 215.26,77.67 215.46,77.86 216.5,77.86
+3.3V_M_UZ8 on TOP (solid shape): 198.93,84.97 198.93,84.48 198.42,84.48 198.42,84.48 198.42,84.17 198.42,84.16 198.42,84.09 198.93,84.09 198.93,83.58 198.6,83.25 198.6,82.35 198.66,82.29 198.66,81.14 198.6,81.08 197.92,81.08 197.33,81.66 197.33,82.85 197.33,82.89 197.03,83.19 197.03,83.23 197.06,83.3 197.13,83.33 197.46,83.67 197.13,84 197.06,84.03 197.03,84.1 197.03,84.74 197.44,85.15 198.75,85.15
+3.3V_MMI_AUX on TOP (solid shape): 269.55,85.69 269.55,84.64 269.25,84.34 269.19,84.34 268.88,84.03 268.88,83.7 269.02,83.56 269.02,82.18 268.99,82.15 268.87,82.15 268.82,82.2 268.82,83 268.41,83.41 268.41,84.28 268.78,84.66 268.78,85.34 268.58,85.55 267.66,85.55 267.48,85.72 267.48,86.29 267.57,86.37 268.86,86.37
+3.3V_MMI_IN on TOP (solid shape): 265.82,86.42 265.82,85.92 265.39,85.5 264.93,85.5 264.8,85.37 264.8,84.51 264.71,84.41 264.14,84.41 263.98,84.58 263.98,86.43 264.17,86.62 265.62,86.62
+3.3V_MMI_IN on TOP (solid shape): 268.2,76.42 268.2,75.41 269.15,74.46 269.15,73.5 268.89,73.25 268.15,73.25 268.15,73.77 267.64,73.77 267.64,73.25 267.35,73.25 267.35,73.77 266.84,73.77 266.84,73.25 266.42,73.25 266.35,73.31 266.35,74.27 267.24,75.15 267.24,76.21 267.28,76.21 267.28,76.81 267.82,76.81
+3.3V_MMI_IN on IN2 (solid shape): outline of 629 points within 264.66,74.09 270,86.55
+3.3V_PGPPC on IN4 (solid shape): 165.31,92.49 165.31,92.38 165.3,92.36 165.4,92.09 165.67,92 165.69,92 165.72,91.97 166.17,91.97 166.27,91.95 166.36,91.97 166.57,91.97 166.86,91.68 166.86,91.65 166.87,91.44 166.97,91.27 167.04,91.2 167.04,91.04 167.46,90.62 167.44,90.59 167.58,90.15 168.02,90.27 168.1,90.31 168.18,90.28 168.26,90.22 168.34,90.19 168.36,90.18 168.76,89.78 168.76,89.66 168.69,89.44 168.76,89.22 168.76,89.21 169.27,88.71 169.27,88.27 169.52,88.02 173.44,88.02 173.94,88.51 176.73,88.51 176.74,88.5 176.74,88.1 176.45,87.8 176.18,87.8 175.91,87.96 175.63,87.8 174.65,87.8 174.32,87.48 174.31,87.48 174.19,87.4 174.12,87.28 174.11,87.27 174.05,87.21 172.78,87.21 172.61,87.26 172.43,87.21 169.16,87.21 168.21,88.15 168.21,88.28 168.12,88.38 168.12,88.39 168.02,88.61 167.81,88.7 167.79,88.7 166.33,90.16 166.3,90.26 166.37,90.33 166.55,90.83 166.03,90.87 165.95,90.84 165.88,90.87 165.73,90.96 165.56,90.97 165.53,90.97 164.54,91.96 164.54,92.35 164.54,92.35 164.54,92.49 164.64,92.59 165.21,92.59
+3.3V_PGPPD on IN3 (solid shape): outline of 87 points within 166.02,89.91 175.75,92.56
+3.3V_PGPPE on IN4 (solid shape): outline of 241 points within 164.73,92.87 172.06,94.67
+3.3V_RUN on TOP (solid shape): 237.7,77.26 237.7,76.04 237.63,75.97 236.03,75.97 235.95,76.04 235.95,77.26 236.1,77.42 237.55,77.42
+3.3V_RUN on TOP (solid shape): 245.37,70.63 245.37,70.05 245.29,69.96 244.64,69.96 244.18,69.5 243.94,69.5 243.81,69.63 243.81,70.21 244.31,70.71 245.3,70.71
+3.3V_RUN on TOP (solid shape): 282.82,11.91 282.82,10.67 282.78,10.63 282.41,10.63 282.41,11.18 281.92,11.18 281.92,10.63 281.66,10.63 281.66,11.96 281.75,12.05 282.69,12.05
+3.3V_RUN on TOP (solid shape): 107.3,115.77 107.3,115.43 107.12,115.25 106.84,115.25 106.41,114.82 105.81,114.82 105.1,115.53 104.61,115.53 104,116.14 104,116.57 104.44,117.01 106.06,117.01
+3.3V_RUN on TOP (solid shape): 289.35,20.85 289.35,20.34 288.8,20.34 288.8,19.86 289.35,19.86 289.35,19.52 289.28,19.44 287.67,19.44 287.46,19.64 287.46,20.85 287.59,20.98 289.23,20.98
+3.3V_RUN on TOP (solid shape): 275.82,68.11 275.82,67.52 276.5,66.84 276.5,65.83 276.29,65.62 275.93,65.62 275.93,66.18 275.45,66.18 275.45,65.63 275.44,65.62 274.63,65.62 274.38,65.87 274.38,67.88 274.67,68.17 275.75,68.17
+3.3V_RUN on TOP (solid shape): 251.93,126.4 251.93,124.75 251.42,124.24 250.85,124.24 250.09,123.48 249.96,123.48 249.9,123.54 249.9,124.46 249.99,124.56 250.01,124.56 250.14,124.64 250.21,124.77 250.22,124.78 251.24,125.8 251.24,126.39 251.32,126.46 251.87,126.46
+3.3V_RUN on TOP (solid shape): 245.27,43.4 245.98,43.4 245.98,43.91 246.47,43.91 246.47,43.4 247.18,43.4 247.18,43.91 247.75,43.91 247.88,43.79 247.88,42.39 246.23,40.74 246.23,39.33 246.12,39.21 244.14,39.21 243.75,39.61 243.75,42.27 244.24,42.77 244.24,43.65 244.45,43.85 244.46,43.85 244.52,43.91 245.27,43.91
+3.3V_RUN on TOP (solid shape): 267.22,73.12 267.25,73.12 267.25,73.11 267.75,73.11 267.75,73.12 267.77,73.12 267.77,73.64 268.02,73.64 268.02,73.12 268.03,73.12 268.03,73.08 268.68,73.08 268.96,72.81 268.96,71.93 268.64,71.61 267.55,71.61 266.34,72.82 266.34,73.01 266.45,73.11 266.95,73.11 266.95,73.12 266.97,73.12 266.97,73.64 267.22,73.64
+3.3V_RUN on TOP (solid shape): 211.44,106.04 211.92,106.04 211.92,106.6 212.19,106.6 212.27,106.56 212.29,106.48 212.44,106.14 212.82,106.12 212.92,106.12 212.97,106.03 212.97,104.14 212.74,103.91 211.37,103.91 210.89,104.39 210.89,106.48 211.02,106.6 211.44,106.6
+3.3V_RUN on TOP (solid shape): 26.1,39.57 26.65,39.57 26.65,40.1 26.9,40.1 26.9,39.57 27.47,39.57 27.79,39.25 27.79,37.83 27.52,37.32 27.43,36.75 27.43,35.96 25.49,35.96 25.48,35.99 25.18,36.18 24.88,35.99 24.87,35.96 24.72,35.96 24.52,36.16 24.52,39.3 24.79,39.57 25.85,39.57 25.85,40.1 26.1,40.1
+3.3V_RUN on TOP (solid shape): 248.3,127.71 248.3,126.84 248.2,126.75 247.49,126.75 247.38,126.64 247.29,126.61 247.22,126.68 247.19,126.73 247.15,126.77 247.13,126.84 247.15,126.91 247.15,127.37 246.69,127.38 246.63,127.36 246.56,127.38 246.1,127.37 246.1,126.91 246.12,126.84 246.1,126.77 246.01,126.6 246.04,126.42 246.03,126.32 245.95,126.27 245.89,126.27 245.71,126.09 245.71,125.41 246.54,124.58 246.54,123.67 246.49,123.61 246.09,123.61 245.98,123.71 245.85,123.77 245.8,123.78 245.74,123.78 245.59,123.93 245.59,124.47 244.83,125.23 244.83,127.36 245.42,127.95 248.05,127.95
+3.3V_RUN on TOP (solid shape): outline of 141 points within 173.52,93.91 176.87,98.72
+3.3V_RUN on BOTTOM (solid shape): 258.32,41.83 258.32,40.99 258.17,40.85 255.96,40.85 255.84,40.96 255.84,41.97 255.92,42.05 258.1,42.05
+3.3V_RUN on BOTTOM (solid shape): 220.77,63.01 220.77,62.16 220.74,62.09 220.67,62.06 220.4,61.92 220.36,61.63 220.37,61.6 219.68,60.91 216.62,60.91 216.36,61.16 216.36,63.78 216.75,64.17 219.61,64.17
+3.3V_RUN on BOTTOM (solid shape): 177.37,111.46 177.68,111.46 178,111.15 178,109.03 177.91,108.94 177.34,108.94 176.64,108.24 176.43,108.24 176.35,108.31 176.35,108.91 176.25,109.02 175.79,109.02 175.62,108.86 175.62,108.32 175.55,108.24 175.44,108.24 175.35,108.33 175.35,109.43 175.79,109.87 175.85,109.92 175.9,109.98 176.01,110.1 176.01,110.65 176.28,110.92 176.28,111.47 176.44,111.63 177.2,111.63
+3.3V_RUN on BOTTOM (solid shape): 65.41,41.82 65.48,41.79 65.51,41.71 65.78,41.34 66.16,41.6 66.21,41.66 66.29,41.67 66.52,41.67 66.69,41.82 68,41.82 69.51,40.31 69.51,38.8 69.36,38.65 64.4,38.65 64.28,38.77 64.28,39.72 64.73,40.36 64.28,40.67 64.28,41.05 65.06,41.82
+3.3V_RUN on BOTTOM (solid shape): outline of 169 points within 178.06,95.64 180.17,103.98
+3.3V_RUN on BOTTOM (solid shape): outline of 219 points within 173.58,68.92 177.39,73.73
+3.3V_RUN on BOTTOM (solid shape): outline of 857 points within 245.27,113.22 253.43,128.51
+3.3V_RUN on IN1 (solid shape): 66.61,41.01 66.61,39.77 66.49,39.65 62.27,39.65 62.04,39.88 62.04,40.97 62.36,41.29 66.33,41.29
+3.3V_RUN on IN1 (solid shape): 26.59,39.46 26.59,38.82 25.73,37.96 25.73,36.52 25.56,36.35 24.35,36.35 24.16,36.54 24.16,39.3 24.66,39.8 26.24,39.8
+3.3V_RUN on IN3 (solid shape): 25.85,38.93 25.85,36.62 25.6,36.37 24.52,36.37 24.37,36.52 24.37,38.81 24.79,39.23 25.56,39.23
+3.3V_RUN on IN3 (solid shape): 66.42,40.98 66.42,39.81 66.27,39.66 62.26,39.66 62.04,39.88 62.04,40.97 62.36,41.29 66.11,41.29
+3.3V_RUN on IN3 (solid shape): outline of 429 points within 211.3,101.32 229.45,112.52
+3.3V_RUN on IN4 (solid shape): 26.98,38.11 26.98,37.33 25.99,36.34 24.7,36.34 24.55,36.48 24.55,37.92 25.31,38.68 26.42,38.68
+3.3V_RUN on IN4 (solid shape): 66.57,40.87 66.57,39.59 66.39,39.41 63,39.41 62.72,39.69 62.72,40.83 63.04,41.15 66.29,41.15
+3.3V_RUN on IN4 (solid shape): outline of 359 points within 243.62,38.55 258.29,42.05
+3.3V_RUN on VCC: 230.2,38.52 229.72,39 229.72,50.81 205.31,75.22 202.38,75.22 201.33,76.27 201.33,78.14 207.64,78.14 230.24,55.53 246.97,55.53 249.51,58.07 255.39,58.07 256.91,56.55 265.25,56.55 267.31,58.6 267.31,85.48 260.96,91.83 260.96,102.25 258.07,105.14 241.04,105.14 241.04,105.13 226.57,105.13 225.52,106.18 225.52,116.26 226.9,117.64 251.71,117.64 265.66,103.69 265.66,95.43 275.18,85.91 275.18,55.89 271.65,52.36 248.15,52.36 246.99,51.19 246.99,39 246.51,38.52 239.68,38.52 237.8,37.57 237.72,37.53 237.72,37.53 237.72,37.27 236.24,37.27 235.77,37.27 235.77,37.54 235.74,37.55 233.81,38.52
+3.3V_RUN on VCC: 167.21,79.15 163.55,82.82 163.55,87.26 162.53,88.28 162.53,88.68 172.8,88.68 174.22,90.1 174.22,97.34 174.7,97.82 181.98,97.82 193.39,86.42 193.39,79.46 193.22,79.29 191.13,79.29 190.56,78.71 186.62,78.71 185.73,77.83 180.29,77.83 179.98,78.14 178.94,78.14 178.51,78.58 173.44,78.58 172.86,79.15
+3.3V_RUN_AUDIO on TOP (solid shape): 284.59,68.32 284.59,67.11 284.59,67.09 284.59,66.65 284.25,66.3 283.49,66.3 282.6,65.41 281.73,65.41 279.87,63.55 275.35,63.55 274.86,64.03 274.86,65.17 275.17,65.48 279.5,65.48 281.09,67.07 281.88,67.07 282.39,67.59 283.72,67.59 283.88,67.75 283.88,68.4 283.93,68.45 284.46,68.45
+3.3V_RUN_AUDIO_UZ5 on TOP (solid shape): 278.8,67.83 279.36,67.83 279.42,67.76 279.42,65.85 279.19,65.62 278.34,65.62 278.34,66.18 277.86,66.18 277.86,65.62 277.31,65.62 277.09,65.85 277.09,68.11 277.15,68.17 278.46,68.17
+3.3V_RUN_CARD on BOTTOM (solid shape): 268.07,77.44 268.07,76.74 267.82,76.49 267.82,72.17 268.39,71.6 269.47,71.6 269.57,71.7 274.19,71.7 274.43,71.46 274.43,71.09 274.18,70.84 269.53,70.84 269.21,70.52 267.82,70.52 266.74,71.6 266.74,77.19 267.17,77.62 267.89,77.62
+3.3V_RUN_DIMM1 on TOP (solid shape): 149.86,51.23 149.86,50.29 149.74,50.17 148.5,50.17 148.44,50.23 148.44,50.48 148.3,50.62 147.38,50.62 147.23,50.77 147.23,51.31 147.49,51.57 149.52,51.57
+3.3V_RUN_DIMM2 on TOP (solid shape): 230.62,50.85 230.62,48.4 230.42,48.2 229.39,48.2 229.14,48.45 229.14,48.63 228.86,48.9 228.86,50.15 228.47,50.54 228.47,51.18 228.55,51.25 230.21,51.25
+3.3V_RUN_DIMM2 on BOTTOM (solid shape): 229.63,50.67 229.63,48.92 229.76,48.79 230.18,48.79 230.34,48.63 230.34,48.31 230.24,48.21 229.37,48.21 229.23,48.34 229.23,48.9 229.32,48.99 229.32,50.71 229.36,50.75 229.55,50.75
+3.3V_RUN_UZ3 on TOP (solid shape): 246.98,46.65 246.98,46.16 247.86,45.29 247.86,44.13 247.77,44.05 247.07,44.05 247.07,44.04 247.05,44.04 247.05,43.52 246.6,43.52 246.6,44.04 246.58,44.04 246.58,44.05 245.87,44.05 245.87,44.04 245.85,44.04 245.85,43.52 245.43,43.52 245.4,43.55 245.4,44.04 245.4,44.08 244.66,44.08 244.49,44.26 244.49,45.41 245.6,45.41 245.61,45.36 245.62,45.31 245.64,45.26 245.66,45.21 245.7,45.17 245.74,45.13 245.78,45.1 245.83,45.08 245.88,45.06 245.93,45.06 245.98,45.06 246.04,45.06 246.09,45.08 246.14,45.1 246.18,45.13 246.22,45.17 246.25,45.21 246.28,45.26 246.3,45.31 246.31,45.36 246.31,45.41 246.31,45.46 246.3,45.52 246.28,45.57 246.25,45.61 246.22,45.65 246.18,45.69 246.14,45.72 246.09,45.74 246.04,45.76 245.98,45.77 245.93,45.77 245.88,45.76 245.83,45.74 245.78,45.72 245.74,45.69 245.7,45.65 245.66,45.61 245.64,45.57 245.62,45.52 245.61,45.46 245.6,45.41 244.49,45.41 244.49,46.26 244.66,46.44 245.26,46.44 245.54,46.72 246.91,46.72
+3.3V_RUN_VDDA on BOTTOM (solid shape): 220.15,118.02 221.46,118.02 221.46,117.19 221.52,117.13 221.52,116.49 220,116.49 219.81,116.3 219.81,115.35 219.68,115.22 219.43,115.22 219.3,115.35 219.3,116.37 219.56,116.62 219.56,117 219.62,117.06 219.81,117.06 219.91,117.17 219.91,118 219.96,118.05 220.12,118.05
+3.3V_RUN_VDDA on IN2 (solid shape): outline of 1140 points within 213.26,114.42 219.99,120.44
+3.3V_RUN_VDDA on IN3 (solid shape): 220,115.55 220,113.7 219.81,113.51 219.33,113.51 219.2,113.64 219.07,113.79 218.88,113.85 218.74,113.85 218.68,113.91 218.68,113.92 218.55,114.06 218.45,114.42 218.08,114.46 218,114.49 217.97,114.56 217.97,114.92 218.12,115.07 218.49,115.07 218.56,115.04 218.59,114.97 218.72,114.53 219.16,114.64 219.21,114.65 219.26,114.64 219.3,114.59 219.35,114.55 219.37,114.5 219.35,114.44 219.54,113.84 219.72,114.44 219.71,114.5 219.72,114.55 219.77,115.05 219.26,115 219.21,114.99 219.16,115 219.12,115.05 219.07,115.1 219.06,115.15 219.07,115.2 219.17,115.31 219.22,115.45 219.22,115.47 219.43,115.68 219.88,115.68
+3.3V_RUN_VDDIO on BOTTOM (solid shape): 221.83,121.36 221.92,121.37 222.53,121.37 222.74,121.15 222.74,120.15 222.5,119.91 220.69,119.91 220.4,119.62 220.37,119.65 219.98,119.63 219.88,119.26 219.86,119.16 219.78,119.12 219.44,119.12 219.28,119.29 219.28,121.14 219.5,121.37 221.74,121.37
+3.3V_RUN_VDDIO on IN4 (solid shape): outline of 1462 points within 213.14,112.62 220.76,120.68
+3.3V_RUN_VMM on TOP (solid shape): 212.81,108.27 212.81,107.13 212.43,106.75 210.56,106.75 210.41,106.91 210.41,108.33 210.49,108.41 212.68,108.41
+3.3V_RUN_VMM on TOP (solid shape): 225.82,122.56 225.82,121.09 225.46,120.73 224.22,120.73 224.11,120.84 224.11,122.54 224.27,122.69 225.69,122.69

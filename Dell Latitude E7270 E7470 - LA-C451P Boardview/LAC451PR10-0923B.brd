# Allegro board LAC451PR10-0923B.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
3.3V_HDD_EN: length 236.2
  TOP w0.102: v1(170.96,86.1) 171.46,85.59 RC184.2
  IN2 w0.102: v1(185.34,77.58) 185.63,77.58 186.89,76.32 186.89,71.43 188.58,69.74 188.58,67.17 185.39,63.98 185.39,62.02 182.34,58.97 86.93,58.97 v1(86.9,58.95)
  IN3 w0.102: v1(185.34,77.58) 184.8,78.13 181.9,78.13 179.05,80.97 179.05,83.17 178.38,83.84 173.59,83.84 171.33,86.1 v1(170.96,86.1) ; v1(86.9,58.95) 86.52,58.57 85.89,58.57 84.01,56.69 71.18,56.69 69.56,58.31 66.85,58.31 65.5,59.66 63.51,59.66 v1(62.95,60.22)
  IN4 w0.102: v1(62.95,60.22) 62.95,60.87 62.25,61.57 62.25,68.89 68.29,74.93 68.29,77.41 75.94,85.07 75.94,94.53 88.05,106.64 88.05,109.06 v1(89.06,110.08)
  BOTTOM w0.076: v1(170.96,86.1) 171.21,86.1 UC1.AN5
  BOTTOM w0.102: UZ4.5 87.75,118 88.87,116.87 88.87,116.18 88.68,115.99 88.68,110.46 v1(89.06,110.08)
3.3V_TP_EN: length 16.3
  TOP w0.102: v1(170.05,86.52) 170.49,86.08 170.49,79.62 172.81,77.31 v2(174.23,77.31) 174.6,77.31 175.37,76.54 175.37,75.14 RC270.2
  BOTTOM w0.076: UC1.AM5 171.32,86.95 171.02,86.65 170.18,86.65 v1(170.05,86.52)
3.3V_TS_EN: length 239
  TOP w0.102: v1(78.93,93.7) 79.86,94.63 81.72,94.63 85.24,98.15 90.79,98.15 95.1,102.46 v1(96.24,102.46) ; RC282.2 171.94,85.02 171.12,85.02 v1(170.95,85.19) ; v1(103.99,113.32) 104.77,112.53 QV7.2
  IN2 w0.102: v1(96.24,102.46) 96.24,105.57 v1(103.99,113.32) ; v1(184.71,77.57) 185.39,76.88 185.8,76.88 186.48,76.2 186.48,72.98 186.13,72.63 186.13,70.23 187.54,68.82 187.54,66.99 184.78,64.23 184.78,62.28 182.15,59.65 94.18,59.65 93.49,60.33 92.9,60.33 92.1,59.53 85.03,59.53 80.25,54.74 78.15,54.74 77.71,54.3 73.95,54.3 73.76,54.49 70.98,54.49 69.83,55.63 v1(69.33,55.63)
  IN3 w0.102: v1(184.71,77.57) 184.35,77.92 181.82,77.92 178.85,80.89 178.85,82.15 177.37,83.64 172.53,83.64 170.98,85.19 v1(170.95,85.19)
  BOTTOM w0.076: v1(170.95,85.19) 171.41,85.65 UC1.AP5
  BOTTOM w0.102: v1(78.93,93.7) 78.93,93.22 77.61,91.91 76.57,91.91 75.69,91.03 75.69,82.03 70,76.34 70,70.86 67.79,68.65 67.79,61.3 69.19,59.9 69.19,58.39 68.36,57.57 68.36,56.6 v1(69.33,55.63)
3.3V_WWAN_EN: length 110.2
  TOP w0.102: UE1.B42 v1(229.24,67.48) ; RZ40.2 288.33,112.81 288.71,112.43 v2(288.71,110.94) 288.71,110.59 v1(288.14,110.02) 287.5,110.02 287.39,110.12 UZ2.3
  IN3 w0.102: v1(288.14,110.02) 287.38,110.02 287.15,109.79 287.15,108.14 283.62,104.61 281.09,104.61 280.01,103.53 280.01,96.94 280.53,96.41 280.53,81.33 282.88,78.98 282.88,74.9 280.08,72.11 280.08,67.86 278.08,65.86 264.11,65.86 263.01,66.96 260.92,66.96 260.81,67.08 259.39,67.08 259.19,67.28 256.51,67.28 256.37,67.42 252.17,67.42 251.46,68.13 249.69,68.13 248.63,69.2 243.83,69.2 242.91,68.27 239.38,68.27 238.48,69.17 236.59,69.17 235.28,67.86 229.62,67.86 v1(229.24,67.48)
3V5V_EN: length 16.9
  TOP w0.102: v1(206.41,84.92) 206.02,84.92 v2(205.71,85.23)
  IN1 w0.254: v1(214.89,85.09) 207.9,85.09 207.62,85.37 206.63,85.37 206.41,85.15 v1(206.41,84.92)
  BOTTOM w0.254: PU102.12 207.05,85.99 206.41,85.35 v1(206.41,84.92) 206.41,83.9 206.09,83.58 PC128.1 PR116.1 206.09,80.9 PR114.2 ; PU100.12 215.39,85.65 214.89,85.16 v1(214.89,85.09)
3V_FB: length 4.9
  BOTTOM w0.102: PR110.1 214.17,84.11 v2(214.26,84.02)
  BOTTOM w0.254: PR110.1 PC113.1 213.31,85.01 PR109.2 214.18,85.04 215.25,86.1 PU100.13
3V_SN: length 1.4
  TOP w0.102: PC112.1 217.35,84.07 v2(217.79,83.63)
3V_VIN:
  vias: v1(218.79,82.34) v1(218.79,81.76) v2(220.1,83.09)
5V_FB: length 4.2
  BOTTOM w0.254: PU102.13 206.93,86.44 205.89,85.4 PR115.2 PC127.1 204.77,84.88 PR118.1
5V_SN:
  vias: v2(211.44,86.23)
5V_VIN:
  vias: v1(211.72,83.35) v1(211.72,82.76) v2(212.28,82.94)
+0.6V_DDR_VTT: length 156.5
  TOP w0.102: v2(78.65,52.29) 78.65,51.68 v1(78.67,51.66)
  IN2 w1.016: 151.8,43.76 153.43,43.76 154.68,45.02 159.18,45.02 162.36,41.83 192.71,41.83 193.35,41.19 214.73,41.19 214.78,41.25 229.03,41.25 229.62,41.83
  IN3 w1.524: 80.74,49.63 80.74,48.1 79.19,46.55 79.19,43.5 81.13,41.56 146.82,41.56 147.15,41.89 147.17,41.88
  vias: v1(71.41,75.28) v1(71.41,74.71) v1(71.41,74.14) v1(79.27,52.26) v1(79.25,51.66) v1(149.22,43.07) v1(149.86,43.07) v1(229.86,42.93) v1(230.5,42.93)
+0.6V_P: length 1
  BOTTOM w0.102: 72.59,75.69 v2(72.59,76.72)
+0.9V_LAN: length 9.1
  TOP w0.127: CL4.1 v3(270.7,94.59)
  TOP w0.203: v1(264.2,95.92) 263.96,95.69 UL1.11 ; v1(258.8,89.44) 259.2,89.84 UL1.40 ; UL1.43 260.4,90.07 v1(260.44,90.03) ; UL1.16 261.2,97.47 261.16,97.51 261.16,97.9 261.55,98.29 v1(261.59,98.29) ; UL1.22 v1(258.8,97.74)
  TOP w0.381: CL11.1 261.47,98.42 v1(261.59,98.29) ; CL9.1 v1(258.8,89.44)
  vias: v1(256.13,89.35) v1(261.73,89.96) v1(265.1,94.75)
+1.0V_AMPHYPLL: length 22.6
  IN3 w0.508: v1(171.71,106.83) 170.39,105.51 170.39,103.88 171.93,102.35 171.93,99.53 170.94,98.54 170.94,98.01 170.41,97.48 166.41,97.48 v1(166.29,97.35)
  BOTTOM w0.254: UC1.L15 v1(166.29,97.35) UC1.K15
  BOTTOM w0.508: CC264.1 171.24,110.44 CC219.1 ; CC264.1 171.36,107.96 171.71,107.6 v1(171.71,106.83) ; CC264.1 172.35,110.32 RC169.2
+1.0V_APLL: length 18.8
  TOP w0.508: v1(189.92,96.74) 190.49,96.18 CC225.1 191.86,96.18 192.1,96.41 CC314.1 192.49,96.43 LC2.2
  IN1 w0.508: v1(185.42,95.7) 183.73,97.39 180.41,97.39 179.98,96.96 179.98,96.44 179.41,95.87 177.66,95.87
  IN4 w0.508: v1(185.42,95.7) 186.19,96.48 189.66,96.48 v1(189.92,96.74)
  BOTTOM w0.254: v1(166.25,94.05) UC1.V15
+1.0V_APLLEBB: length 22.4
  TOP w0.102: RC310.2 v2(173.71,111.35)
  TOP w0.356: v1(163.66,95.69) 163.66,95.58 163.09,95.01 CC218.1
  TOP w0.508: RC310.2 174.98,110.19 v1(174.97,110.18)
  IN3 w0.508: v1(174.97,110.18) 174.37,110.78 166.73,110.78 165.14,109.18 165.14,107.43 165.59,106.97 165.59,101.77 165.66,101.71
  BOTTOM w0.254: UC1.N18 v1(163.66,95.69)
+1.0V_CLK1: length 13.4
  TOP w0.508: RC302.2 170.61,111.02 v1(170.61,106.98)
  BOTTOM w0.203: 167.15,103.95 167.13,103.92 166.62,103.92 166.27,103.57 166.27,103 166.27,102.99 UC1.A14
  BOTTOM w0.254: 167.15,103.95 167.83,104.62 167.83,106.35 168.13,106.65 168.13,107.64 v2(168.3,107.81) 169.03,107.81 169.18,107.67 169.92,107.67 v1(170.61,106.98)
+1.0V_CLK2: length 23.8
  TOP w0.508: RC170.2 163.05,114.6 162.01,113.56 162.01,111.81 162.37,111.45 CC220.1 163.42,110.35 162.05,108.97 159.59,108.97 158.98,108.37 158.98,104.61 160.77,102.82 163.75,102.82 164.44,102.13 164.44,101.48 164.15,101.2
  BOTTOM w0.254: v1(163.67,97.35) UC1.K19
  vias: v2(163.96,98.34)
+1.0V_CLK3: length 12.3
  TOP w0.102: v1(162.37,97.35) v2(162.37,97.91)
  TOP w0.508: v1(165.5,111.27) 166.15,111.92 RC303.2
  IN3 w0.508: v1(165.5,111.27) 164.7,111.27 163.12,109.69 163.12,107.08 163.45,106.75 163.95,106.75 164.37,106.33 164.37,103.89
  BOTTOM w0.254: UC1.L21 v1(162.37,97.35)
+1.0V_CLK4: length 5.1
  TOP w0.102: v2(162.65,96.11) 162.37,95.83 v1(162.37,95.68)
  BOTTOM w0.254: UC1.N20 v1(162.37,95.68)
  BOTTOM w0.508: v1(163.93,109.08) 163.64,109.37 163.07,109.37 162.6,109.84 CC226.1 163.61,110.44 RC173.2
+1.0V_CLK5: length 14.7
  TOP w0.356: v1(163.02,96.52) 162.96,96.58 162.42,96.58 162.21,96.38 162.21,96.29 161.8,95.88 RC52.2
  IN3 w0.508: 164.53,102.09 164.98,102.54 164.98,106.66 164.53,107.12 164.53,109.43 v1(166.24,111.15)
  BOTTOM w0.254: UC1.L19 v1(163.02,96.52)
  BOTTOM w0.508: v1(166.24,111.15) 166.44,110.94 RC171.2 167.4,110.44 CC221.1
+1.0V_CLK6: length 10.2
  TOP w0.508: v1(169.02,103.98) 169.18,103.98 169.99,104.78 169.99,109.04 169.85,109.17 v2(169.85,110.29) 169.85,110.28 CC216.1 169.85,112.07 RC300.2
  BOTTOM w0.203: v1(169.02,103.98) 169.02,103.55 168.75,103.28 UC1.A10
+1.0V_DTS: length 19.2
  TOP w0.102: v1(175.38,95.08) 175.38,95.09 v2(175.73,95.44)
  TOP w0.508: RC301.2 190.64,94.85 v1(189.89,94.1)
  IN3 w0.508: v1(189.89,94.1) 189.29,94.71 182.29,94.71 181.56,95.44 181.02,95.44 180.59,95.87 180.01,95.87 179.65,95.51 177.5,95.51 177.14,95.87 176.07,95.87 175.38,95.18 v1(175.38,95.08)
  BOTTOM w0.203: UC1.T1 175.36,95.06 v1(175.38,95.08)
+1.0V_MPHYAON: length 15.3
  TOP w0.508: v1(174.52,97.81) 174.38,97.95 174.38,99.01 173.68,99.71 173.68,102.26 173.11,102.83 168.83,102.83 168.54,102.53 ; 167.09,97.49 166.52,98.07 165.41,98.07 165.28,98.2 CC203.1 164.76,98.2 164.32,97.76 v1(164.32,97.35)
  BOTTOM w0.254: v1(174.52,97.81) 174.42,97.71 UC1.L1 ; UC1.K17 v1(164.32,97.35)
  vias: v1(166.19,115.11) v1(166.19,114.52) v1(166.77,115.11) v1(166.77,114.52) v1(167.35,115.11) v1(167.35,114.52) v2(167.79,111.22)
+1.0V_MPHYGT: length 2.8
  BOTTOM w0.254: UC1.P16 165.29,95.37 v1(164.98,95.68) 164.98,95.76 UC1.N17 ; UC1.N15 165.63,95.79 v1(165.63,95.68) 165.63,95.57 UC1.P15 ; v1(165.62,96.52) 165.62,96.42 UC1.N16
  vias: v1(172.92,113.14) v1(172.92,112.55) v1(173.5,113.14) v1(173.5,112.55) v1(174.09,113.14) v1(174.09,112.55) v2(173.64,114.16)
+1.0V_PRIM: length 87.7
  TOP w0.508: v1(163.02,91.49) 163.02,91.67 162.39,92.29 CC206.1 ; CC286.1 160.83,72.79 v1(161.65,72.79) ; CC285.1 164.13,119.78 162.85,119.78 161.97,120.66 161.97,121.71 v1(161.42,122.26)
  TOP w0.762: 132.6,127.33 132.6,126.91 131.49,125.8 127.66,125.8 v3(127.48,125.62) 126.99,125.13 117.17,125.13 115.84,123.8 114.42,123.8 113.81,124.41
  IN2 w0.508: v1(161.42,122.26) 161.75,122.6 161.75,124.2 157.51,128.44 157.51,135.76 156.55,136.73 142.04,136.73 134.02,128.71 133.04,128.71 132.6,128.27 v1(132.6,128.08)
  IN3 w0.508: v1(161.65,72.79) 161.22,72.79 160.64,73.37 160.64,82.65
  BOTTOM w0.254: UC1.AB17 UC1.Y18 v1(164.32,93.16) ; UC1.P18 v1(164.32,94.84) ; UC1.AK20 v1(162.37,88.13) ; UC1.AB20 v1(163.02,91.49) UC1.AB19 v1(163.67,91.49)
  vias: v1(165.36,118.06) v1(165.94,118.63) v1(165.94,118.06) v1(166.51,118.63) v1(166.51,118.06) v1(167.08,118.63) v1(167.08,118.06) v1(192.86,94.85) v1(193.46,94.85) v1(223.9,95.09) v1(223.9,94.46) v1(224.48,95.09) v1(224.48,94.46) v1(225.07,95.09) v1(225.07,94.46) v1(225.65,95.09) v1(225.65,94.46)
+1.0V_PRIM_CORE: length 29
  TOP w0.508: CC205.1 163.27,90.65 v1(163.67,90.65)
  IN3 w1.016: 166.96,109.47 167.21,109.71 169.67,109.71 171.34,108.03 180.24,108.03 181.2,109 189.16,109 191.31,106.85
  BOTTOM w0.254: UC1.V21 162.12,93.51 162.62,93.51 UC1.V20 ; UC1.V21 v1(161.72,94) ; UC1.V21 v1(161.49,93.33)
  vias: v1(159.97,107.53) v1(160.37,107.93) v1(163.67,89.81) v1(165.73,108.78) v1(165.73,108.22) v1(190.54,90.88) v1(191.17,105.95) v1(191.12,90.88) v1(191.73,105.94) v1(191.7,90.89) v1(192.29,90.89) v1(192.89,90.89) v1(193.47,90.89) v1(233.09,93.63) v1(233.09,93) v1(233.65,93.62) v1(233.65,92.99) v1(234.21,93.62) v1(234.21,92.99) v2(232.53,93.66)
+1.0V_PRIM_COREP: length 5
  TOP w0.102: 235,88.27 234.6,88.27 v3(234.46,88.13)
  TOP w0.254: PU402.1 239.8,92.57 v1(239.43,92.93)
  IN4 w0.254: v1(239.43,89.44) v1(239.43,92.93)
+1.0V_PRIM_XDP: length 86.4
  TOP w0.381: CC29.1 129.55,124.49 v1(129.5,124.54) 129.59,124.63 CC28.1
  TOP w0.508: v1(121.63,124.16) 121.23,123.77 v2(118.65,123.77) 116.82,121.94 115.2,121.94 114.92,121.66 113.23,121.66 111.95,122.94 111.95,124.15 112.37,124.57 RC216.2 111.57,125.38 v1(110.91,126.04) ; v1(171.59,113.09) 172.07,112.61 RC115.2
  IN2 w0.508: v1(121.63,124.16) 122.55,125.09 127.82,125.09 128.37,124.54 v1(129.5,124.54) 129.5,125 130.03,125.54 134.21,125.54 135.87,127.2 147.38,127.2 149.21,125.37 149.21,122.56 149.57,122.21 150.43,122.21 151.1,122.88 154.28,122.88 156.47,120.69 156.47,117.23 v1(157.12,116.58)
  IN3 w0.508: v1(157.12,116.58) 159.15,116.58 161.87,113.86 170.81,113.86 v1(171.59,113.09)
  BOTTOM w0.305: JXDP1.44 128.89,121.97 129.5,122.58 v1(129.5,124.54) 128.89,125.16 JXDP1.43
  BOTTOM w0.508: RC138.1 110.96,125.99 v1(110.91,126.04)
+1.0V_RUN_VMM: length 2.9
  TOP w0.102: v1(225.85,111.97) 226.08,111.97 v2(226.59,112.48)
  BOTTOM w0.508: RV661.1 220.19,109.09
+1.0V_SRAM: length 4.3
  TOP w0.102: RC309.2 v2(178.18,111.35)
  TOP w0.508: CC217.1 162.16,91.42 162.37,91.22 v1(162.37,90.65)
  BOTTOM w0.254: UC1.AF20 162.69,90.32 v1(162.37,90.65) 162.04,90.33 UC1.AF21 ; UC1.T20 v1(162.98,94.03) UC1.T19
  vias: v1(175.93,111.82) v1(175.94,111.25)
+1.0V_VCCST: length 187.2
  TOP w0.508: v1(161.72,97.35) 161.72,98.04 161.19,98.57 CC202.1
  TOP w0.762: v1(151.07,112.92) 151.07,111.23 151.79,110.51 156.56,110.51 157.17,111.12 157.17,112.78 v3(157.07,112.89) 157.07,114.63 156.18,115.52 v1(156.18,116.05)
  IN1 w0.508: v1(123.29,114.64) 123.2,114.55 123.2,113.52 124.14,112.58 124.9,112.58 125.09,112.77 125.71,112.77 126.32,112.16 126.32,110.73 126.81,110.24 129.46,110.24 129.75,110.54 130.57,110.54 v1(131.38,109.72)
  IN2 w0.762: 123.75,127.43 124.89,126.28 133.72,126.28 135.53,128.1 147.65,128.1 150.11,125.64 150.11,123.76
  IN3 w0.508: v1(81.21,84.27) 80.9,84.27 80.57,84.6 80.57,86 80.97,86.41 81.42,86.41 81.82,86.81 81.82,90.65 83.2,92.02 83.2,93.1 85.13,95.03 93.2,95.03 95.64,97.47 95.64,107.73 97.47,109.56 100.8,109.56 102.27,111.03 109.04,111.03 110.35,112.34 111.25,112.34 112.54,113.64 117.15,113.64 117.81,114.3 119.64,114.3 120.94,115.6 122.32,115.6 v1(123.29,114.64)
  IN3 w0.762: v1(149.88,122.88) 150,123 154.41,123 156.63,120.79 156.63,117.78 156.18,117.33 v1(156.18,116.05)
  IN4 w0.508: v1(131.38,109.72) 131.91,109.19 132.85,109.19 v1(133.45,109.79) 134.35,109.79 135.9,108.24 135.9,107.06 137.94,105.01 139.14,105.01 139.55,105.42 140.15,105.42 140.41,105.16 141.7,105.16 142.3,104.57 144.07,104.57 144.46,104.17 145.79,104.17 146.01,104.39 146.73,104.39 147.69,105.34 147.69,108.12 151.07,111.51 v1(151.07,112.92)
  BOTTOM w0.203: UC1.A18 v1(163.79,103.86) 163.79,103.9
  BOTTOM w0.254: UC1.K20 162.66,97.81 162.08,97.81 UC1.K21 162.04,97.68 v1(161.72,97.35) ; CC195.1 164.17,105.84 164.17,104.28 163.79,103.9
  BOTTOM w0.508: v1(81.21,84.27) 81.56,84.27 81.87,84.59 81.87,85.89 82.14,86.15 PC602.1 82.71,87.02 PR601.1 PR604.1 PR605.1 ; RC238.2 160.77,111.08 157.53,111.08 157.03,111.58 157.03,114.7 156.18,115.56 v1(156.18,116.05) ; RC71.1 130.86,109.2 v1(131.38,109.72)
  vias: v1(122.9,128.61)
+1.0V_VCCST_C:
  vias: v2(119.53,127.96)
+1.0V_VCCSTG: length 92.3
  TOP w0.508: v1(157.26,117.41) 158,116.67 v2(158,115.71) 158,113.95 CC199.1 159.22,112.34 158.96,112.09 158.96,111.51 RC143.2 158.62,111.5 v1(158,112.12)
  IN2 w0.508: v1(144.6,122.49) 143.48,122.49 143.01,122.96 139.3,122.96 136.78,120.43 136.71,120.43 136.7,120.44 v1(136.7,120.46)
  IN3 w0.508: v1(157.26,117.41) 157.44,117.59 157.44,121.24 154.95,123.73 145.17,123.73 144.6,123.16 v1(144.6,122.49) ; v1(158,112.12) 159.67,112.12 162.09,109.71 162.09,104.16 161.68,103.75 v1(161.3,103.75)
  IN4 w0.508: v1(138.97,110.14) 138.67,109.84 135.76,109.84 134.71,110.89 133.02,110.89 132.53,110.41 131.12,110.41 130.76,110.04 130.76,106.61 v1(130.78,106.59)
  BOTTOM w0.203: UC1.A22 161.31,103.74 v1(161.3,103.75)
  BOTTOM w0.508: RC82.1 142.5,109.41 ; 142.5,109.41 142.46,109.45 142.46,112.66 145.36,115.57 145.97,115.57 147.48,117.08 147.48,121.92 146.23,123.17 145.13,123.17 144.6,122.64 v1(144.6,122.49) 144.6,122.16 RC130.1 ; 142.5,109.41 141.73,109.41 140.83,110.31 RC81.1 139.14,110.31 v1(138.97,110.14) RC87.2 ; RC135.1 137.73,119.05 136.7,120.08 v1(136.7,120.46) 137.05,120.81 RC134.1 RC131.1 ; v1(130.78,106.59) 130.11,106.59 129.08,107.62 RC83.1
+1.0V_VCCSTG_C: length 0.8
  BOTTOM w0.102: 160.17,114.33 v2(160.98,114.33)
+1.0V_VCCSTG_R: length 17.8
  TOP w0.508: RC143.1 160.35,110.42 v1(160.14,110.22)
  IN1 w0.254: v1(160.14,110.22) 160.26,110.1 160.26,110.09 162.16,108.19 162.16,106.9 163.22,105.85 163.22,103.75 164.32,102.65 164.32,101.21 164.1,100.99 164.1,99.89 164.1,99.88 164.1,98.47 163.88,98.24 163.41,98.24 163.18,98.47 163.18,99.17 162.91,99.44 v1(162.72,99.44)
  BOTTOM w0.254: UC1.G20 v1(162.72,99.44)
+1.0V_VMM_VDD: length 7.7
  TOP w0.254: v1(214.34,117.42) 214.66,117.09 UV8.C8 ; UV8.H6 v1(218.24,115.47) ; UV8.E6 v1(215.64,115.47) ; v1(215.64,117.42) 215.96,117.09 UV8.E8 ; UV8.E3 v1(215.64,113.52) ; v1(215.64,118.07) 215.96,117.74 UV8.E9 ; v1(216.29,120.02) UV8.F12 UV8.G12 ; v1(218.24,116.12) 217.91,116.44 UV8.H7 ; UV8.G3 v1(217.59,113.52) ; UV8.E7 v1(215.64,116.12) ; v1(218.24,117.42) 217.91,117.1 UV8.H8 ; UV8.C9 214.66,117.74 v1(214.34,118.07) ; UV8.H9 217.91,117.75 v1(218.24,118.07) ; UV8.D3 v1(214.99,113.52)
  BOTTOM w0.508: v1(216.29,120.02) 216.31,119.99 CV84.1
  vias: v2(216.46,110.32)
+1.0V_VMM_VDDTX: length 8.9
  TOP w0.254: UV8.D12 215.31,119.69 v1(215.64,119.37) 215.96,119.69 UV8.E12 ; UV8.F3 v1(216.29,113.52) ; UV8.J10 218.57,118.39 v1(218.89,118.72) ; UV8.K10 219.21,118.39 v1(219.54,118.07) 219.21,117.75 UV8.K9 219.21,117.74 v1(219.54,117.42) 219.21,117.1 UV8.K8 ; UV8.C6 214.66,115.8 v1(214.34,116.12) UV8.C7 ; v1(218.24,113.52) 218.56,113.19 UV8.J2 218.56,113.19 v1(218.24,112.87)
  BOTTOM w0.102: v2(216.75,121.42) 215.62,120.29 CV92.1
  BOTTOM w0.508: CV92.1 215.62,119.38 v1(215.64,119.37) ; CV93.1 214.33,116.11 v1(214.34,116.12)
+1.0VO_DSW: length 2.5
  TOP w0.254: CC204.1 173.75,88.03 173.75,87.24 v2(173.92,87.07) 174.34,87.07 174.43,87.16 v1(174.43,87.17)
  BOTTOM w0.254: UC1.AL1 173.8,87.05 174.32,87.05 v1(174.43,87.17)
+1.0VS_VCCIO: length 216.1
  TOP w0.254: UV8.J3 v1(218.89,113.52) ; UV8.E5 v1(215.64,114.82)
  TOP w0.508: RC2.1 145.31,100.78 v1(145.37,100.72) ; QE11.1 265.87,53.12 v1(264.96,54.03) 264.34,54.66 RE90.1 ; v1(125.51,131.61) 125.32,131.42 RC132.1 ; v1(248.64,86.86) v3(251.71,86.86) 252.97,86.86 253.91,85.92 259.72,85.92 262,83.64 262,79.8 262.46,79.35 262.46,78.82 262.85,78.43 v1(263,78.43) 263,78.06 261.64,76.7 260.93,76.7 260.58,76.35 RE59.2
  IN1 w0.457: v1(142.9,107.4) 143.04,107.26 143.04,105.62 143.3,105.36 143.3,103.56 145.37,101.5 v1(145.37,100.72)
  IN1 w0.508: v1(218.89,113.52) 218.89,111.82 218.62,111.56 217.25,111.56 216.89,111.92 216.89,114.52 216.59,114.82 v1(215.64,114.82)
  IN2 w0.508: v1(145.26,122.47) 145.26,120.48 144.78,120 143.95,120 143.39,119.44 143.39,117.41 145.93,114.87
  IN3 w0.508: v1(136.99,122.32) 136.99,122.25 137.51,121.73 138.2,121.73 139.24,122.77 142.89,122.77 143.8,121.85 144.93,121.85 145.26,122.18 v1(145.26,122.47)
  IN4 w0.508: v1(133.49,127.1) 133.32,126.93 130.29,126.93 129.88,127.34 129.88,128.75 129.2,129.43 126.38,129.43 125.51,130.3 v1(125.51,131.61) ; v1(264.96,54.03) 265.49,53.5 267.73,53.5 269.87,55.65 269.87,58.24 270.86,59.23 270.86,63.56 271.47,64.17 271.47,65 272.81,66.34 272.81,67.38 273.81,68.38 273.81,69.85 278.79,74.83 278.79,76.95 275.79,79.96 270.74,79.96 269.7,78.92 263.89,78.92 263.41,78.43 v1(263,78.43)
  BOTTOM w0.203: UC1.AK28 157.47,88.11 v1(157.24,88.11) ; UC1.AK30 157.01,88.11 v1(157.24,88.11) ; v1(157.24,88.11) UC1.AL30 ; UC1.AL30 v1(157.24,86.56) ; UC1.AL30 156.78,86.97 UC1.AM30
  BOTTOM w0.254: v1(157.24,86.56) UC1.AM28 ; v1(149.92,86.56) UC1.AM42 v1(150.84,86.56) UC1.AL42 ; v1(156.32,86.56) UC1.AM30
  BOTTOM w0.508: v1(218.89,113.52) 220.65,113.52 220.89,113.76 222.54,113.76 ; v1(133.49,127.1) 133.92,126.67 133.92,124.76 136.35,122.32 v1(136.99,122.32) ; v1(147.01,113.77) 144.43,113.77 143.07,112.41 143.07,109.88 143.33,109.62 143.33,107.83 v1(142.9,107.4)
  BOTTOM w1.524: UV28.7 227.81,118.59 228.7,119.48 236.81,119.48 248.96,107.34 248.96,89.59 248.64,89.27 v1(248.64,86.86) 249.67,85.84 249.67,82.63 248.39,81.35 245.47,81.35 243.99,79.88 243.99,76.37 243.94,76.32
  vias: v1(236.41,54.62) v1(236.73,54.14) v1(237.04,54.62) v1(237.36,54.14) v1(237.68,54.62) v1(238,54.14) v1(238.31,54.62) v1(238.63,54.14)
+1.2V_LDO: length 10.4
  TOP w0.102: v3(263.2,75.89) 263.83,75.89 265.08,77.15 v1(265.08,77.22)
  TOP w0.203: 266.82,77.5 267.32,78 UR2.10
  TOP w0.508: v1(265.08,77.22) 265.11,77.2 CR13.1 266.52,77.2 266.82,77.5
  IN4 w0.508: v1(269.48,77.02) 269.1,76.64 266.64,76.64 266.06,77.22 v1(265.08,77.22)
+1.2V_MEM: length 104.7
  TOP w0.508: v1(220.72,40.24) 220.38,39.9 CD94.1 ; v1(210.16,40.27) 210.32,40.1 CD103.1 ; CD79.1 130.1,40.03 v1(129.84,40.28)
  BOTTOM w0.152: UC1.BB41 151.29,80.08
  BOTTOM w0.178: UC1.BB23 161.24,80.97 161.24,79.81 v1(161.42,79.63) ; v1(156.25,80.02) 156.25,80.98 UC1.BB32
  BOTTOM w0.203: v1(147.67,79.97) 147.63,80.01 UC1.BB47 ; UC1.BB51 145.17,80.02 v1(145.19,80.01)
  BOTTOM w0.254: v1(159.98,84) 160.28,83.7 UC1.AU23 ; UC1.AU42 150.1,83.7 v1(149.93,83.87) ; v1(153.58,84) 153.88,83.7 UC1.AU35 ; UC1.AU28 157.54,83.7 v1(157.24,84) ; v1(151.27,79.13) 151.27,80.07 151.29,80.08
  BOTTOM w0.305: JDIMM2.129 v1(195.97,51.26) ; JDIMM2.141 198.97,51.51 198.82,51.66 197.47,51.66 v1(197,51.19) 197.48,50.71 JDIMM2.135 ; JDIMM1.123 113.88,50.65 114.49,51.27 v1(115.22,51.27) 115.37,51.12 JDIMM1.129 ; JDIMM2.148 v1(202.73,40.24) ; JDIMM2.123 194.48,50.99 194.03,51.43 v1(192.97,51.43) JDIMM2.117 ; v1(167.45,40.31) 167.13,40.31 166.73,40.71 JDIMM2.12 ; JDIMM1.117 112.37,51.09 112.21,51.26 v1(110.88,51.26) JDIMM1.111 ; v1(205.55,40.22) 205.73,40.39 JDIMM2.160 ; JDIMM1.112 v1(111.12,40.43) ; v1(117.37,40.42) 117.37,40.56 117.12,40.81 JDIMM1.136 ; JDIMM2.154 v1(204.23,40.24) ; JDIMM1.199 134.88,50.91 v1(134.43,51.35) ; v1(139.63,40.27) 140.12,40.76 JDIMM1.220 ; JDIMM2.199 v1(215.48,51.26) ; JDIMM1.163 v1(125.88,51.39) ; JDIMM2.241 v1(225.97,51.26) ; JDIMM1.142 v1(118.63,40.43) ; JDIMM2.163 206.48,50.92 v1(206.21,51.18) 205.61,51.18 205.48,51.04 JDIMM2.159 ; JDIMM2.220 v1(220.72,40.24) ; JDIMM1.54 v1(96.62,40.43) ; JDIMM2.147 202.48,51.93 v1(202.6,52.05) 203.85,52.05 203.97,51.92 JDIMM2.153 ; JDIMM1.159 v1(124.88,51.39) ; JDIMM1.12 v1(86.13,40.43) ; JDIMM2.54 v1(177.22,40.24) ; v1(210.16,40.27) 210.23,40.34 JDIMM2.178 ; JDIMM1.147 121.88,51.2 v1(122.08,51.4) 122.7,51.4 123.37,50.72 JDIMM1.153 ; JDIMM1.178 129.63,40.66 129.84,40.45 v1(129.84,40.28) ; v1(171.97,51.28) 171.97,51.29 171.98,51.28 JDIMM2.33 ; JDIMM1.135 v1(116.88,51.26) 118.01,51.26 118.37,50.9 JDIMM1.141 ; JDIMM2.118 193.22,40.51 v1(192.99,40.27) 192.1,40.27 191.73,40.65 JDIMM2.112 ; JDIMM1.33 v1(91.37,51.08) ; JDIMM1.241 v1(145.37,51.26) ; JDIMM1.148 v1(122.12,40.43) ; JDIMM2.142 199.23,40.49 v1(199,40.27) 198.07,40.27 197.73,40.62 JDIMM2.136 ; JDIMM1.154 v1(123.63,40.43) ; JDIMM1.124 v1(114.12,40.43) ; JDIMM1.96 v1(107.13,40.43) ; JDIMM1.75 v1(101.88,51.08) ; JDIMM1.160 125.12,40.81 124.9,40.59 v1(124.9,40.45) ; JDIMM1.118 v1(112.62,40.43) ; JDIMM2.124 194.73,40.76 195.2,40.28 v1(195.54,40.28) 195.95,40.28 196.23,40.56 JDIMM2.130 ; JDIMM2.111 v1(191.48,51.28) ; JDIMM2.96 v1(187.73,40.27) ; JDIMM1.130 v1(115.63,40.43) ; JDIMM2.75 v1(182.48,51.28)
  vias: v3(205.46,56.3)
+1.2V_MEM_CPUCLK: length 1.4
  TOP w0.102: v2(151.93,85.91) 152.19,86.18 152.19,86.62
  BOTTOM w0.254: UC1.AM40 151.36,86.95 v1(151.75,86.56)
+1.2V_MEN_P: length 47.4
  TOP w0.254: 80.36,60.17 80.36,76.03 78.18,78.22 PC213.1 76.93,78.76 77.29,79.12 77.29,79.97 76.86,80.4 PR206.2 PC212.2 75.26,80.4 74.58,79.73 v1(74.58,78.85)
  BOTTOM w0.254: v1(74.58,78.85) 73.82,78.09 73.82,77.19 74,77.01 PU201.5
  BOTTOM w0.508: 72.04,59.98 69.72,59.98 68.2,61.5 68.2,68.48 70.23,70.52 74.39,70.52
  vias: v1(75.13,58.84) v1(76.05,58.84) v1(76.78,58.84) v1(77.67,59.25) v1(77.68,58.2) v1(77.98,58.73) v1(78.31,59.25) v1(78.32,58.2) v1(78.61,58.73) v1(78.94,59.25) v1(78.95,58.2) v1(79.25,58.73) v1(79.58,59.25) v1(79.88,58.73) v1(80.2,59.29) v2(79.54,53.82)
+1.5V_RUN: length 101.9
  TOP w0.508: 298.33,20.48 298.33,21.97 v3(297.95,22.35) 297.43,22.87 286.66,22.87 285.02,24.51 285.02,26.2 284.54,26.68 v1(284.26,26.68) ; v1(293.53,84.26) 291.06,81.79 RA3.1
  IN4 w0.508: v1(293.53,84.26) 292.78,83.51 290.89,83.51 285.04,77.66 285.04,75.17 286.2,74 286.2,66.21 284.48,64.49 278.29,64.49 277.48,63.67 277.48,62.57 277.94,62.11 277.94,59.72 276.43,58.21 276.43,55.06 274.03,52.66 274.03,50.3 273.53,49.81 273.53,48.31 276.43,45.41 276.43,44.33 281.15,39.61 281.15,27.59 281.7,27.05 283.89,27.05 v1(284.26,26.68)
+1.5V_RUN_AUDIO:
  vias: v2(290.27,74.44)
+1.5V_VIN: length 0.4
  TOP w0.102: 291.27,20.99 v2(291.27,21.43)
+1.8V_PGPPF: length 7.7
  TOP w0.381: v1(165.63,90.65) 165.63,90.9 166,91.26 166.63,91.26 v2(166.86,91.03) 170.56,91.03 170.76,91.23 171.88,91.23 RC304.2
  BOTTOM w0.254: UC1.AF16 v1(165.63,90.65)
+1.8V_PRIM: length 203.5
  TOP w0.381: RC313.1 170.69,93.79 171.28,93.19 171.93,93.19 172.3,92.82 172.3,92.31 172.7,91.91 172.7,91.66 173.02,91.35
  IN1 w1.016: 188.66,107.03 188.66,98.64 189,98.29 189,92.86 186.99,90.85 185.14,90.85
  IN2 w1.016: 184.87,90.37 185.64,90.37 187.69,88.31 187.69,85.42 190.2,82.91 191.77,82.91 193.06,81.62 193.06,79.17 194.73,77.5 194.73,75.02 193.94,74.23 193.35,74.23 192.66,73.53
  IN3 w2.032: 244.61,53.23 245.79,52.05 245.79,49.61 244.49,48.31 244.49,44.84 245.71,43.61 247.07,43.61 248.36,42.33 254.84,42.33 257.2,44.69 262.61,44.69 263.37,43.93 268.58,43.93 275.18,37.32 275.18,11.98 276.44,10.73 276.44,3.67 ; 190.99,70.62 190.99,68.36 193.82,65.53 211.79,65.53 217.02,60.3 227.53,60.3 231.58,56.24 237.69,56.24
  BOTTOM w0.203: v1(174.91,92.22) 174.73,92.41 UC1.AA1
  BOTTOM w1.016: 210.51,104.2 210.5,104.19 198.94,104.19 197.46,105.67 194.22,105.67 192.2,107.69 189.37,107.69
  vias: v1(175.47,92.22) v1(183.98,91.23) v1(184,90.67) v1(187.77,107.88) v1(188.36,107.88) v1(190.04,72.02) v1(190.62,72.02) v1(191.22,72.02) v1(191.8,72.02) v1(277.86,3.82) v1(277.86,3.23) v1(278.46,3.82) v1(278.46,3.23) v2(190.92,73.02)
+1.8V_RUN_CARD: length 69.8
  TOP w0.203: UR2.13 268.52,77.36 268.5,77.34 v1(268.5,77.34)
  TOP w0.762: v1(295.89,85.35) 296.39,84.86 298.18,84.86 303.28,79.76 v3(303.28,73.59) v3(303.28,61.69) 303.28,61.29 301.6,59.61 v3(301.6,59.6) 301.6,58.07
  IN1 w0.762: v1(295.89,85.35) 295.26,85.99 289.61,85.99 288.53,84.91 286.07,84.91 282.48,88.49 277.84,88.49 v1(277.82,88.5)
  IN3 w0.762: v1(268.5,77.34) 268.5,77.54 271.02,80.06 273.09,80.06 275.63,82.59 275.63,86.31 v1(277.82,88.5)
  vias: v1(301.34,55.15)
+1.8VALWP: length 11.5
  TOP w0.102: 283.58,5.34 283.58,5.61 v3(283.08,6.1)
  TOP w0.508: v1(289.98,6.7) 290.88,7.6 PC503.1 PR501.1
  BOTTOM w0.508: v1(289.98,6.7) 285.45,6.7 v1(284.02,5.27)
+1VALWP: length 13.8
  TOP w0.254: v1(232.1,85.51) PR306.1 231.51,84.58 PC307.1
  IN1 w0.254: v1(232.1,85.51) 231.18,86.43 231.18,91.03 230.35,91.86 225.14,91.86 v1(225.13,91.87)
  vias: v1(222.86,91.88) v1(223.43,91.88) v1(223.99,91.87) v1(223.99,91.28) v1(224.56,91.87) v1(224.56,91.28) v1(225.13,91.28) v3(225.68,91.6)
+1VALWP_B+: length 1.5
  TOP w0.102: v2(223.58,77.69) 223.77,77.89 PC306.1
+1VS_VCCIOP: length 14.9
  TOP w0.102: 239.33,52.21 v3(240.38,52.21)
  TOP w0.254: PR421.1 v1(233.13,45.98) ; PU401.1 238.43,47.1 v1(238.73,47.41)
  IN4 w0.254: v1(233.13,45.98) 233.13,46.81 234.93,48.61 234.93,50.63 235.65,51.34 237.98,51.34 v1(238.73,50.59) ; v1(238.73,50.02) v1(238.73,47.41)
+2.5V_MEM: length 112.5
  TOP w0.102: 151.74,47.27 151.75,47.27 151.75,46.78 v2(151.63,46.66)
  IN3 w1.016: 151.81,47.52 154.75,47.52 161.73,40.53 165.97,40.53 167.24,39.26 193.2,39.26 193.77,39.84 194.71,39.84 195.29,39.26 221.9,39.26 223.84,41.2 227.36,41.2 229.02,42.86 229.02,43.28 230.3,44.56 230.3,46.17 231.28,47.15 231.28,49.03 ; 232.5,49.46 234.27,49.46 235.94,47.8 235.94,43.28 239.23,39.99 242.05,39.99 243.33,41.27 246.19,41.27 247.16,40.29
  vias: v1(149.83,47.33) v1(150.44,47.33) v1(231.13,50.48) v1(231.13,49.84) v1(247.19,39.24) v1(247.76,39.24)
+2.5V_VIN:
  vias: v2(259.61,43.67)
+3.3V_1.8V_PGPPA: length 0.7
  BOTTOM w0.254: UC1.AK15 v1(166.38,87.18)
  vias: v1(187.72,76.08) v1(188.3,76.07) v2(187.77,75.18)
+3.3V_1.8V_PGPPG: length 25.9
  IN2 w0.508: v1(166.27,90.65) 166.53,90.65 169.4,87.78 172.6,87.78 173.96,86.42 177.52,86.42 178.5,87.4 178.5,88.02 179.21,88.73 183.8,88.73 v1(184.16,89.09)
  BOTTOM w0.254: v1(166.27,90.65) UC1.AD15
  BOTTOM w0.508: RC235.2 181.51,91.03 RC234.2 181.85,90.5 182.44,89.91 v2(182.44,89.64) 182.99,89.09 v1(184.16,89.09)
+3.3V_ALW: length 199.6
  TOP w0.102: v3(76.78,45.28) 77.38,44.69 v1(77.38,44.67)
  TOP w0.254: v1(244.32,73.26) 244.63,73.57 RPE5.7
  TOP w0.381: v1(278.95,6.07) 279.09,6.21 CZ28.1 ; PR905.1 66.34,71.33 66.03,71.65 PU902.5 ; UE4.5 246.36,80.72 246.11,80.97 v1(246.11,82.55)
  TOP w0.406: UC14.5 86.89,118.26 87.11,118.04 CZ115.1 ; v1(246.11,82.55) 246.7,83.14 249.3,83.14 249.69,82.75 UE3.5 ; UZ10.5 285.38,15.67 CZ48.1 ; UE5.5 252.56,54.2 252.27,54.5 v1(252.02,54.5)
  TOP w0.457: CE52.1 251.59,54.92 v1(252.02,54.5)
  TOP w0.508: RE73.1 RE74.1 v1(281.26,7.62) ; PR3.1 70.28,39.23 v1(70.77,39.72) ; RE71.1 274.06,18.6 v1(273.72,18.94) ; v1(281.28,10.51) 281.06,10.28 RE72.1 RE75.1 ; v1(242.02,62.67) 241.28,62.67 RE8.1 RE300.1 ; PR931.2 v1(94.9,72.81) 95.53,72.18 95.53,68.63 95.86,68.3 97.7,68.3 98.85,69.45 PR913.1 ; PR903.1 PR905.1 PC903.2 68.49,71.33 68.55,71.27 v1(68.73,71.27) ; 248.66,45.54 248.31,45.18 248.31,42.3 246.59,40.59 246.59,39.19 246.18,38.77 243.79,38.77 243.24,39.33 v1(243.24,39.63) 243.24,42.46 243.79,43.01 243.79,44.85 242.75,45.89 PR404.1 ; v1(247.35,58.27) 247.85,58.77 RE68.1 ; v1(258.39,77.2) 257.52,77.2 256.66,76.35 RE301.2 ; v1(231.45,40.22) 231.8,39.87 PR414.1 PR413.1 ; PR417.1 v1(243.1,85.86) ; RE5.1 RE36.1 227.05,76.21 228.57,77.73 v1(228.57,77.97) ; RZ24.1 281.26,19.02 v1(281.26,18.5) ; CZ115.1 87.16,117.12 v1(87.16,116.44) ; v1(258.48,79.31) 258.8,78.99 RE63.1 ; v1(61.69,63.06) 60.53,63.06 60.17,62.7 PR834.2 ; CZ48.1 v1(285.39,14.94) ; RE69.1 258.96,58.15 258.96,57.67 v1(258.85,57.55) ; PR410.1 v1(242.61,96.81) ; RE298.2 RE84.2 233.73,58.05 233.88,57.9 v1(233.88,57.6) 233.88,57.37 233.53,57.02 231.65,57.02 231.11,57.55 231.11,58.5 RE10.1 RE9.1 230.17,57.87 229.51,57.21 227.84,57.21 227.39,57.65 227.39,58.39 RE25.1 ; PR307.1 v1(232.13,86.39) ; PR418.1 v1(245.77,85.89) 245.44,85.56 245.02,85.56 243.3,83.84 242.94,83.84 242.28,83.18 242.28,82.83 RE81.1 ; PR6.2 v1(77.9,120.23) ; PR902.1 v1(66.77,67.85) ; RD30.2 v1(81.63,43.02)
  IN1 w0.508: v1(77.38,44.67) 76.24,43.53 74.58,43.53 v1(70.77,39.72)
  IN2 w0.508: v1(74.39,60.32) 74.01,60.7 69,60.7 68.11,61.59 68.11,67.22 67.47,67.85 v1(66.77,67.85) 66.77,67.41 62.43,63.06 v1(61.69,63.06)
  IN3 w0.457: v1(252.02,54.5) 252.11,54.59 257.42,54.59 257.8,54.21 261.51,54.21 263.28,55.98 263.28,58.24 v1(263.76,58.72)
  IN3 w0.508: 194.31,78.63 194.36,78.58 194.36,74.57 192.97,73.19 190.32,73.19 188.94,71.8 188.94,66.81 188.5,66.38 183.77,66.38 182.33,64.94 v1(182.33,64.13)
  IN4 w0.508: v1(243.24,39.63) 240.13,39.63 238.62,41.14 232.99,41.14 232.06,40.22 v1(231.45,40.22)
  BOTTOM w0.305: v1(278.95,6.07) 279.16,6.27 JKBTP1.6
  BOTTOM w0.406: v1(159.71,122.02) 159.51,121.82 159.51,121.29 159.72,121.08 UC13.5
  BOTTOM w0.508: PR107.1 215.24,81.62 v1(215.22,81.61) ; v1(218.42,65.87) 218.42,66.58 v1(223.97,72.13) ; v1(68.73,71.27) 68.7,71.29 67.17,71.29 66.16,70.29 66.16,68.46 v1(66.77,67.85) ; PR113.1 206.74,83.5 v1(206.58,83.33) ; v1(290.9,11.41) RZ9.1 RZ8.1 ; v1(285.39,14.94) 286,15.55 287.12,15.55 287.52,15.15 JLED1.8 ; CZ12.1 v1(287.58,11.41)
  vias: v1(86.9,115.9) v1(87.49,115.9) v1(87.74,116.44) v1(88.81,106.21) v1(89.13,105.7) v1(89.38,106.21) v1(194.87,78.67) v1(195.44,78.67) v1(197.55,78.7) v1(215.78,101.94) v1(215.78,101.33) v1(216.42,101.94) v1(216.42,101.33) v1(217.05,101.94) v1(217.05,101.33) v1(217.69,101.94) v1(217.69,101.33) v1(218.32,101.94) v1(218.32,101.33) v1(218.96,101.94) v1(218.96,101.33) v1(229.78,80.74) v1(242.26,70.19) v1(244.76,67.73) v1(249.39,48.52) v1(249.39,45.97) v1(249.96,48.52) v1(249.96,47.9) v1(249.95,46.59) v1(249.95,45.97) v1(250.53,48.54) v1(250.53,47.91) v1(250.52,46.6) v1(250.52,45.98) v1(263.76,59.29) v1(264.45,46.96) v1(264.72,73.05) v1(264.78,47.41) v1(276.53,18.53) v1(287.59,109.42) v1(287.69,111.86) v1(287.6,108.85) v1(287.91,108.34) v1(288.17,109.41) v1(288.19,108.83) v1(288.26,111.86) v1(290.9,9.34) v1(291.23,9.85) v1(291.51,9.34) v1(296.58,4.53) v1(296.58,3.95) v1(297.18,4.53) v1(297.18,3.95) v3(87.45,104.77) v3(181.72,64.16)
+3.3V_ALW2: length 591.3
  TOP w0.406: PU903.5 104.05,70.92 PC905.2
  TOP w0.508: v1(245.27,84.87) 246.48,84.87 247.8,86.19 252.58,86.19 254.35,84.41 256.8,84.41 257.53,85.14 v1(259.05,85.14) 259.05,83.58 258.63,83.16 258.63,81.17 257.02,79.56 RE57.2 ; PR920.1 v1(88.29,62.3) 89.21,61.38 91.67,61.38 92.3,62.01 PR932.1 93.57,63.08 v3(95.3,64.8) 98.27,67.78 103.46,67.78 105.64,69.95 105.64,72.86 ; 105.64,72.86 PR914.1 PC905.2 ; 105.64,72.86 105.64,73.85 104.96,74.52 100.56,74.52 100.05,74.01 PR909.2 ; PR917.1 v1(9.12,59.47) ; PR104.2 213.42,83.7 213.15,83.43 213.15,80.91 v1(213.61,80.45)
  IN1 w0.508: v1(290.88,12.82) 290.88,21.86 289.95,22.78 286.58,22.78 284.93,24.42 284.93,26.97 284.07,27.83 279.88,27.83 276.49,31.23 276.49,46.41 v1(274.86,48.04) ; v1(259.05,85.14) 261.55,85.14 263.81,82.88 263.81,79.85 264.45,79.22 265.5,79.22 266.06,79.78 266.06,83.19 268.56,85.7 279.33,85.7 279.87,85.16 281.87,85.16 v1(283.02,86.31)
  IN2 w0.508: v1(61.63,60.88) 61.63,59.91 61.92,59.62 63.83,59.62 64.59,58.86 64.59,58.33 65.53,57.39 65.97,57.39 66.66,58.07 70.98,58.07 72.17,56.88 77.09,56.88 77.41,57.21 79.53,57.21 85.07,62.75 87.84,62.75 v1(88.29,62.3) ; v1(9.12,59.47) 9.33,59.69 14.95,59.69 16.48,58.15 18.98,58.15 20.34,59.51 34.71,59.51 36.51,57.7 47.57,57.7 v1(47.85,57.43) ; v1(91.22,57.94) 206.73,57.94 v1(214.39,65.6) ; v1(213.61,80.45) 213.8,80.45 214.32,79.93 214.32,77.15 212.9,75.73 210.73,75.73 209.06,74.06 209.06,70.96 v1(211.33,68.7)
  IN3 w0.508: v1(175.94,124.01) 175.94,123.62 176.54,123.02 177.39,123.02 179.7,120.71 185.07,120.71 188.35,123.99 192.27,123.99 195.81,120.44 199.9,120.44 200.56,119.78 203.46,119.78 206.5,122.83 208.39,122.83 210.9,125.34 227.01,125.34 229.55,122.8 v1(229.55,118.26) ; v1(274.86,48.04) 275.38,48.56 275.38,50 274.58,50.8 274.58,52.38 282.35,60.14 284.72,60.14 285.65,61.07 285.65,62.84 286.53,63.73 286.53,74.37 286.7,74.53 286.7,82.62 v1(283.02,86.31)
  IN4 w0.508: v1(245.27,84.87) 244.48,84.87 240,80.4 231.8,80.4 230.78,81.42 229.05,81.42 227.56,79.92 222.53,79.92 221.36,78.75 215.5,78.75 213.8,80.45 v1(213.61,80.45) ; v1(47.85,57.43) 47.85,57.79 49.38,59.32 50.33,59.32 51.6,60.59 57.76,60.59 58.21,61.04 61.47,61.04 v1(61.63,60.88)
  BOTTOM w0.381: RZ84.1 286.95,10.74 CZ24.1 286.95,11.63 287.4,12.07
  BOTTOM w0.508: v1(245.27,84.87) 245.61,85.21 246.77,85.21 247.39,85.84 247.39,89.66 247.84,90.1 247.84,102.4 247.03,103.21 247.03,107.69 243.2,111.51 234.24,111.51 232.98,112.77 232.98,114.83 v1(229.55,118.26) ; v1(290.88,12.82) 288.6,12.82 287.86,12.07 287.4,12.07 ; v1(175.94,124.01) 175.94,123.4 R272.2 ; v1(88.29,62.3) 91.22,59.37 v1(91.22,57.94) ; v1(211.33,68.7) 211.33,66.72 212.44,65.6 v1(214.39,65.6)
+3.3V_ALW2_R: length 0.8
  TOP w0.102: v2(284.87,10.02) 285.37,10.51 v1(285.37,10.64)
+3.3V_ALW_DSW: length 246.6
  TOP w0.508: 184.45,66.07 184.45,66.08 184.45,67.04 184.67,67.26 184.67,69.2 185.05,69.58 RC243.2 ; v1(170.1,69.47) 171.84,67.74 175.32,67.74 175.56,67.98 175.56,68.51 175.77,68.72 RC67.1 176.49,68.91 178.37,68.91 178.83,69.36 180.52,69.36 CC279.1 180.85,69.07
  IN2 w0.508: v1(66.8,57.35) 66.91,57.46 70.72,57.46 71.91,56.27 77.34,56.27 77.47,56.41 79.59,56.41 84.62,61.44 91.25,61.44 93.36,63.55 99.49,63.55 99.84,63.19 164.56,63.19 170.1,68.73 v1(170.1,69.47) 169.66,69.91 169.66,73.85 169.93,74.12 169.93,76.99 168.59,78.33 v1(168.59,79.79)
  IN4 w0.508: v1(96.87,101.84) 92.8,101.84 91.84,102.79 84.78,102.79 76.35,94.37 76.35,84.9 68.69,77.24 68.69,74.76 62.72,68.79 62.72,62.51 63.64,61.59 63.64,60.45 64.55,59.53 66.04,59.53 66.71,58.86 66.71,57.44 v1(66.8,57.35) ; v1(114.58,122.25) 113.24,122.25 112.19,121.19 112.19,113.34 111.02,112.16 103.29,112.16 v1(102.14,113.31)
  BOTTOM w0.254: UC1.AD18 164.27,90.73 v1(164.33,90.65) UC1.AD17 ; UC1.AJ17 v1(164.32,88.13)
  BOTTOM w0.508: v1(102.14,113.31) 102.14,112.87 98.85,109.58 98.85,107.72 96.87,105.74 v1(96.87,101.84) ; v1(114.58,122.25) 112.53,122.25 RC241.1
+3.3V_ALW_PCH: length 305.2
  TOP w0.305: JAPS1.1 183.56,63.29 183.27,63.57 v1(183.27,64.13)
  TOP w0.381: v1(130.68,129.31) 130.83,129.15 v3(130.83,128.24) 130.83,127.14 RC133.1
  TOP w0.457: CC209.1 163.27,92.77 163.02,93.02 v1(163.02,93.11)
  TOP w0.508: RC346.1 179.98,114.6 181.03,115.65 ; v1(161.59,88.85) 161.6,88.86 CC215.1 ; v1(223.5,58.53) 223.5,60.79 221.62,62.68 ; RC187.1 162.01,70.86 v1(162.69,71.55) ; v1(202.89,88.52) 201.41,90 201.1,90 200.44,90.66 200.05,90.66 197.2,93.51 v1(196.9,93.51) ; 188.08,98.72 189.18,99.82 189.18,102.28 190.52,103.63 RC341.2 189.67,104.45 189.09,105.04 189.09,107.08 189.54,107.54 189.54,109.93 183.83,115.65 181.03,115.65 ; v1(254.45,87.69) 254.76,87.69 255.06,87.99 RC347.2 RC348.2 ; 181.03,115.65 179.96,116.72 176.27,116.72 v1(175.22,117.78) ; v1(178.24,67.94) 178.65,67.94 179.37,68.66 RC344.2 ; RC73.2 v1(174.6,73.22) ; RC183.1 184.53,73.3 183.62,72.39 RC186.1 183.26,72.24 183.52,71.98 v1(183.52,71.69) ; RC26.2 v1(171.93,73.22)
  IN1 w0.508: v1(183.27,64.13) 183.27,64.73 183.89,65.35 198.24,65.35 205.62,57.97 222.95,57.97 v1(223.5,58.53)
  IN2 w0.508: v1(184.07,67.91) 184.08,67.89 184.08,67.59 184.11,67.56 184.11,65.97 183.27,65.13 v1(183.27,64.13)
  IN3 w0.508: 249.91,84.21 251.38,85.68 254.43,85.68 254.89,86.14 254.89,87.26 v1(254.45,87.69) ; v1(196.9,93.51) 196.02,92.63 196.02,90.83 196.28,90.57 196.28,86.03 195.65,85.4 194.46,85.4 193.25,84.2 193.25,80.8 192.15,79.7 192.15,75.61 190.33,73.8 190.07,73.8 188.37,72.1 v1(188.34,72.1) ; v1(202.89,88.52) 202.89,85.62 202.74,85.47 202.74,78.49 203.17,78.06 210.12,78.06 210.78,77.4 214.03,77.4 214.64,76.79 225.67,76.79 226.63,77.76 227.42,77.76 228.25,78.6 229.74,78.6 230.87,79.73 230.87,82.33 230.39,82.81 230.39,83.37 230.76,83.75 231.88,83.75 235.2,80.43 239.2,80.43 241.27,82.5 242.75,82.5 243.86,83.61 244.97,83.61 ; v1(178.06,127.07) 172.91,127.07 170.1,129.88 160.42,129.88 158.4,127.86 145.53,127.86 145.06,128.33 v1(145.06,128.88) ; v1(175.22,117.78) 176.51,119.07 184.93,119.07 187.49,121.62 189.3,121.62 v1(189.42,121.51)
  IN4 w0.508: v1(130.68,129.31) 130.91,129.08 132.92,129.08 133.26,128.74 134.44,128.74 135.04,128.14 144.32,128.14 v1(145.06,128.88)
  BOTTOM w0.254: UC1.AK17 v1(164.58,87.18) ; v1(177.79,74.72) 178.23,74.72 179.44,75.93 179.44,76.62 178.88,77.17 RC288.2 ; v1(163.02,93.11) UC1.V19 ; UC1.AJ21 v1(161.59,88.85)
  BOTTOM w0.508: RC289.2 202.96,88.59 v1(202.89,88.52) ; RC235.1 181.49,92.43 181.34,92.43 v1(180.9,92.86) ; v1(189.42,121.51) 189.11,121.81 189.11,123.26 191.36,125.51 191.36,127.5 189.98,128.88 184.97,128.88 184.08,128 RC222.1 184.08,126.63 183.03,125.57 178.98,125.57 178.06,126.49 v1(178.06,127.07) ; v1(177.95,90.84) 178.48,91.37 RC331.1 RC330.1 ; RC317.2 v1(183.28,86.64)
  vias: v1(186.07,88.46) v1(187.7,72.1)
+3.3V_ALW_PCH_UZ22: length 1
  TOP w0.102: v2(192.73,84.88) 192.92,84.69 192.92,83.96
+3.3V_ALW_UE1: length 102.2
  TOP w0.254: v1(231.81,60.44) 231.92,60.54 UE1.A54
  TOP w0.279: UE1.A43 226.8,65.73 v1(226.4,65.32) ; UE1.A17 236.92,72.95 v1(237.16,73.19)
  TOP w0.305: UE1.B30 231.17,70.93 v1(231.01,70.77) ; UE1.B5 v1(237.13,64.98)
  TOP w0.508: v1(228.83,74.33) CE6.1 ; v1(231.81,60.44) 231.95,60.3 CE2.1 ; v1(243.99,56.22) 243.43,56.78 243.43,57.79 243.99,58.35 243.99,62.43 v2(243.48,62.94) 242.64,63.77 242.64,64.99 242.03,65.6 240.5,65.6 240.1,65.21 240.1,64.74 240.46,64.38 v1(240.81,64.38) 241.02,64.18 CE3.1 ; v1(226.4,65.32) 226.4,63.06 CE5.1 ; CE4.1 v1(237.72,73.75)
  IN2 w0.508: v1(228.83,74.33) 228.83,74.09 229.68,73.24 229.68,72.11 v1(231.01,70.77) 231.25,70.53 231.25,69.66 230.16,68.56 229.16,68.56 227.99,67.39 227.99,66.48 227.49,65.99 226.84,65.99 226.4,65.54 v1(226.4,65.32) ; v1(237.16,73.19) 237.16,71.79 237.71,71.24 237.71,69.74 236,68.03 236,65.52 236.54,64.98 v1(237.13,64.98)
  IN3 w0.508: v1(243.99,56.22) 245.34,56.22 246.21,55.34 246.21,54.44 247.67,52.98 263.42,52.98 264.04,53.6 264.04,57.32 265.64,58.92 v1(266.3,58.92)
  IN4 w0.508: 229.92,64.45 235.38,64.45 235.91,64.98 v1(237.13,64.98) 237.72,64.38 v1(240.81,64.38) ; v1(237.72,73.75) v1(237.16,73.19)
  BOTTOM w0.508: v1(231.81,60.44) 231.81,61.09 231.01,61.9 226.29,61.9 224.85,63.33 224.85,64.52 225.42,65.1 226.17,65.1 v1(226.4,65.32)
+3.3V_ALW_UE2: length 77.7
  TOP w0.254: v1(256.73,73.19) 256.73,72.87 256.62,72.76 UE2.A52 ; UE2.A58 253.62,73.59 v1(254.23,74.19) ; UE2.A11 248.44,65.79 248.41,65.76 247.91,65.76 247.82,65.85 v1(247,65.85) ; UE2.A41 260.76,67.29 261.03,67.56 v1(261.83,67.56) 262.36,67.56 CE23.1 ; CE18.1 260.58,59.42 259.93,60.07 v2(259.93,60.24) ; v1(255.59,60.3) 255.39,60.3 255.12,60.57 UE2.A26
  TOP w0.305: v2(259.93,60.24) 259.93,60.81 v1(259.6,61.13) 259.6,62.71 259.27,63.04 UE2.B35 ; CE13.1 252.96,59.73 253.12,59.9 UE2.A22 ; v1(250.42,70.11) 250.34,70.04 UE2.B3
  TOP w0.381: CE22.1 256.46,59.42 v1(255.59,60.3) ; CE15.1 255.37,75.01 254.99,74.63 CE20.1 254.67,74.63 v1(254.23,74.19)
  TOP w0.508: CE16.1 246.4,65.85 v1(247,65.85) ; v1(252.32,59.46) 252.49,59.29 CE13.1 CE14.1 ; CE19.1 258.91,74.9 v1(258.91,74.42) ; CE17.1 247.03,71.79 v1(247.24,72)
  IN3 w0.508: v1(247.24,72) 247.34,72 249.23,70.11 v1(250.42,70.11) ; v1(259.6,61.13) 259.15,61.58 255.46,61.58 255,61.12 255,60.57 255.28,60.3 v1(255.59,60.3)
  IN4 w0.508: 262.94,67.29 262.67,67.56 v1(261.83,67.56) ; 262.94,67.29 263.22,67.01 263.22,64.29 262.55,63.62 260.72,63.62 258.98,61.88 255.42,61.88 254.98,61.44 254.98,60.59 255.27,60.3 v1(255.59,60.3) ; 262.94,67.29 262.94,68.59 263.36,69.01 263.36,73.67 262.05,74.98 259.47,74.98 v1(258.91,74.42)
  BOTTOM w0.508: 253.32,69.76 251.62,69.76 251.24,70.14 250.71,70.14 250.68,70.11 v1(250.42,70.11) ; v1(247,65.85) 246.21,66.64 246.21,71.23 246.64,71.66 246.89,71.66 v1(247.24,72) ; v1(252.32,59.46) 254.75,59.46 v1(255.59,60.3) ; v1(254.23,74.19) 253.29,73.25 253.29,71.64
+3.3V_ALWP: length 22
  IN4 w0.254: v1(214.58,86.58) 214.21,86.22 214.21,84.13 214.64,83.7 216.1,83.7 216.42,84.02 219.22,84.02 220.94,85.73 220.94,92.02 222.03,93.11 222.03,95.59 221.38,96.24 v1(220.94,96.24)
  vias: v1(219.72,96.24) v1(219.72,95.6) v1(220.36,96.24) v1(220.36,95.6) v1(220.94,95.6) v3(220.38,97.4)
+3.3V_CAM: length 7
  TOP w0.102: v3(99.62,109.64) 99.62,110.22 QZ1.1
  TOP w0.381: CZ1.1 98.97,113.49 v1(99.59,112.87)
  TOP w0.508: QZ1.1 100.59,111.86 v1(99.59,112.87)
  BOTTOM w0.254: 98.6,113.76 99.37,113.22 v1(99.59,112.87)
+3.3V_HDD: length 113.6
  TOP w0.254: 37.56,51.6 CN30.1 37.01,51.1 36.74,50.83 v1(36.74,50.2) ; 37.56,51.6 37.95,51.98 37.95,52.99 38.35,53.39 UN5.12 ; 37.56,51.6 37.56,51.27 RN57.1 ; UN4.24 29.23,56.27 29.75,56.8 RN42.1 ; v1(23.1,51.34) CN20.1 23.85,51.98 24.1,52.23 24.1,53.5 24.38,53.78 UN4.12 ; UN5.24 43.39,55.89 43.91,56.42 RN63.1
  TOP w0.508: RN28.1 21.78,56.42 v1(21.47,56.74) ; RN42.1 CN19.1 v1(30.57,58.59) ; v1(31.15,49.37) RN44.1 RN51.1 ; v1(45.95,52.68) 45.95,50.64 45.43,50.12 RN71.1 ; v1(43.66,56.99) 44.1,57.44 CN29.1 RN63.1 ; RN64.1 v1(43.91,55.41) ; RN69.1 v1(35.47,53.37) ; RN65.1 44.17,53.01 v1(43.95,53.01) ; v1(21.47,56.74) 22.04,57.31 RN26.1 ; v1(21.47,56.74) 20.86,57.34 20.86,59.74 21.89,60.77 24.46,60.77 24.86,60.36 RN25.1 ; RN37.1 15.83,38.63 16.62,39.42 18.49,39.42 20.14,41.07 21.27,41.07 21.28,41.08 ; RN55.1 v1(38.96,59.62) ; RN70.1 v1(43.91,54.39) ; RN58.1 35.85,56.04 v1(35.41,56.49) 35.85,56.93 RN56.1 ; RN43.1 v1(29.94,55.79) ; RN49.1 v1(21.56,53.76) ; RN50.1 v1(29.94,54.77) ; RN27.1 v1(23.78,49.37)
  IN2 w3.048: 80.81,110.85 80.81,100.33 78.48,98 77.49,98 74.46,94.97 74.46,84.43 67.35,77.31 67.35,75.07 64.87,72.6 64.87,72.3 57.38,64.8 57.19,64.8 53.19,60.8 50.63,60.8 49.43,59.6 48.68,59.6
  vias: v1(25.49,42.68) v1(25.49,42.1) v1(25.49,41.46) v1(25.49,40.83) v1(26.12,42.68) v1(26.12,42.1) v1(26.12,41.46) v1(26.12,40.83) v1(43.14,59.56) v1(43.72,59.56) v1(44.28,59.55) v1(44.87,59.55) v1(45.43,59.53) v1(46.01,59.53) v1(82.86,113.01) v1(82.85,111.98) v1(83.12,112.49) v1(83.42,113.01) v1(83.41,111.98) v1(83.68,112.49) v3(27.87,43.99)
+3.3V_HDD_P: length 3.5
  BOTTOM w0.102: v3(10.67,37.37) 10.16,36.86 v1(10.16,36.2) ; v3(22.46,38.01) 22.72,37.75 v1(23.37,37.75) 24.01,37.75 v3(24.32,38.06)
+3.3V_HDD_UZ4: length 1.3
  BOTTOM w0.102: 84.81,115.01 v2(86.14,115.01)
+3.3V_LAN: length 93
  TOP w0.254: CL25.1 255.56,109.5 UL4.39 ; UL4.8 v1(260.97,106.16) ; 261.47,110.47 261.47,111.26 v1(261.3,111.43) ; CL27.1 267.37,109.5 UL4.21 ; v1(264.04,106.17) 263.97,106.25 UL4.14 ; UL4.1 v1(257.47,106.16) ; UL4.4 v1(258.97,106.16)
  TOP w0.381: CL26.1 255.86,106.38 v1(256.18,106.7)
  TOP w0.406: CL15.1 251.75,95.4 UL2.5
  TOP w0.508: v1(262.91,122.41) CL19.1 267.64,122.41 268.48,123.26 JLOM1.9 ; JLOM1.12 283.66,128.33 284.88,127.11 284.88,122.87 v1(285.33,122.42) CL18.1 RL29.1 ; 252.21,90.04 251.39,90.85 v3(251.39,91.75) 251.39,95.04 CL15.1 ; 252.21,90.04 251.84,89.67 RC20.2 RC19.2 ; 252.21,90.04 v1(253.46,90.04) 253.9,90.47 RL2.1 RL1.1 ; v1(254.8,109.56) CL25.1 ; RL70.1 RL6.1 RL4.2 ; RL70.1 266.24,87.18 v1(266.23,87.17) ; RL70.1 RL5.1 ; RL30.1 v1(280.91,116.16) ; v1(268.17,109.56) CL27.1
  IN1 w0.508: v1(262.91,122.41) 262.91,120.48 256.07,113.64 256.07,110.21
  IN1 w1.016: 262.61,105.19 262.61,95.86 266.29,92.17 266.29,91.16 266.93,90.52
  IN3 w0.508: v1(253.46,90.04) 256.49,90.04 257.97,88.55 265.47,88.55 v1(266.61,89.7)
  vias: v1(267.24,89.7) v1(281.58,112.64) v1(281.58,112.09)
+3.3V_LAN_OUT: length 2.3
  TOP w0.102: v1(260,97.73) v2(260,98.28)
  TOP w0.203: UL1.19 v1(260,97.73) ; UL1.15 v1(261.6,97.73)
  vias: v1(255.46,94.32) v1(255.47,93.73) v1(264.45,92.74) v1(264.83,92.3)
+3.3V_LAN_UZ2:
  vias: v2(284.38,113.6)
+3.3V_M: length 26.3
  TOP w0.508: v1(203.92,80.44) 203.92,77.5 204.77,76.66 v3(208.05,76.66) 209.74,76.66 210.47,77.39 213.85,77.39 RZ72.1 ; v1(201.17,81.84) 201.41,82.08 201.41,83.01 200.59,83.83 200.59,83.92 200.2,84.31 199.87,84.31
  IN2 w0.508: v1(203.92,80.44) 203.91,80.44 202.5,81.84 v1(201.17,81.84)
  BOTTOM w0.508: RC276.2 203.74,85.06 204.48,84.32 204.48,82.3 204.01,81.83 204.01,80.53 v1(203.92,80.44)
+3.3V_M_TPM: length 38.4
  TOP w0.127: v3(218.37,64.25) 218.42,64.3 v1(220,64.3)
  TOP w0.254: UZ12.22 212.21,69.51 211.9,69.2 210.95,69.2 CZ75.1
  TOP w0.508: 216.53,77.61 218.11,77.61 219.38,76.34 QZ9.3 219.78,75 v1(219.49,74.71) 219.49,74.3 RZ88.1 ; v1(212.46,67.84) 210.78,67.84 210.49,68.13 CZ75.1 ; RZ69.1 v1(212.32,73.6)
  IN2 w0.508: v1(212.46,67.84) 213.03,68.41 213.03,71.31 212.18,72.16 212.18,73.46 v1(212.32,73.6) 212.57,73.6 213.43,72.74 214.88,72.74 215.96,73.82 218.6,73.82 v1(219.49,74.71)
  BOTTOM w0.508: v1(220,64.3) 219.57,64.73 218.44,64.73 215.33,67.84 v1(212.46,67.84)
+3.3V_M_UZ8: length 1.5
  TOP w0.102: v2(197.33,86.28) 197.56,86.05 197.56,84.86 197.56,84.86
+3.3V_MMI_AUX: length 5.9
  TOP w0.508: CR42.1 268.82,85.89 RR16.1 267.54,86.58 v2(267.09,86.58) 266.65,86.58 266.23,86.17 266.23,85.37 R274.1 265.86,83.97 RR19.1
+3.3V_MMI_IN: length 2.3
  TOP w0.203: UR2.11 267.72,77.97 267.32,77.57 267.32,77.17 267.57,76.92 CR36.1
  vias: v1(265.07,86.31) v1(265.06,85.75) v1(265.58,86.01) v1(268.32,74.9) v1(268.34,74.33) v1(268.92,74.33) v2(264.37,86.22)
+3.3V_PGPPB: length 3.2
  TOP w0.102: v2(165.25,88.46) 165.25,88.63 165.62,89 v1(165.62,89)
  TOP w0.508: RC305.2 166.74,89.9 CC265.1 166.01,89.38 v1(165.62,89)
  BOTTOM w0.254: UC1.AG15 v1(165.62,89)
+3.3V_PGPPC: length 2.7
  TOP w0.102: v1(176.51,88.36) v2(175.96,88.36)
  TOP w0.508: CC207.1 164.98,91.84 v1(164.98,92.33) ; RC306.2 177,88.85 v1(176.51,88.36)
  BOTTOM w0.254: UC1.Y16 v1(164.98,92.33)
+3.3V_PGPPD: length 2.4
  TOP w0.508: RC307.2 176.4,90.69 175.71,90.69 v1(175.51,90.48)
  BOTTOM w0.254: v1(166.27,92.29) UC1.Y15
+3.3V_PGPPE: length 3.9
  TOP w0.508: RC308.2 173.32,92.18 172.86,92.64 172.86,93.13 172.25,93.73 v1(171.67,93.73) ; CC208.1 164.98,93.36 v1(164.98,94)
  BOTTOM w0.254: UC1.T16 v1(164.98,94)
+3.3V_RTC_LDO: length 142.1
  TOP w0.102: v2(252.54,85.37) 251.95,85.37 v1(251.53,84.95)
  TOP w0.508: PR105.2 212.54,80.59 213.38,79.75 v1(213.61,79.75)
  IN2 w0.508: v1(265.09,83.55) 266.62,82.02 266.62,75.97 267.46,75.13 267.46,70.34 268.09,69.71 268.09,66.52 267.68,66.1 267.68,63.86 267.99,63.55 268.26,63.55 268.66,63.14 268.66,56.87 267.99,56.2 267.99,53.15 267.29,52.45 267.29,46.11 v1(267.13,45.94)
  IN3 w0.508: v1(251.53,84.95) 251.66,85.07 254.69,85.07 255.42,85.8 261.36,85.8 263.61,83.55 v1(265.09,83.55)
  IN4 w0.508: v1(281.81,16.23) 282.03,16.44 282.03,18.7 278.38,22.35 278.38,25.75 277.58,26.55 277.58,28.57 277.59,28.58 276.62,29.55 276.62,38.19 272.92,41.88 272.51,41.88 268.44,45.94 v1(267.13,45.94) ; v1(251.53,84.95) 250.23,86.25 247.81,86.25 245.48,83.92 244.38,83.92 240.26,79.79 231.8,79.79 231.37,79.36 227.82,79.36 227.54,79.08 225.33,79.08 224.38,78.13 215.23,78.13 v1(213.61,79.75)
  BOTTOM w0.508: v1(281.81,16.23) 282.09,16.51 PD1.3
+3.3V_RUN: length 1023.4
  TOP w0.203: UV26.30 228.72,107.96 228.27,107.51 227.54,107.51 CV602.1 ; UV26.57 238.93,110.36 239.09,110.52 239.09,110.88 239.52,111.31 239.95,111.31 CV604.1 ; UV26.5 v1(235.98,113.29) ; v1(245.77,114.59) 245.9,114.46 246.29,114.46 246.43,114.61 UV7.51 ; UV26.21 228.8,111.56 228.67,111.69 228.67,111.95 228.94,112.21 v1(229.02,112.21) ; UV26.51 238.82,107.96 239.13,107.65 239.13,107.22 v1(239.63,106.71) ; UV7.57 248.83,114.38 v1(249.13,114.08) ; UV7.5 v1(251.58,117.35)
  TOP w0.381: CV600.1 v1(239.63,106.71) ; CV62.1 CV510.1 245.16,113.52 v1(245.6,113.97) ; CV601.1 v1(227,112.23) ; v1(99.73,113.58) 99.07,114.25 CA7.1 ; QC2.2 178.78,96.92 178.91,96.79 v1(179.17,96.79)
  TOP w0.457: RE67.1 249.76,57.45 250.1,57.11 250.62,57.11 250.95,57.44 v1(250.95,57.64)
  TOP w0.508: RC51.1 RC50.1 RC287.2 191.28,74.85 192.5,73.63 192.5,70.29 190.12,67.91 v1(189.57,67.91) ; RC51.1 RC245.1 RC279.1 RC190.1 ; RC51.1 RC189.1 RC47.1 ; v1(246.72,58.26) 246.72,59.17 245.41,60.47 245.41,63.02 244.07,64.36 244.07,69.74 ; RV19.1 241.81,128.51 242.1,128.22 ; v1(237.91,126.12) 239.82,126.12 240.47,125.47 v1(241.21,125.47) 242.1,126.36 242.1,128.22 ; 243,109.76 RV613.1 RV612.1 RV611.1 ; 243,109.76 RV614.1 RV601.1 RV615.1 RV610.1 ; 243,109.76 245.7,109.76 RV55.1 RV56.1 RV57.1 RV58.1 RV60.1 251.29,110.21 RV53.1 251.74,110.19 252.09,110.55 252.09,112.12 253.05,113.08 RV54.1 CV66.1 v1(252.41,115.86) ; 242.1,128.22 244.76,128.22 245.39,127.59 ; RZ89.1 220.43,74.28 v1(220.43,74.7) ; v1(148.78,48.6) 148.24,48.6 147.8,49.04 RD65.1 145.07,49.64 143.86,48.43 143.86,43.03 141.82,40.99 137.49,40.99 135.96,39.47 RD64.1 ; 253.13,127.39 251.98,126.23 CV70.1 ; 253.13,127.39 253.79,127.39 254.94,126.24 254.94,125.31 254.58,124.95 RV52.1 ; 253.13,127.39 253.13,131.53 v1(252.47,132.19) 249.55,132.19 247.61,130.25 v1(247.61,127.73) ; v1(174.52,81.48) 173.47,82.53 RC282.1 ; v1(284.25,25.99) 284.41,25.83 284.41,24.25 286.41,22.26 286.84,22.26 287.73,21.37 v1(287.73,20.68) ; v1(225.5,109.26) 225.87,109.64 RV605.1 ; PR612.1 81.63,86.14 v1(81.19,85.7) ; v1(212.74,40.28) 213.03,39.99 RD71.1 ; CV603.1 RV603.1 238.1,116.26 v1(237.84,116.52) ; v1(219.19,124.35) 219.19,124.51 219.67,124.99 221.33,124.99 222.91,123.41 226.88,123.41 228.76,121.53 v1(228.76,116.43) 228.32,115.99 RV602.1 ; v1(229.85,52.07) 229.65,52.27 RD60.1 ; v1(174.95,69.46) 174.9,69.41 RC13.1 ; RC137.1 136.71,119.48 137.37,120.14 137.37,121.22 ; v1(270.51,53.26) 270.25,53.26 268.72,51.72 268.72,50.87 266.18,48.34 v1(266.18,46.08) ; RE48.1 254.73,58.23 254.23,57.72 v1(253.85,57.72) RE51.1 ; CC285.2 163.62,118.89 162.47,118.89 v1(162.18,119.19) 161.95,119.41 161.05,119.41 160.11,118.47 158.65,118.47 157.64,119.48 157.64,121.6 155.57,123.67 148.96,123.67 147.11,121.83 143.85,121.83 142.91,122.77 139.11,122.77 137.56,121.22 137.37,121.22 ; RC270.1 175.47,73.5 v1(175.22,73.25) ; v1(134.6,120.96) 134.6,121.04 135.28,121.71 136.88,121.71 137.37,121.22 ; v1(240.31,112.29) CV604.1 ; RC21.1 RC27.2 173.96,73.87 v1(173.96,73.22) ; RD63.1 RD62.1 159.33,46.12 161.73,43.72 v1(163.68,43.72) ; CV602.1 227.14,106.97 227.62,106.49 v1(227.62,106.32) ; QZ1.3 99.86,113.45 v1(99.73,113.58) ; v1(216.29,64.61) 216.01,64.89 RZ90.1 ; v1(249.72,114.02) 249.78,114.02 250.08,113.72 RV51.1 ; CC287.2 141.28,119.68 141.78,119.19 142.91,119.19 144.63,117.47 v1(144.63,117.18) 145.37,116.43 147.34,116.43 149.5,114.27 v1(149.5,112.48) ; RV604.1 v1(225.46,107.86) ; RD69.1 RD70.1 231.07,40.88 v1(231.25,41.06) ; PR507.1 288.16,13.52 v1(287.55,13.52) 287,13.52 286.33,12.85 282.42,12.85 282.04,12.47 282.04,11.77
  IN1 w0.508: v1(176.79,109.94) 178.25,108.48 178.25,104.12 v1(178.88,103.5) ; v1(238.85,99.45) 238.85,97.42 235.53,94.1 235.53,81.83 236.75,80.62 240.47,80.62 240.97,81.11 v1(240.97,83.42) ; v1(266.18,46.08) 266.63,46.53 268.32,46.53 271.94,42.91 v1(274.46,42.91)
  IN1 w0.762: 25.72,38.97 30.9,44.14 36.49,44.14 40.01,40.62 43.79,40.62 44.35,40.06 54.8,40.06 56.02,41.28 60.58,41.28 61.38,40.48 62.54,40.48
  IN2 w0.508: v1(105.83,74.77) 105.18,75.42 99.2,75.42 97.37,73.59 94.82,73.59 94.12,72.89 91.2,72.89 89.96,74.13 87.2,74.13 85.95,75.37 85.95,81.31 81.57,85.7 v1(81.19,85.7) ; v1(229.93,47.86) 229.75,47.86 229.44,47.54 229.44,43.96 227.58,42.11 214.42,42.11 214.37,42.06 193.71,42.06 192.99,42.77 164.06,42.77 163.68,43.15 v1(163.68,43.72) 162.02,43.72 158.24,47.51 151.52,47.51 150.42,48.6 v1(148.78,48.6) ; v1(210.89,73.62) 210.89,73.97 211.27,74.35 215.1,74.35 216.13,75.38 219.75,75.38 v1(220.43,74.7) ; v1(134.6,120.96) 133.08,120.96 132.03,119.91 125.44,119.91 125.17,119.64 120.78,119.64 117.51,116.38 107.17,116.38 v1(106.63,115.83) 104.53,115.83 102.72,114.02 100.94,114.02 100.37,113.45 99.87,113.45 v1(99.73,113.58) 99.43,113.58 95.65,109.81 95.65,101.96 96.43,101.19 v1(96.75,101.19) ; v1(173.96,73.22) 173.96,74 175.12,75.15 176.71,75.15 179.94,78.39 v1(180.19,78.39)
  IN3 w0.508: v1(96.75,101.19) 96.4,100.85 96.4,96.95 93.81,94.36 89.94,94.36 89.21,93.63 85.04,93.63 84.01,92.6 84.01,91.14 82.62,89.76 82.62,86.37 81.95,85.7 v1(81.19,85.7) ; v1(134.6,120.96) 134.6,119.67 135.7,118.58 137.44,118.58 138.47,117.55 139.72,117.55 140.24,118.07 143.74,118.07 v1(144.63,117.18) ; v1(176.79,109.94) 176.79,111.88 173.28,115.4 169.97,115.4 168.56,116.81 165.78,116.81 163.41,119.19 v1(162.18,119.19) ; v1(246.72,58.26) 246.72,58.49 247.08,58.86 247.7,58.86 248.3,58.26 248.66,58.26 249.96,56.97 250.61,56.97 250.95,57.31 v1(250.95,57.64) ; v1(287.55,13.52) 290.55,10.52 292.58,10.52 292.88,10.22 v1(292.88,9.9)
  IN3 w0.762: 62.54,40.48 61.38,40.48 60.75,41.11 56.08,41.11 54.8,39.82 44.59,39.82 43.79,40.62 40.01,40.62 36.75,43.89 30.64,43.89 25.34,38.58
  IN4 w0.508: v1(231.25,41.06) 213.51,41.06 v1(212.74,40.28) ; v1(287.55,13.52) 287.55,13.37 286.9,14.02 286.9,15.82 287.49,16.4 287.49,18.73 287.73,18.97 v1(287.73,20.68) ; v1(284.25,25.99) 284.01,25.99 283.65,26.35 281.51,26.35 280.45,27.4 280.45,39.25 276.79,42.91 v1(274.46,42.91)
  IN4 w1.27: 26.39,38.16 27.39,39.16 29.69,39.16 31.26,40.73 31.26,40.99 33.46,43.19 36.19,43.19 38.49,40.89 43.53,40.89 45.12,39.3 55.06,39.3 56.21,40.45 63.13,40.45 63.29,40.28
  BOTTOM w0.254: JEDP1.10 v1(99.73,113.58) ; CC30.2 144.36,117.7 144.21,117.55 142.47,117.55 142.26,117.75 UC8.14
  BOTTOM w0.305: JUSH1.8 293.4,9.42 292.92,9.9 v1(292.88,9.9)
  BOTTOM w0.356: v1(292.88,9.9) 292.31,10.47 CZ11.1
  BOTTOM w0.381: CC30.2 145.01,117.56 v1(144.63,117.18)
  BOTTOM w0.432: v1(241.21,125.47) 241.21,125.66 240.73,126.15 QV3.2 ; QV3.5 238.22,126.15 238.2,126.12 v1(237.91,126.12)
  BOTTOM w0.508: RC292.1 179.88,92.53 v1(180.22,92.87) ; v1(96.75,101.19) 96.25,101.19 RV623.1 ; 176.54,111.43 176.54,113.67 RC225.1 ; v1(252.47,132.19) RV8.2 RV22.2 250.35,132.51 QV5.2 ; RC326.2 177.62,89.61 v1(177.45,89.44) ; RC179.1 143.75,112.23 144.66,113.14 147.1,113.14 147.76,112.48 v1(149.5,112.48) ; v1(240.97,83.42) 240.97,82.92 239.38,81.33 239.38,79.17 v1(237.35,77.14) ; RC345.2 181.53,77.49 180.87,78.15 RC59.1 v1(180.19,78.39) 179.63,78.39 RC272.1 ; RC318.1 RC319.1 155.23,123.16 154.92,123.47 149.07,123.47 148.24,122.64 148.24,116.81 149.5,115.56 v1(149.5,112.48) ; RV622.1 220.14,125.31 v1(219.19,124.35) 218.86,124.03 UV27.5 217.81,123.67 216.98,124.51 216.98,124.96 RV501.1 ; 177.29,69.4 187.61,69.4 189.14,67.87 189.53,67.87 v1(189.57,67.91) 208.23,67.91 210.8,70.48 v1(211.4,70.48) ; v1(239.63,106.71) 240.17,106.18 240.17,100.77 v1(238.85,99.45) ; v1(149.5,112.48) 149.5,111.7 148.95,111.15 RC181.1 ; 105.78,66.37 105.83,66.42 v1(105.83,74.77) ; v1(253.85,57.72) 253.85,57.96 253.43,58.38 251.69,58.38 v1(250.95,57.64)
  BOTTOM w3.048: 217.18,62.57 199.76,62.57 198.73,61.54 168.93,61.54 164.1,66.37 102.42,66.37 90.38,54.33 88.31,54.33 87.08,53.09 82.57,53.09 81.23,51.75 81.23,49.09 79.49,47.35 75.46,47.35 68.5,40.39 68.26,40.39
  vias: v1(24.81,37.83) v1(24.81,37.19) v1(24.81,36.61) v1(25.45,37.83) v1(25.45,37.19) v1(25.45,36.61) v1(64.98,40.65) v1(64.98,40.01) v1(65.57,40.65) v1(65.57,40.01) v1(66.15,40.65) v1(66.15,40.01) v1(174.89,96.11) v1(212.02,104.19) v1(212.66,104.19) v1(218.98,63.17) v1(219.35,62.67) v1(219.57,63.33) v1(219.89,62.18) v1(219.91,62.81) v1(220.47,62.25) v1(244.1,40.22) v1(244.1,39.58) v1(244.74,40.22) v1(244.74,39.58) v1(245.37,40.22) v1(245.37,39.58) v1(246.01,40.22) v1(246.01,39.58) v1(250.49,124.24) v1(258.07,41.69) v1(258.07,41.09) v1(268.16,72.54) v1(268.45,72.04) v1(268.74,72.54) v1(274.9,67.24) v1(274.9,66.65) v3(26.46,36.74)

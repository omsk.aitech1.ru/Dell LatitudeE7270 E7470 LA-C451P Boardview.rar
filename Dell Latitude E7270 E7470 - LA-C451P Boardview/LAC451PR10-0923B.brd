# Allegro board LAC451PR10-0923B.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
USB3_PTX_DRX_N5: length 130
  TOP w0.094: v4(273.91,97.04) 274.19,97.32 275.02,97.32 CI29.2
  IN4 w0.102: v4(166.99,106.93) 167.29,107.24 167.78,107.24 168.01,107.01 168.01,104.76 168.4,104.37 169.33,104.37 170.25,105.28 179.47,105.28 182.1,107.91 185.58,107.91 186.94,106.55 188.79,106.55 189.29,107.06 203.92,107.06 206.19,104.78 210.94,104.78 211.45,105.3 218.73,105.3 219.24,104.78 225.94,104.78 226.83,105.67 226.83,106.42 227.2,106.79 228.32,106.79 229.56,108.03 237.41,108.03 238.33,107.12 239.8,107.12 243.18,103.74 270.5,103.74 272.11,102.13 272.11,97.82 272.69,97.24 273.7,97.24 v4(273.91,97.04)
  BOTTOM w0.076: UC1.B17 164.71,102.8 164.9,102.8 165.1,103.01 165.1,105.16 166.29,106.35 166.29,106.89 166.6,107.19 166.78,107.19 166.99,106.98 v4(166.99,106.93)
USB3_PTX_DRX_P1: length 142.3
  IN4 w0.102: v4(169.34,107.08) 169.46,106.96 170.03,106.96 170.62,106.36 179.37,106.36 181.76,108.75 185.92,108.75 187.28,107.38 188.44,107.38 188.95,107.89 204.26,107.89 206.48,105.67 210.65,105.67 211.11,106.13 215.48,106.13 216.09,106.74 218.49,106.74 219.56,105.67 225.62,105.67 225.92,105.98 225.92,106.77 226.78,107.63 227.83,107.63 229.54,109.34 237.38,109.34 238.39,108.33 239.92,108.33 243.67,104.58 274.44,104.58 274.9,105.03 279.55,105.03 280.06,104.53 282.4,104.53 283.65,103.27 283.65,101.34 284.85,100.15 284.85,98.43 283.57,97.16 283.57,95.16 283.44,95.03 v4(283.44,94.02)
  BOTTOM w0.076: v4(169.34,107.08) 169.34,107.07 169.09,106.82 168.78,106.82 168.08,106.12 168.08,104.51 167.26,103.69 166.72,103.69 166.51,103.48 166.51,103.07 166.55,102.98 166.55,102.79 166.51,102.69 166.51,102.45 166.57,102.25 166.59,102.17 166.61,102.12 166.65,101.97 166.65,101.85 166.73,101.59 UC1.D13
  BOTTOM w0.094: v4(283.44,94.02) 283.13,94.33 283.13,94.7 CI16.2
USB3_PTX_DRX_P2: length 53.2
  TOP w0.094: v4(157.58,140.28) 157.44,140.14 157.44,134.82 156.61,133.98 154.58,133.98 154.35,134.2 154.35,134.42 v4(154.08,134.69)
  IN2 w0.122: v4(154.08,134.69) 154.21,134.56 154.21,131.4 153.93,131.12 153.93,125.95 158.5,121.39 158.5,118.76 165.53,111.72 167.13,111.72 169.81,109.04 169.81,105.83 169.49,105.51 169.29,105.51 v4(169.07,105.72)
  BOTTOM w0.076: UC1.A13 166.94,103.08 167.06,102.97 167.28,102.97 167.48,103.17 167.48,103.43 168.41,104.36 168.41,105.26 168.61,105.46 168.82,105.46 169.07,105.71 v4(169.07,105.72)
  BOTTOM w0.094: v4(157.58,140.28) 157.34,140.04 157.34,139.64 157.5,139.48 JDOCK1.92
USB3_PTX_DRX_P3: length 127.5
  TOP w0.094: CI4.2 66.97,120.74 66.97,120.09 66.64,119.76 66.43,119.76 v4(66.18,119.51)
  IN1 w0.102: v4(66.18,119.51) 66.18,119.56 66.55,119.93 67.71,119.93 69.57,118.07 71.19,118.07 71.49,118.36 73.95,118.36 77.39,121.8 82.07,121.8 83.48,120.39 86.17,120.39 86.69,119.87 88.28,119.87 89.6,121.19 112.53,121.19 114.82,123.48 115.86,123.48 118,125.62 131.83,125.62 132.19,125.26 134.62,125.26 135.36,126 140.35,126 140.97,125.38 146.25,125.38 147.11,124.51 154.56,124.51 158.49,120.58 158.49,118.85 158.97,118.37 158.97,115.73 163.64,111.05 164.87,111.05 166.33,109.6 166.33,106.06 166.62,105.77 167.14,105.77 v4(167.31,105.6)
  BOTTOM w0.076: UC1.A15 165.5,103.21 165.45,103.26 165.45,103.47 165.5,103.53 165.63,103.53 165.71,103.6 165.71,103.74 165.63,103.82 165.54,103.82 165.45,103.91 165.45,104.03 165.54,104.12 165.62,104.12 165.71,104.21 165.71,104.34 165.62,104.43 165.55,104.43 165.45,104.53 165.45,105.03 166.47,106.05 166.96,106.05 167.31,105.7 v4(167.31,105.6)
USB3_PTX_DRX_P4: length 96.9
  TOP w0.094: CI28.2 92.08,120.25 92.08,120.12 92.28,119.92 v4(92.33,119.92)
  IN1 w0.102: v4(92.33,119.92) 92.26,119.92 91.9,120.28 91.9,120.44 92.03,120.57 112.79,120.57 113.75,121.53 115.92,121.53 119.39,125 131.58,125 131.97,124.61 134.87,124.61 135.64,125.38 140.08,125.38 140.71,124.76 145.92,124.76 146.78,123.89 154.31,123.89 157.87,120.32 157.87,118.56 158.29,118.14 158.29,114.61 159.92,112.99 160.83,112.99 163.38,110.44 164.07,110.44 165.05,109.45 165.05,107.42 165.64,106.83 165.64,105.15 165.96,104.83 166.26,104.83 166.63,104.46 v4(166.63,104.41)
  BOTTOM w0.076: UC1.D15 165.71,101.43 165.81,101.59 165.85,101.74 165.88,101.85 165.88,101.97 165.93,102.13 165.94,102.17 165.96,102.25 166.01,102.4 166.02,102.45 166.02,102.69 165.99,102.79 165.99,102.98 166.02,103.07 166.04,103.09 166.04,104.52 166.19,104.67 166.37,104.67 v4(166.63,104.41)
USB3_PTX_DRX_P5: length 129.9
  TOP w0.094: v4(273.92,97.75) 274.16,97.51 275.09,97.51 CI30.2
  IN4 w0.102: v4(166.99,107.62) 167.16,107.45 167.87,107.45 168.22,107.1 168.22,104.85 168.49,104.58 169.24,104.58 170.16,105.5 179.38,105.5 182.01,108.13 185.67,108.13 187.03,106.76 188.7,106.76 189.21,107.27 204.01,107.27 206.28,105 210.85,105 211.37,105.51 218.82,105.51 219.33,105 225.85,105 226.62,105.76 226.62,106.51 227.11,107.01 228.23,107.01 229.47,108.25 237.5,108.25 238.41,107.33 239.89,107.33 243.27,103.96 270.58,103.96 272.32,102.22 272.32,97.91 272.78,97.45 273.63,97.45 v4(273.92,97.75)
  BOTTOM w0.076: v4(166.99,107.62) 166.99,107.56 166.79,107.36 166.53,107.36 166.13,106.96 166.13,106.42 164.93,105.23 164.93,103.07 164.83,102.97 164.71,102.97 UC1.A17
USB3_PTX_L_DRX_N1: length 9.8
  BOTTOM w0.094: JUSB3.8 291.59,95.28 291.38,95.07 291.1,95.07 290.66,95.52 288.89,95.52 288.75,95.66 288.75,96.15 288.71,96.18 288.71,97.23 v5(288.37,97.58) 288.02,97.93 287.69,97.93 287.53,98.09 DI4.4 DI4.7 286.06,98.09 285.91,97.93 285.66,97.93 285.57,97.84 285.4,97.84 RI18.2
USB3_PTX_L_DRX_N3: length 11.6
  TOP w0.094: JUSB1.8 71.05,130.87 71.17,130.76 71.17,130.32 70.67,129.82 70.67,128.57 v5(70.28,128.19) 69.7,127.6 68.51,127.6 68.48,127.63 67.89,127.63 67.85,127.6 67.26,127.6 66.67,127.01 66.67,126.7 66.51,126.54 DI1.7 DI1.4 66.51,124.81 66.67,124.65 66.67,124.02 RI22.2
USB3_PTX_L_DRX_N4: length 9.3
  TOP w0.094: JUSB2.8 94.06,130.87 94.16,130.78 94.16,130.46 93.51,129.81 93.51,129.13 93.02,128.64 93.02,128.59 v5(92.15,127.72) 91.82,127.39 91.82,126.7 91.66,126.54 DI6.7 DI6.4 91.66,124.95 91.82,124.79 91.82,124.44 91.89,124.36 91.89,124.04 RI26.2
USB3_PTX_L_DRX_N5: length 5.3
  TOP w0.094: RI30.2 278.82,97.21 279.4,97.21 279.55,97.05 DI7.7 DI7.4 281.08,97.05 281.24,97.21 281.62,97.21 v4(281.82,97.01)
  BOTTOM w0.094: v4(281.82,97.01) 281.57,97.26 281.33,97.26 281.17,97.1 JNGFF2.27
USB3_PTX_L_DRX_P1: length 9.7
  BOTTOM w0.094: RI17.2 285.37,97.65 285.65,97.65 285.74,97.74 285.88,97.74 286.04,97.59 DI4.6 DI4.5 287.54,97.59 287.7,97.74 287.94,97.74 288.01,97.68 288.01,97.63 288.42,97.21 288.47,97.21 288.53,97.16 v5(288.53,95.86) 288.53,95.62 288.82,95.33 290.58,95.33 291.03,94.89 291.37,94.89 291.59,94.67 JUSB3.9
USB3_PTX_L_DRX_P3: length 11.6
  TOP w0.094: RI21.2 66.86,124.04 66.86,124.65 67.01,124.8 DI1.5 DI1.6 67.01,126.54 66.85,126.7 66.85,126.94 67.33,127.42 v5(68.18,127.42) 69.77,127.42 70.18,127.82 70.23,127.82 70.65,128.24 70.65,128.29 70.85,128.49 70.85,129.74 71.35,130.24 71.35,130.75 71.47,130.87 JUSB1.9
USB3_PTX_L_DRX_P4: length 9.3
  TOP w0.094: RI25.2 92.08,124.03 92.08,124.44 92,124.52 92,124.79 92.16,124.95 DI6.5 DI6.6 92.16,126.54 92,126.7 92,127.26 92.51,127.77 92.51,127.82 v5(93.38,128.7) 93.69,129 93.69,129.73 94.34,130.38 94.34,130.78 94.44,130.87 JUSB2.9
USB3_PTX_L_DRX_P5: length 5.4
  TOP w0.094: RI29.2 278.97,97.4 279.4,97.4 279.56,97.55 DI7.6 DI7.5 281.05,97.55 281.21,97.4 281.52,97.4 v4(281.82,97.69)
  BOTTOM w0.094: JNGFF2.29 281.17,97.6 281.33,97.44 281.57,97.44 v4(281.82,97.69)
USB20_N1: length 155.7
  TOP w0.094: UI3.2 275.46,102.14 275.3,101.98 275.03,101.98 v1(274.83,102.18)
  IN2 w0.122: v1(274.83,102.18) 274.65,102 274.36,102 274.1,101.75 274.1,100.86 274.77,100.19 274.77,97.37 277.33,94.81 277.33,92.54 278.28,91.59 278.28,90.32 277.16,89.2 277.16,76.08 v1(276.81,75.73)
  IN4 w0.076: v1(169.69,91.57) 169.57,91.57 169.44,91.71 169.44,91.88 169.58,92.02 172.86,92.02 173.43,92.59 175.66,92.59 176.07,92.19 177.63,92.19 177.78,92.33 178.43,92.33 178.53,92.24 178.53,92.24
  IN4 w0.102: v1(276.81,75.73) 277.15,76.07 277.15,76.22 276.09,77.28 274.45,77.28 272.98,75.81 267.67,75.81 266.01,74.15 264.03,74.15 263.03,75.15 263.03,76.06 262.66,76.42 259.09,76.42 258.65,75.98 257.87,75.98 257.5,76.35 256.61,76.35 255.67,75.41 255.23,75.41 254.44,74.62 251.27,74.62 250.88,74.23 246.5,74.23 245.97,73.71 240.84,73.71 239.77,74.78 236.07,74.78 235.79,74.49 234.62,74.49 234.34,74.78 232.2,74.78 231.42,73.99 230.77,73.99 230.01,74.75 226.53,74.75 225.88,74.1 217.46,74.1 216.81,74.75 208,74.75 206.53,76.22 205.69,76.22 204.29,77.62 203.55,77.62 198.19,82.98 196.27,82.98 196.01,82.73 193.37,82.73 192.31,83.79 191.37,83.79 185.46,89.7 185.46,91.09 183.76,92.79 181.82,92.79 181.26,92.24 178.53,92.24
  BOTTOM w0.076: UC1.AB9 v1(169.69,91.57)
USB20_N1_R: length 12.9
  TOP w0.094: LI7.2 286.32,100.3 286.4,100.21 286.8,100.21 v5(286.95,100.07) 287.12,99.89 287.12,98.55 287.21,98.46 287.46,98.46 DI5.2 287.19,97.95 287.1,97.86 287.1,97.53 287.79,96.83 289.12,96.83 289.67,96.28 290.59,96.28 290.8,96.49 290.8,97.44 290.57,97.67 290.57,98.01 290.35,98.23 290.08,98.23 289.98,98.13 289.98,97.11 JUSB3.2
USB20_N2: length 149.7
  TOP w0.094: LZ1.1 96.34,113.45 96.07,113.41 95.95,113.49 95.82,113.49 95.54,113.78 95.54,114.31 93.45,116.41 93.45,122.87 v1(93.85,123.27)
  IN1 w0.076: 178.5,92.83 178.12,92.45 178.1,92.45 177.82,92.16 177.1,92.16 176.01,91.07 175.21,91.07 175.11,90.97 171.46,90.97 171.33,90.84 171.33,90.76 v1(171.59,90.51)
  IN1 w0.102: 178.5,92.83 179.08,93.41 185.16,93.41 186.86,95.1 186.86,96.99 183.6,100.25 183.32,100.25 180.49,103.08 180.49,107.1 181.69,108.3 181.69,111.64 178.87,114.47 169.71,114.47 167.43,116.75 165.16,116.75 162.86,119.04 162.86,122.77 160.31,125.32 155.81,125.32 155.16,125.96 147.78,125.96 146.91,126.83 141.6,126.83 140.98,127.45 134.66,127.45 133.92,126.71 132.94,126.71 132.58,127.07 116.79,127.07 114.95,125.23 113.99,125.23 112.37,123.62 109.53,123.62 109.03,123.11 107.88,123.11 107.44,122.66 93.88,122.66 93.67,122.87 93.67,123.1 v1(93.85,123.27)
  BOTTOM w0.076: UC1.AD6 171.34,90.75 v1(171.59,90.51)
USB20_N2_R: length 4.7
  TOP w0.094: v1(99.53,112.01) 99.53,111.92 99.4,111.79 99.26,111.79 99.16,111.9 98.71,111.9 98.59,111.77 98.47,111.77 98.36,111.85 98.32,112.07 LZ1.2
  BOTTOM w0.094: JEDP1.12 98.91,112.94 98.95,112.72 99.01,112.67 99.13,112.58 99.13,111.93 99.25,111.81 99.43,111.81 99.53,111.91 v1(99.53,112.01)
USB20_N3: length 168.6
  TOP w0.094: LI3.4 69.98,119.64 69.89,119.54 69.8,119.54 69.73,119.47 69.73,119.22 69.82,119.12 70.69,119.12 71.04,119.48 v1(71.04,119.52)
  IN1 w0.076: v1(176.79,87.14) 176.73,87.2 176.73,87.79 177.94,89 178.41,89 178.42,88.99 178.48,88.99 178.49,88.98 178.5,88.98
  IN1 w0.102: 178.5,88.98 183.44,88.98 183.86,89.39 183.86,89.95 183.52,90.28 183.52,91.6 183.68,91.76 183.83,91.76 184.17,92.1 185.67,92.1 188.11,94.53 188.11,97.67 186.98,98.8 186.98,101.85 187.56,102.43 187.56,106.61 186.75,107.42 186.75,108.34 179.38,115.71 171.86,115.71 161.01,126.56 156.32,126.56 155.68,127.2 148.34,127.2 147.48,128.07 142.13,128.07 141.5,128.7 131.57,128.7 131.34,128.93 130.34,128.93 129.74,129.52 126.78,129.52 125.87,130.44 117.41,130.44 111.95,124.97 99.98,124.97 98.93,123.92 85.63,123.92 84.53,122.81 76.79,122.81 73.5,119.52 v1(71.04,119.52)
  BOTTOM w0.076: UC1.AH3 172.61,88.27 172.77,88.27 172.92,88.2 173,88.16 173.18,88.16 173.34,88.22 173.48,88.22 173.7,88.15 173.82,88.15 173.93,88.2 174.29,88.2 174.44,88.06 175.57,88.06 175.68,88.17 176.12,88.17 176.58,87.71 176.58,87.35 v1(176.79,87.14)
USB20_N3_R: length 11.1
  TOP w0.094: LI3.3 69.98,121.69 69.79,121.89 69.79,122.8 69.96,122.97 70.3,122.97 DI2.3 69.88,123.33 69.79,123.42 69.79,124.03 v1(69.99,124.23)
  IN1 w0.102: JUSB1.2 68.54,129.37 68.33,129.17 68.33,127.4 69.82,125.92 69.82,124.4 v1(69.99,124.23)
USB20_N4: length 149.5
  TOP w0.094: v1(86.07,121.72) 85.73,121.37 84.08,121.37 83.78,121.67 83.78,121.83 84.09,122.14 LI4.4
  IN1 w0.076: v1(169.69,90.51) 169.63,90.57 169.63,90.81 169.78,90.97 170.54,90.97 171.2,91.62 175.83,91.62 176.91,92.7 177.44,92.7 178.33,93.59 178.35,93.59 178.5,93.74
  IN1 w0.102: v1(86.07,121.72) 86.92,121.72 88.12,122.92 89.7,122.92 90.59,122.02 112.18,122.02 114.54,124.38 115.58,124.38 117.65,126.45 132.18,126.45 132.54,126.09 134.2,126.09 134.94,126.83 140.71,126.83 141.33,126.21 146.64,126.21 147.51,125.34 154.91,125.34 155.56,124.7 160.05,124.7 162.23,122.52 162.23,121.4 161.66,120.83 161.66,119.11 164.64,116.13 167.17,116.13 169.45,113.85 178.61,113.85 181.01,111.45 181.01,108.65 179.78,107.42 179.78,102.91 183.17,99.53 183.36,99.53 186.24,96.65 186.24,95.36 184.92,94.04 178.8,94.04 178.5,93.74
  BOTTOM w0.076: v1(169.69,90.51) 169.55,90.73 UC1.AD9
USB20_N4_R: length 14.4
  TOP w0.094: v1(89.01,126.57) 88.8,126.36 88.8,125.99 88.59,125.78 87.61,125.78 86.46,124.63 85.96,124.63 85.86,124.54 DI3.3 85.43,124.19 85.43,124.6 85.32,124.71 84.03,124.71 83.81,124.49 83.81,124.29 83.87,124.23 83.99,124.23 84.09,124.12 LI4.3
  IN1 w0.102: v1(89.01,126.57) 88.83,126.76 88.83,127.15 88.94,127.25 90.73,127.25 91.51,128.04 91.51,129.19 91.69,129.37 JUSB2.2
USB20_N5: length 81
  IN2 w0.122: v1(175.61,87.14) 175.42,87.32 175.42,87.74 174.08,89.09 174.08,90.24 175.45,91.61 176.71,91.61 178.7,93.61 178.7,95.44 180.27,97.01 180.27,100.61 180.15,100.73 180.15,108.24 181.02,109.11 181.02,111.03 177.2,114.85 169.99,114.85 168.49,116.36 165.55,116.36 162.79,119.11 162.79,125.36 160.8,127.35 160.8,134.85 157.44,138.21 153.64,138.21 152.88,138.97 152.88,140.05 v1(153.04,140.21)
  BOTTOM w0.076: v1(175.61,87.14) 175.61,87.33 175.42,87.51 174.88,87.51 174.67,87.73 174.25,87.73 174.21,87.77 UC1.AJ1
  BOTTOM w0.094: v1(153.04,140.21) 152.84,140.01 152.84,139.56 153,139.4 JDOCK1.74
USB20_N6: length 79.5
  TOP w0.094: v1(151.54,140.23) 151.37,140.05 151.37,138.83 152.52,137.68 152.52,135.07 152.63,134.96 152.79,134.96 v1(152.98,135.15)
  IN2 w0.122: v1(171.09,89.44) 170.96,89.44 170.81,89.59 170.81,89.78 170.91,89.89 171.84,89.89 174.99,93.04 176.06,93.04 176.67,93.65 177.51,93.65 178.04,94.18 178.04,96.34 178.42,96.72 178.42,112.11 176.51,114.02 169.72,114.02 168.02,115.71 165.09,115.71 161.74,119.06 161.74,120.32 160.5,121.56 160.5,122.25 161.14,122.88 161.14,123.94 156.89,128.18 156.89,135.42 156.26,136.05 154.33,136.05 153.3,135.02 153.13,135.02 153,135.15 v1(152.98,135.15)
  BOTTOM w0.076: v1(171.09,89.44) 171.34,89.69 UC1.AF6
  BOTTOM w0.094: JDOCK1.68 151.5,139.46 151.34,139.62 151.34,140.03 v1(151.54,140.23)
USB20_N7: length 173.2
  IN4 w0.102: v1(177.11,87.63) 177.29,87.81 177.29,88.08 177.52,88.31 177.96,88.31 178.29,87.98 180.38,87.98 182.83,85.53 185.52,85.53 187.36,83.69 187.36,81.94 189.29,80.01 190.38,80.01 191,79.39 196.74,79.39 197.11,79.02 197.11,77.85 197.44,77.52 197.98,77.52 198.42,77.07 200.3,77.07 202.23,75.14 203.38,75.14 206.88,71.64 208.7,71.64 209.12,71.22 214.45,71.22 215.25,70.42 215.25,68.39 217.84,65.8 217.95,65.8 227.1,56.64 228.71,56.64 229.53,55.82 238.42,55.82 238.8,56.2 239.73,56.2 240.69,55.24 241.33,55.24 242.35,54.22 247.08,54.22 248.09,55.24 252.24,55.24 252.97,54.52 252.97,53.33 257.38,48.91 261.82,48.91 261.99,48.75 266.8,48.75 272.84,42.71 273.26,42.71 277.45,38.52 277.45,29.88 278.41,28.92 278.41,26.89 279.25,26.05 279.25,24.29 280.78,22.75 285.29,22.75 285.99,22.06 287.84,22.06 288.74,21.15 288.74,12.43 288.21,11.9 287.38,11.9 287.14,11.66 287.14,10.07 287.71,9.51 287.99,9.51 288.07,9.58 288.07,9.7 v1(287.86,9.91)
  BOTTOM w0.076: v1(177.11,87.63) 177.01,87.63 176.87,87.77 176.87,87.91 176.98,88.02 177.25,88.02 177.37,87.91 177.44,87.91 177.52,87.99 177.52,88.34 177.13,88.73 176.3,88.73 176.02,88.45 174.51,88.45 174.42,88.53 174.14,88.53 173.99,88.38 173.8,88.38 UC1.AH1
  BOTTOM w0.094: JUSH1.19 287.9,9.1 288.06,9.26 288.06,9.71 v1(287.86,9.91)
USB20_N8: length 107.7
  IN4 w0.076: v1(169.68,89.44) 169.66,89.44 169.46,89.64 169.46,89.75 169.64,89.94 171.93,89.94 173.06,91.07 175.83,91.07 177.02,89.88 177.55,89.88 178.39,89.04 178.5,89.04 178.51,89.02 178.53,89.02
  IN4 w0.102: v1(244.91,57.86) 244.7,57.65 244.7,57.45 244.49,57.25 243.16,57.25 242.57,57.84 238.12,57.84 237.74,57.46 235.16,57.46 234.58,58.03 229.63,58.03 228.71,58.95 227.63,58.95 217.73,68.86 217.73,71.68 216.47,72.93 207.86,72.93 206.33,74.47 205.5,74.47 203.76,76.21 202.61,76.21 200.91,77.91 200.91,78.3 200.1,79.12 198.73,79.12 197.9,79.94 197.9,80.5 197.22,81.19 196.33,81.19 196.17,81.34 192.67,81.34 191.83,82.18 190.43,82.18 184.82,87.79 184.45,87.79 183.22,89.02 178.53,89.02
  BOTTOM w0.076: UC1.AF8 170.04,89.8 v1(169.68,89.44)
  BOTTOM w0.094: JNGFF1.5 244.6,45.77 244.44,45.93 244.44,48.17 245.34,49.06 245.34,54.49 244.71,55.12 244.71,57.66 v1(244.91,57.86)
USB20_N9: length 130
  IN1 w0.076: v1(176.59,89.49) 176.59,89.75 176.81,89.97 178.07,89.97 178.33,89.71 178.34,89.7 178.34,89.68 178.35,89.67
  IN1 w0.102: v1(107.64,124.35) 112.23,124.35 116.63,128.75 118.7,128.75 119.77,129.82 125.49,129.82 126.9,128.41 129.96,128.41 130.06,128.3 131.01,128.3 131.62,127.69 133.86,127.69 134.24,128.07 141.24,128.07 141.86,127.45 147.2,127.45 148.06,126.58 155.42,126.58 156.06,125.94 160.62,125.94 168.25,118.32 168.25,116.81 169.97,115.09 179.12,115.09 186.07,108.14 186.07,107.16 186.89,106.33 186.89,102.75 186.34,102.2 186.34,98.46 187.48,97.32 187.48,94.85 185.41,92.77 183.31,92.77 182.9,92.36 182.9,89.85 182.65,89.6 178.41,89.6 178.35,89.67
  BOTTOM w0.076: v1(176.59,89.49) 176.54,89.49 175.99,88.95 175.04,88.95 174.89,89.09 174.54,89.09 174.24,89.4 174.07,89.4 173.94,89.27 173.94,89.16 174.01,89.09 UC1.AG1
  BOTTOM w0.094: v1(107.64,124.35) 107.05,124.35 106.85,124.15 106.85,123.61 107.19,123.27 107.19,121.29 108.28,120.19 LV27.3
USB20_N9_R: length 17.8
  BOTTOM w0.094: JEDP1.2 101.89,116.95 101.93,116.73 102,116.68 102.19,116.49 104.29,116.49 104.33,116.53 104.91,116.53 104.95,116.49 v5(106.33,116.49) 108.57,116.49 109.86,117.78 110.37,117.78 110.49,117.9 DV4.2 111.31,118.6 111.44,118.47 111.44,117.52 111.54,117.42 111.84,117.42 111.94,117.52 111.94,120.11 111.64,120.4 111.07,120.4 110.86,120.19 LV27.4
USB20_N10: length 159.3
  IN2 w0.122: v1(277.28,90.68) 277.09,90.48 276.51,90.48 276.1,90.07 276.1,76.17 275.97,76.04 275.73,76.04 275.61,75.91 v1(275.61,75.7)
  IN4 w0.076: 178.53,88.4 178.52,88.4 178.51,88.42 178.15,88.42 177.71,88.86 170.86,88.86 170.72,88.72 170.72,88.61 v1(170.96,88.37)
  IN4 w0.102: 178.53,88.4 180.66,88.4 183.04,86.02 185.7,86.02 187.81,83.91 187.81,82.84 189.31,81.34 190.59,81.34 191.44,80.49 193.64,80.49 193.98,80.15 196.74,80.15 198.29,78.59 198.29,78.21 198.73,77.77 200.18,77.77 202.4,75.55 203.54,75.55 205.24,73.85 206.07,73.85 207.68,72.24 215.87,72.24 216.42,71.69 216.42,68.34 217.23,67.52 218.18,67.52 227.38,58.33 228.46,58.33 229.95,56.84 238,56.84 238.38,57.22 242.31,57.22 242.91,56.62 245.07,56.62 245.44,56.98 253.63,56.98 253.73,57.08 255.2,57.08 256.09,56.19 256.09,55.23 256.89,54.43 258.37,54.43 258.96,55.03 262.08,55.03 263.5,56.45 264.49,56.45 264.73,56.69 265.15,56.69 267.99,59.52 268.17,59.52 268.67,60.02 268.67,63.66 268.87,63.87 268.87,64.41 270.87,66.41 270.87,69.46 271.9,70.49 271.9,71.08 273.93,73.11 273.93,75.62 274.52,76.21 275.7,76.21 275.8,76.11 275.8,75.9 v1(275.61,75.7)
  BOTTOM w0.076: UC1.AH7 v1(170.96,88.37)
  BOTTOM w0.094: JNGFF2.9 279.46,90.6 279.33,90.47 277.5,90.47 v1(277.28,90.68)
USB20_P1: length 155.6
  TOP w0.094: v1(274.83,101.6) 275.03,101.8 275.31,101.8 275.47,101.64 UI3.3
  IN2 w0.122: v1(277.4,75.73) 277.38,75.74 277.38,89.11 278.5,90.23 278.5,91.68 277.54,92.63 277.54,94.9 274.99,97.46 274.99,100.28 274.32,100.95 274.32,101.66 274.45,101.79 274.64,101.79 v1(274.83,101.6)
  IN4 w0.076: 178.53,92.53 178.53,92.53 178.51,92.52 177.7,92.52 177.56,92.38 176.15,92.38 175.74,92.78 173.35,92.78 172.78,92.21 169.5,92.21 169.25,91.96 169.25,91.72 169.11,91.57 v1(169.06,91.57)
  IN4 w0.102: v1(277.4,75.73) 277.37,75.76 277.37,76.31 276.18,77.49 274.36,77.49 272.9,76.03 267.58,76.03 265.92,74.37 264.12,74.37 263.24,75.24 263.24,76.15 262.75,76.64 259,76.64 258.56,76.2 257.96,76.2 257.59,76.56 256.52,76.56 255.58,75.62 255.14,75.62 254.35,74.84 251.18,74.84 250.79,74.45 246.41,74.45 245.89,73.92 240.93,73.92 239.86,74.99 235.98,74.99 235.7,74.71 234.71,74.71 234.42,74.99 232.12,74.99 231.33,74.2 230.86,74.2 230.1,74.96 226.44,74.96 225.79,74.31 217.55,74.31 216.9,74.96 208.09,74.96 206.61,76.44 205.78,76.44 204.38,77.83 203.63,77.83 198.28,83.19 196.18,83.19 195.93,82.94 193.45,82.94 192.39,84 191.46,84 185.67,89.78 185.67,91.18 183.84,93.01 181.73,93.01 181.18,92.45 178.61,92.45 178.53,92.53
  BOTTOM w0.076: UC1.AB10 v1(169.06,91.57)
USB20_P1_R: length 12.9
  TOP w0.094: LI7.3 286.34,99.7 286.47,99.82 286.47,99.97 286.53,100.03 286.67,100.03 286.94,99.76 286.94,98.55 286.84,98.45 286.53,98.45 DI5.3 286.82,97.95 286.91,97.86 286.91,97.45 287.72,96.65 289.04,96.65 289.6,96.1 290.66,96.1 290.98,96.41 290.98,97.52 290.76,97.74 290.76,98.08 290.43,98.41 290.24,98.41 290.09,98.56 JUSB3.3
USB20_P2: length 149.7
  TOP w0.094: LZ1.4 96.01,112.99 95.99,113.09 95.97,113.24 95.97,113.26 95.89,113.31 95.75,113.31 95.36,113.7 95.36,114.24 93.26,116.33 v1(93.26,123.27)
  IN1 w0.076: v1(170.89,90.5) 171.14,90.75 171.14,90.92 171.38,91.15 175.03,91.15 175.13,91.26 175.93,91.26 177.02,92.35 177.74,92.35 177.97,92.58 177.97,92.6 177.98,92.61
  IN1 w0.102: v1(93.26,123.27) 93.46,123.08 93.46,122.78 93.79,122.45 107.53,122.45 107.97,122.9 109.12,122.9 109.62,123.4 112.46,123.4 114.08,125.02 115.03,125.02 116.88,126.86 132.49,126.86 132.85,126.5 134.01,126.5 134.75,127.24 140.89,127.24 141.51,126.62 146.82,126.62 147.69,125.75 155.08,125.75 155.72,125.11 160.22,125.11 162.65,122.68 162.65,118.95 165.07,116.53 167.34,116.53 169.62,114.26 178.78,114.26 181.48,111.55 181.48,108.39 180.28,107.18 180.28,102.99 183.23,100.04 183.51,100.04 186.65,96.9 186.65,95.19 185.08,93.62 178.99,93.62 177.98,92.61
  BOTTOM w0.076: v1(170.89,90.5) 170.89,90.77 UC1.AD7
USB20_P2_R: length 4.8
  TOP w0.094: LZ1.3 98.04,111.66 98.26,111.7 98.42,111.59 98.66,111.59 98.79,111.71 99.09,111.71 99.19,111.61 99.34,111.61 v1(99.53,111.42)
  BOTTOM w0.094: JEDP1.13 98.62,112.53 98.83,112.56 98.95,112.48 98.95,111.85 99.17,111.63 99.32,111.63 v1(99.53,111.42)
USB20_P3: length 168.5
  TOP w0.094: LI3.1 69.38,119.63 69.54,119.46 69.54,119.14 69.75,118.94 v1(71.04,118.94)
  IN1 w0.076: 178.5,89.19 177.86,89.19 176.54,87.87 176.54,87.43 176.26,87.14 v1(176.2,87.14)
  IN1 w0.102: v1(71.04,118.94) 71.41,119.31 73.59,119.31 76.88,122.6 84.62,122.6 85.72,123.71 99.02,123.71 100.07,124.76 112.03,124.76 117.49,130.22 125.78,130.22 126.69,129.31 129.65,129.31 130.25,128.71 131.25,128.71 131.48,128.48 141.41,128.48 142.04,127.85 147.39,127.85 148.25,126.99 155.59,126.99 156.23,126.35 160.92,126.35 171.77,115.49 179.29,115.49 186.54,108.25 186.54,107.33 187.35,106.52 187.35,102.52 186.77,101.94 186.77,98.71 187.89,97.59 187.89,94.62 185.59,92.31 184.08,92.31 183.74,91.97 183.59,91.97 183.31,91.69 183.31,90.19 183.64,89.86 183.64,89.48 183.35,89.19 178.5,89.19
  BOTTOM w0.076: UC1.AJ3 172.7,87.77 172.54,87.93 172.54,88.06 172.58,88.1 172.73,88.1 172.86,88.04 172.97,87.99 173.13,87.99 173.14,88 173.21,88 173.37,88.05 173.46,88.05 173.68,87.99 173.85,87.99 173.88,88 173.96,88.03 174.23,88.03 174.37,87.89 175.64,87.89 175.75,88.01 176.05,88.01 176.41,87.65 176.41,87.35 176.21,87.14 v1(176.2,87.14)
USB20_P3_R: length 11.1
  TOP w0.094: v1(69.4,124.23) 69.6,124.03 69.6,123.42 69.51,123.33 DI2.2 69.09,122.97 69.43,122.97 69.61,122.79 69.61,121.9 69.38,121.68 LI3.2
  IN1 w0.102: v1(69.4,124.23) 69.61,124.43 69.61,125.83 68.12,127.31 68.12,129.2 67.95,129.37 JUSB1.3
USB20_P4: length 149.6
  TOP w0.094: v1(86.07,121.13) 86.01,121.19 84,121.19 83.6,121.6 83.6,121.97 83.49,122.08 LI4.1
  IN1 w0.076: 178.21,93.76 178.2,93.74 178.2,93.72 177.36,92.88 176.83,92.88 175.75,91.8 171.12,91.8 170.47,91.15 169.71,91.15 169.44,90.89 169.44,90.78 169.17,90.51 v1(169.06,90.51)
  IN1 w0.102: v1(86.07,121.13) 86.44,121.5 87.01,121.5 88.21,122.7 89.61,122.7 90.5,121.81 112.27,121.81 114.63,124.17 115.67,124.17 117.74,126.24 132.09,126.24 132.45,125.88 134.29,125.88 135.03,126.62 140.62,126.62 141.24,126 146.56,126 147.42,125.13 154.82,125.13 155.47,124.48 159.97,124.48 162.01,122.44 162.01,121.49 161.45,120.92 161.45,119.02 164.56,115.91 167.09,115.91 169.36,113.64 178.52,113.64 180.8,111.36 180.8,108.74 179.57,107.5 179.57,102.83 183.08,99.31 183.27,99.31 186.03,96.56 186.03,95.45 184.83,94.25 178.71,94.25 178.21,93.76
  BOTTOM w0.076: UC1.AD10 168.9,90.73 v1(169.06,90.51)
USB20_P4_R: length 14.4
  TOP w0.094: v1(88.43,126.57) 88.61,126.39 88.61,126.06 88.52,125.97 87.54,125.97 86.39,124.81 85.96,124.81 85.86,124.91 DI3.2 85.47,125.29 85.47,125.04 85.32,124.89 83.95,124.89 83.63,124.57 83.63,124.23 83.49,124.1 LI4.2
  IN1 w0.102: v1(88.43,126.57) 88.62,126.76 88.62,127.24 88.85,127.47 90.64,127.47 91.3,128.12 91.3,129.18 91.11,129.37 JUSB2.3
USB20_P5: length 81.1
  IN2 w0.122: v1(175.02,87.14) 175.21,87.32 175.21,87.65 173.86,89 173.86,90.33 175.36,91.83 176.62,91.83 178.48,93.7 178.48,95.53 180.06,97.1 180.06,100.52 179.93,100.64 179.93,108.33 180.81,109.2 180.81,110.94 177.11,114.64 169.9,114.64 168.4,116.14 165.46,116.14 162.58,119.02 162.58,125.27 160.59,127.26 160.59,134.76 157.35,137.99 153.55,137.99 152.66,138.88 152.66,140 v1(152.46,140.21)
  BOTTOM w0.076: v1(175.02,87.14) 174.6,87.56 174.29,87.56 174.23,87.5 173.92,87.5 173.65,87.77 UC1.AJ2
  BOTTOM w0.094: v1(152.46,140.21) 152.66,140.01 152.66,139.6 152.5,139.44 JDOCK1.72
USB20_P6: length 79.5
  TOP w0.094: v1(152.98,134.58) 152.79,134.78 152.55,134.78 152.33,134.99 152.33,137.61 151.19,138.76 151.19,140 v1(150.96,140.23)
  IN2 w0.122: v1(170.31,89.44) 170.44,89.44 170.59,89.59 170.59,89.87 170.82,90.1 171.75,90.1 174.9,93.25 175.97,93.25 176.58,93.86 177.42,93.86 177.82,94.27 177.82,96.43 178.2,96.81 178.2,112.02 176.43,113.8 169.63,113.8 167.93,115.5 165,115.5 161.53,118.97 161.53,120.23 160.28,121.47 160.28,122.34 160.92,122.97 160.92,123.85 156.68,128.09 156.68,135.33 156.17,135.84 154.42,135.84 153.39,134.81 153.2,134.81 v1(152.98,134.58)
  BOTTOM w0.076: v1(170.31,89.44) 170.69,89.82 UC1.AF7
  BOTTOM w0.094: JDOCK1.66 151,139.44 151.16,139.6 151.16,140.03 v1(150.96,140.23)
USB20_P7: length 173.2
  IN4 w0.102: v1(177.69,87.63) 177.5,87.81 177.5,88 177.61,88.1 177.87,88.1 178.2,87.77 180.29,87.77 182.74,85.31 185.43,85.31 187.14,83.6 187.14,81.85 189.2,79.79 190.29,79.79 190.91,79.18 196.65,79.18 196.89,78.93 196.89,77.77 197.36,77.3 197.89,77.3 198.33,76.86 200.21,76.86 202.14,74.93 203.29,74.93 206.79,71.42 208.61,71.42 209.03,71 214.36,71 215.03,70.33 215.03,68.3 217.75,65.58 217.86,65.58 227.02,56.42 228.62,56.42 229.44,55.61 238.51,55.61 238.89,55.99 239.64,55.99 240.6,55.03 241.24,55.03 242.26,54.01 247.16,54.01 248.18,55.03 252.16,55.03 252.75,54.43 252.75,53.24 257.29,48.7 261.73,48.7 261.9,48.54 266.71,48.54 272.76,42.49 273.17,42.49 277.24,38.43 277.24,29.79 278.2,28.83 278.2,26.8 279.03,25.96 279.03,24.2 280.69,22.54 285.2,22.54 285.9,21.84 287.75,21.84 288.53,21.07 288.53,12.52 288.12,12.11 287.29,12.11 286.93,11.74 286.93,9.98 287.62,9.29 288.08,9.29 288.28,9.5 288.28,9.75 v1(288.44,9.91)
  BOTTOM w0.076: UC1.AH2 173.56,88.66 173.65,88.7 174.49,88.7 174.57,88.61 175.95,88.61 176.23,88.9 177.2,88.9 177.69,88.41 v1(177.69,87.63)
  BOTTOM w0.094: v1(288.44,9.91) 288.24,9.71 288.24,9.26 288.4,9.1 JUSH1.18
USB20_P8: length 107.6
  IN4 w0.076: v1(169.04,89.44) 169.06,89.44 169.27,89.64 169.27,89.83 169.57,90.13 171.85,90.13 172.98,91.25 175.91,91.25 177.09,90.07 177.63,90.07 178.47,89.22 178.5,89.22 178.51,89.24 178.53,89.24
  IN4 w0.102: 178.53,89.24 183.31,89.24 184.54,88.01 184.91,88.01 190.52,82.39 191.92,82.39 192.76,81.56 196.26,81.56 196.42,81.4 197.3,81.4 198.12,80.59 198.12,80.03 198.82,79.33 200.19,79.33 201.13,78.39 201.13,78 202.7,76.42 203.85,76.42 205.59,74.68 206.41,74.68 207.95,73.15 216.56,73.15 217.94,71.76 217.94,68.94 227.72,59.17 228.8,59.17 229.72,58.25 234.67,58.25 235.25,57.67 237.66,57.67 238.04,58.05 242.66,58.05 243.25,57.46 244.41,57.46 244.49,57.54 244.49,57.69 v1(244.32,57.86)
  BOTTOM w0.076: v1(169.04,89.44) 169.39,89.79 UC1.AF9
  BOTTOM w0.094: JNGFF1.3 244.1,45.77 244.26,45.93 244.26,48.25 245.15,49.14 245.15,54.42 244.52,55.05 244.52,57.66 v1(244.32,57.86)
USB20_P9: length 130
  IN1 w0.076: v1(176.01,89.49) 176.07,89.49 176.73,90.15 178.15,90.15 178.47,89.83 178.49,89.83 178.5,89.82
  IN1 w0.102: v1(107.64,123.76) 108.01,124.13 112.32,124.13 116.72,128.54 118.79,128.54 119.86,129.6 125.4,129.6 126.81,128.19 129.87,128.19 129.97,128.09 130.92,128.09 131.53,127.48 133.94,127.48 134.32,127.86 141.15,127.86 141.77,127.24 147.11,127.24 147.97,126.37 155.33,126.37 155.98,125.73 160.54,125.73 168.03,118.23 168.03,116.72 169.88,114.88 179.03,114.88 185.86,108.05 185.86,107.07 186.68,106.24 186.68,102.84 186.13,102.29 186.13,98.37 187.27,97.23 187.27,94.93 185.32,92.99 183.22,92.99 182.69,92.45 182.69,89.94 182.57,89.82 178.5,89.82
  BOTTOM w0.076: UC1.AG2 173.5,89.09 173.99,89.58 174.29,89.58 174.6,89.28 174.94,89.28 175.1,89.11 175.93,89.11 176.09,89.28 176.09,89.4 v1(176.01,89.49)
  BOTTOM w0.094: LV27.2 108.82,120.79 108.71,120.69 108.71,120.45 108.65,120.38 108.35,120.38 107.37,121.36 107.37,123.35 107.03,123.68 107.03,124.07 107.13,124.16 107.24,124.16 107.44,123.96 107.6,123.96 107.67,123.9 107.67,123.79 v1(107.64,123.76)
USB20_P9_R: length 18
  BOTTOM w0.094: JEDP1.3 101.6,116.54 101.82,116.58 101.88,116.54 102.11,116.31 v5(104.62,116.31) 106.01,116.31 106.04,116.27 106.63,116.27 106.66,116.31 108.65,116.31 109.93,117.6 110.32,117.6 110.49,117.43 DV4.3 111.35,116.67 111.44,116.76 111.44,117.09 111.59,117.24 111.91,117.24 112.12,117.45 112.12,120.18 111.72,120.58 111.07,120.58 110.86,120.79 LV27.1
USB20_P10: length 159.3
  IN2 w0.122: v1(277.28,90.1) 277.11,90.27 276.6,90.27 276.31,89.98 276.31,76.06 276.19,75.94 v1(276.19,75.7)
  IN4 w0.076: 178.53,88.62 178.51,88.62 178.5,88.6 178.23,88.6 177.79,89.05 170.78,89.05 170.54,88.8 170.54,88.58 v1(170.33,88.37)
  IN4 w0.102: v1(276.19,75.7) 276.02,75.87 276.02,76.2 275.79,76.42 274.43,76.42 273.72,75.71 273.72,73.2 271.69,71.17 271.69,70.58 270.66,69.55 270.66,66.5 268.66,64.5 268.66,63.96 268.45,63.75 268.45,60.1 268.08,59.74 267.9,59.74 265.06,56.9 264.64,56.9 264.4,56.66 263.41,56.66 261.99,55.24 258.87,55.24 258.28,54.64 256.98,54.64 256.31,55.32 256.31,56.28 255.29,57.3 253.64,57.3 253.54,57.19 245.35,57.19 244.98,56.83 243,56.83 242.39,57.43 238.29,57.43 237.91,57.05 230.04,57.05 228.55,58.54 227.47,58.54 218.27,67.74 217.32,67.74 216.63,68.43 216.63,71.78 215.96,72.45 207.77,72.45 206.16,74.06 205.33,74.06 203.63,75.76 202.49,75.76 200.26,77.99 198.82,77.99 198.5,78.3 198.5,78.68 196.82,80.36 194.07,80.36 193.73,80.7 191.53,80.7 190.67,81.55 189.4,81.55 188.02,82.93 188.02,83.99 185.79,86.23 183.13,86.23 180.74,88.62 178.53,88.62
  BOTTOM w0.076: UC1.AH8 v1(170.33,88.37)
  BOTTOM w0.094: v1(277.28,90.1) 277.47,90.28 279.26,90.28 279.45,90.1 JNGFF2.7
USB_OC0#: length 147.6
  TOP w0.102: v1(278.13,104.4) 278.22,104.31 UI3.13
  IN2 w0.102: v1(199.17,101) 198.79,101.38 198.79,101.73 200.13,103.06 213.38,103.06 214.11,102.34 214.11,101.68 215.14,100.64 230.2,100.64 231.96,102.41 232.61,102.41 v1(233.06,101.96) ; v1(277.99,92.86) 277.99,95.09 275.44,97.65 275.44,99.07 276.41,100.05 276.41,102.69 v1(278.13,104.4)
  IN4 w0.102: v1(233.06,101.96) 233.08,101.93 234.83,101.93 238.34,98.41 254.28,98.41 257.21,95.48 261.46,95.48 263.82,93.13 277.72,93.13 v1(277.99,92.86)
  BOTTOM w0.076: UC1.A9 169.68,103.47 169.68,104.45 171.05,105.83 171.89,105.83 172.92,106.85 172.92,107.92
  BOTTOM w0.102: 172.92,107.92 172.92,108.91 174.15,110.14 174.15,110.64 174.88,111.37 174.88,113.39 174.6,113.67 RPC3.3 174.6,114.86 174.75,115.01 175.84,115.01 176.41,115.58 179.33,115.58 180.74,114.17 180.74,113.27 190.26,103.75 195.02,103.75 196.27,102.5 198.11,102.5 198.79,101.82 198.79,101.38 v1(199.17,101)
USB_OC1#: length 136.5
  TOP w0.102: UI1.3 76.5,124.05 77.25,123.3 v1(78.12,123.3)
  IN1 w0.102: v1(158.77,124.04) 158.77,123.8 158.26,123.28 158.26,122.04 159.3,121 159.3,119.75 159.77,119.27 159.77,117.37 161.02,116.12 161.02,114.84 164,111.86 166.63,111.86 168.19,110.3 169.68,110.3 171.75,108.23 172.79,108.23 v1(173.44,108.87)
  IN4 w0.102: v1(158.77,124.04) 156.43,126.38 148.73,126.38 145.52,123.17 144.46,123.17 144,122.71 139.02,122.71 138.04,121.73 137.04,121.73 132.45,126.32 130.03,126.32 129.27,127.08 129.27,127.86 129.04,128.09 126.86,128.09 123.8,131.15 119.26,131.15 111.12,123.01 107.8,123.01 107,122.21 97.23,122.21 96.7,122.74 78.67,122.74 v1(78.12,123.3)
  BOTTOM w0.076: UC1.C9 169.42,102.14 169.84,102.56 169.84,104.38 170.94,105.48 172.08,105.48 173.44,106.84 173.44,107.41
  BOTTOM w0.102: 173.44,107.41 v1(173.44,108.87) 173.44,109.08 174.36,110 174.36,110.56 175.1,111.3 RPC3.2
USB_OC2#: length 117.9
  TOP w0.102: v1(97.55,123.29) 97.55,123.76 97.38,123.93 UI2.3
  IN1 w0.102: v1(174.04,108.96) 173.69,109.3 173.26,109.3 172.39,108.43 171.84,108.43 169.77,110.5 168.27,110.5 166.71,112.06 164.09,112.06 161.22,114.93 161.22,116.2 159.98,117.45 159.98,119.36 159.5,119.83 159.5,121.08 158.47,122.12 158.47,123.15 v1(159.34,124.02)
  IN4 w0.102: v1(159.34,124.02) 156.79,126.58 148.65,126.58 145.45,123.39 144.39,123.39 143.91,122.91 138.94,122.91 137.96,121.93 137.59,121.93 137.41,122.11 137.41,122.59 137.26,122.74 136.32,122.74 132.53,126.53 130.12,126.53 129.47,127.17 129.47,127.94 129.13,128.29 126.95,128.29 123.89,131.35 119.17,131.35 111.04,123.22 107.72,123.22 106.91,122.41 98.42,122.41 v1(97.55,123.29)
  BOTTOM w0.076: 173.87,106.97 172.03,105.13 170.87,105.13 170.28,104.53 170.28,102.12 170.11,101.94 169.87,101.94 169.42,101.5 UC1.D9
  BOTTOM w0.102: RPC3.1 175.6,113.66 175.32,113.38 175.32,111.24 174.56,110.47 174.56,109.48 v1(174.04,108.96) 174.04,107.14 173.87,106.97
USB_OC3#: length 14.9
  BOTTOM w0.076: UC1.B9 169.11,102.88 169.11,103.32 169.51,103.72 169.51,104.52 171.12,106.13 171.87,106.13 172.54,106.81 172.54,108.3
  BOTTOM w0.102: RPC3.4 174.1,113.81 174.67,113.24 174.67,111.69 v2(174.45,111.47) 173.95,110.97 173.95,110.23 172.54,108.82 172.54,108.3
USB_PWR_EN1#: length 231.1
  TOP w0.102: RPE9.2 v1(225.44,73.32) ; UI1.4 77.08,124.05 76.9,124.24 v1(76.9,124.68) ; UE1.B44 v1(229.24,66.48)
  IN1 w0.102: v1(229.24,66.48) 228.83,66.06 226.99,66.06 225.3,67.75 223.58,67.75 222.57,68.76 v1(222.42,68.76) ; v1(76.9,124.68) 77.57,125.36 96.33,125.36 97.32,124.36 98.71,124.36 99.73,125.38 111.78,125.38 117.24,130.84 122.58,130.84 125.4,133.66 125.4,139.02 126.26,139.89 133.25,139.89 137.16,135.97 166.04,135.97 170.36,131.65 171.32,131.65 173.95,129.02 175.98,129.02 v1(176.36,129.4)
  IN3 w0.102: v1(225.44,73.32) 223.41,75.35 209.91,75.35 208.93,76.32 202.97,76.32 202.62,75.97 201.8,75.97 200.75,77.01 200.75,81 199.46,82.29 199.46,85.96 199.76,86.25 199.76,88.44 200.85,89.54 200.85,91.56 198.35,94.06 198.35,96.11 197.16,97.29 197.16,99.68 195.74,101.1 195.74,109.61 193.69,111.67 193.69,117.46 v1(193.32,117.83)
  IN4 w0.102: v1(225.44,73.32) 223.84,73.32 222.42,71.9 v1(222.42,68.76)
  BOTTOM w0.102: v1(193.32,117.83) 193.32,117.38 192.81,116.87 180.97,116.87 180.31,117.54 180.31,123.38 176.36,127.33 v1(176.36,129.4)
USB_PWR_EN2#: length 199.4
  TOP w0.102: RPE9.3 225.99,73.82 v2(226.51,73.29) 227,72.81 v1(227,70.73) UE1.A33 ; v1(98.54,124.79) 98.54,124.09 98.7,123.93 UI2.4
  IN1 w0.102: v1(98.54,124.79) 99.33,125.58 111.69,125.58 117.15,131.04 122.49,131.04 125.19,133.75 125.19,139.11 126.18,140.09 133.33,140.09 137.25,136.17 166.12,136.17 170.44,131.85 171.4,131.85 173.84,129.41 v1(175.8,129.41)
  IN3 w0.102: v1(192.47,116) 192.47,112.29 195.34,109.42 195.34,100.93 196.76,99.51 196.76,97.12 197.94,95.94 197.94,93.84 199.78,92 199.78,89.38 198.41,88.02 198.41,86.19 198.63,85.97 198.63,82.26 200.14,80.75 200.14,79.74 199.53,79.12 199.53,77.38 201.55,75.36 205.02,75.36 205.72,74.66 209.16,74.66 209.28,74.53 216.54,74.53 218.72,72.35 220.75,72.35 223.33,69.77 226.68,69.77 227,70.09 v1(227,70.73)
  BOTTOM w0.102: v1(192.47,116) 191.79,116.67 180.89,116.67 180.11,117.45 180.11,123.17 175.92,127.36 175.92,129.29 v1(175.8,129.41)
USB_PWR_SHR_EN#: length 103.1
  TOP w0.102: UI3.6 277.22,99.86 276.06,98.7 v1(276.06,98.5) ; v1(241.16,84.41) 240.94,84.41 240.05,83.52 240.05,81.24 238.03,79.22 234.6,79.22 234.01,78.62 228.32,78.62 227.89,78.19 227.89,77.91 226.92,76.95 225.32,76.95 v2(225.09,76.71) 224,75.62 224,74.63 224.32,74.32 RPE9.4 225.88,74.32 226.51,73.69 227.51,73.69 227.74,73.46 227.74,72.25 227.58,72.09 v1(227.58,71.42) ; v1(239.81,68.86) 240.94,67.73 240.94,66.92 240.66,66.63 239.99,66.63 239.9,66.73 UE1.A8
  IN3 w0.102: v1(250.86,97.9) 250.86,96.26 254.9,92.22 262.53,92.22 263.69,93.38 270.46,93.38 272.82,95.74 275.21,95.74 276.06,96.59 v1(276.06,98.5)
  IN4 w0.102: v1(227.58,71.42) 227.73,71.27 227.73,69.76 228.52,68.97 230.78,68.97 231.14,69.33 237.45,69.33 237.92,68.86 v1(239.81,68.86) ; v1(250.86,97.9) 250.86,93.34 247.39,89.87 247.39,87.14 246.72,86.47 245.21,86.47 243.52,84.78 241.53,84.78 v1(241.16,84.41)
USB_PWR_SHR_VBUS_EN: length 94.7
  TOP w0.102: UE1.B50 229.33,63.48 v1(229.38,63.53) ; v1(275.23,88.95) 275.63,89.34 275.63,93.94 v2(274.52,95.04) 273.28,96.29 273.28,97.86 273.64,98.23 274.19,98.23 274.83,98.87 275.93,98.87 276.72,99.65 UI3.5 ; RPE9.1 225.13,72.82 225.69,72.26 v1(225.69,72.08)
  IN3 w0.102: v1(275.23,88.95) 274.57,88.95 270.71,85.09 270.71,80.51 268.66,78.46 265.28,78.46 264.46,77.64 262.31,77.64 262.19,77.77 258.53,77.77 257.58,78.72 257.58,80.11 257.77,80.31 257.77,80.97 257.54,81.2 257.18,81.2 256.85,80.88 255.78,80.88 255.14,81.52 251.55,81.52 250.73,80.7 245.16,80.7 244.92,80.46 242.07,80.46 239.24,77.63 234.53,77.63 232.9,75.99 230.6,75.99 230.33,75.73 227.48,75.73 226.45,74.7 226.45,72.84 v1(225.69,72.08)
  BOTTOM w0.102: v1(225.69,72.08) 226.37,72.08 227.57,70.89 227.57,69.04 227.77,68.84 227.77,67.52 228.3,66.99 229.99,66.99 230.25,66.73 230.25,64.84 229.38,63.98 v1(229.38,63.53)
USBCOMP: length 1.5
  TOP w0.102: RC44.1 171.13,92.22 v1(171.13,92.63)
  BOTTOM w0.076: UC1.AB6 171.34,92.41 v1(171.13,92.63)
USH_DET#: length 217
  TOP w0.102: DZ7.2 295.89,8.44 296.76,7.58 RZ87.1 296.63,7.01 v1(296.15,7.01) ; UE1.A16 239.3,70.73 v1(239.35,70.67) ; v2(180.36,96) 180.41,96.05 v1(181.28,96.05)
  IN3 w0.102: v1(197.36,95.13) 197.36,95.12 197.53,94.94 197.53,93.67 199.34,91.87 199.34,89.52 198,88.18 198,86.02 198.23,85.8 198.23,80.89 198,80.67 198,79.78 198.38,79.4 198.38,77.37 203.64,72.12 210.43,72.12 212.05,70.5 212.05,69.4 v1(212.4,69.05) 213.55,69.05 216,66.59 220.89,66.59 223.86,69.57 226.76,69.57 228.55,71.36 238.92,71.36 239.35,70.93 v1(239.35,70.67)
  IN4 w0.102: v1(296.15,7.01) 294.64,7.01 293.82,7.82 282.17,7.82 281.35,8.64 277.25,8.64 274.67,11.22 274.67,19.54 273.79,20.42 273.79,37.57 271.93,39.43 269.65,39.43 265.96,43.13 263.11,43.13 262.48,43.76 256.25,43.76 255.63,44.38 244.4,44.38 241.59,47.19 241.59,50.55 239.6,52.54 229.13,52.54 228.7,52.97 227.35,52.97 215.85,64.47 215.85,65.6 v1(212.4,69.05) ; v1(181.28,96.05) 181.43,95.9 184.41,95.9 185.39,94.92 190.68,94.92 190.99,95.23 193.81,95.23 193.88,95.17 197.32,95.17 v1(197.36,95.13)
  BOTTOM w0.102: v1(181.28,96.05) 181.15,95.92 RC281.2
USH_DET#_R: length 5.1
  TOP w0.102: v1(296.57,9.36) 296.72,9.2 DZ7.1 297.67,7.49 RZ87.2 297.67,6.57 v2(298.26,5.99)
  BOTTOM w0.102: JUSH1.1 296.9,9.02 v1(296.57,9.36)
USH_PWR_STATE#: length 129.1
  TOP w0.102: UE1.A34 226.55,70.23 v1(226.54,70.24) ; v1(295.63,9.89) 295.63,10.14 v2(295.37,10.4)
  IN4 w0.102: v1(295.63,9.89) 295.4,9.66 295.4,9.38 294.24,8.23 282.34,8.23 281.51,9.05 277.42,9.05 275.15,11.32 275.15,20.7 274.46,21.39 274.46,37.47 272.08,39.85 269.81,39.85 266.12,43.53 263.28,43.53 262.65,44.17 256.42,44.17 255.8,44.79 244.57,44.79 242,47.36 242,50.72 239.77,52.94 229.3,52.94 228.87,53.37 227.89,53.37 v1(226.5,54.76)
  BOTTOM w0.102: v1(226.54,70.24) 226.08,69.78 224.58,69.78 224.03,69.22 224.03,62.87 226.5,60.4 v1(226.5,54.76) ; RZ10.2 295.4,10.12 v1(295.63,9.89) 294.9,9.16 JUSH1.5
USH_RST#: length 124.8
  TOP w0.102: v1(293.66,12.48) v2(293.66,11.79) ; UE1.A62 235.92,61.21 235.52,60.82 v1(235.52,60.6)
  IN2 w0.102: v1(241.13,41.7) 241.13,42.4 239.68,43.85 235.89,43.85 235.34,44.4 235.34,54.02 232.85,56.51 232.85,57.93 v1(235.52,60.6)
  IN4 w0.102: v1(293.66,12.48) 294.33,11.81 296.49,11.81 297.08,11.22 297.08,7.26 296.01,6.19 289.53,6.19 289.01,6.71 284.11,6.71 283.61,7.22 280.96,7.22 279.94,8.24 277.08,8.24 274.27,11.05 274.27,19.37 273.38,20.25 273.38,37.4 271.76,39.02 269.48,39.02 265.79,42.72 263.04,42.72 260.98,40.66 259.1,40.66 258.47,41.29 258.47,42.11 258.09,42.49 241.92,42.49 v1(241.13,41.7)
  BOTTOM w0.102: RZ115.1 v1(293.66,12.48)
USH_RST#_R: length 3.4
  BOTTOM w0.102: JUSH1.6 294.4,9.69 v2(294.49,9.77) 294.55,9.84 RZ114.2 RZ115.2
USH_SMBCLK: length 86.9
  TOP w0.102: v1(257.62,73.19) UE2.A50
  IN2 w0.122: v1(289.56,9.84) 289.71,9.99 289.71,19.37 284.89,24.19 284.89,25.02 285.19,25.32 285.48,25.32 v1(285.65,25.48)
  BOTTOM w0.102: v1(257.62,73.19) 257.62,72.58 258.39,71.81 259.02,71.81 259.75,71.08 259.75,67.51 261.33,65.93 263.24,65.93 263.93,65.25 263.93,63.39 265.17,62.15 265.17,61.15 265.58,60.74 267.21,60.74 272.76,55.2 272.76,54.75 273.14,54.36 276.78,54.36 279.89,51.25 279.89,28.63 283.22,25.31 285.47,25.31 v1(285.65,25.48) ; JUSH1.16 289.4,9.02 289.54,9.17 289.54,9.36 289.74,9.55 289.74,9.66 v1(289.56,9.84) 289.74,10.02 289.74,10.17 RZ8.2
USH_SMBDAT: length 85.7
  TOP w0.102: UE2.B53 257.87,71.08 v1(257.97,70.98)
  IN2 w0.122: v1(290.14,9.84) 289.96,10.02 289.96,19.47 285.14,24.29 285.14,24.91 285.29,25.07 285.48,25.07 v1(285.65,24.9)
  BOTTOM w0.102: v1(257.97,70.98) 257.97,71.31 258.25,71.59 258.93,71.59 259.52,70.99 259.52,67.42 261.24,65.71 263.15,65.71 263.7,65.15 263.7,63.3 264.94,62.05 264.94,61.05 265.49,60.51 267.12,60.51 272.53,55.1 272.53,54.65 273.04,54.14 276.69,54.14 279.66,51.16 279.66,28.54 283.13,25.08 285.47,25.08 v1(285.65,24.9) ; RZ9.2 289.96,10.17 289.96,10.02 v1(290.14,9.84) 289.96,9.66 289.96,9.46 289.77,9.27 289.77,9.15 289.9,9.02 JUSH1.15
VCI_IN2#: length 13.2
  TOP w0.102: RPE5.4 245.86,74.57 245.45,74.98 v1(245.45,75.08) ; UE2.B63 252.87,70.9 v1(253.37,70.4)
  IN3 w0.102: v1(253.37,70.4) 252.99,70.78 252.99,71.86 251.47,73.38 251.47,73.91 250.39,74.99 245.54,74.99 v1(245.45,75.08)
VCT_LAN_R1: length 6
  TOP w0.102: RL3.2 268.03,92.2 v2(267.17,92.2) 266.68,92.2 266.43,92.45 265.44,92.45 264.2,93.69 UL1.6
VGA_ID: length 5.3
  TOP w0.102: UE1.B59 v1(232.67,63.04) ; RE84.1 RE85.1 232.84,60.35 v1(232.89,60.4)
  IN2 w0.102: v1(232.67,63.04) 232.89,62.82 v1(232.89,60.4)
VID0_PRIM_CORE: length 6.4
  TOP w0.254: PU402.9 243.66,91.07 243.94,90.79 v2(243.94,88.72) 243.94,88.38 PR408.2 PR418.2 PR420.1
VID0_VCCIO: length 7.8
  TOP w0.254: PU401.9 236.93,43.19 236.67,42.93 235.59,42.93 235.1,42.44 v2(235.1,41.18) 234.06,40.15 234.06,40.11 232.97,39.01 PR416.1 PR414.2
VID1_PRIM_CORE: length 4
  TOP w0.254: PU402.8 242.45,89.51 v2(242.72,89.24) 243.05,88.91 PR419.1 243.05,87.49 PR417.2 PR411.2
VID1_VCCIO: length 5.2
  TOP w0.254: PR413.2 233.46,41.3 233.46,41.32 PR415.1 234.29,41.8 234.63,42.15 234.63,42.47 235.62,43.46 235.62,44.17 235.81,44.36 PU401.8
VIDALERT_N: length 73.4
  IN1 w0.084: v1(78.88,88.2) 79.46,88.78 79.46,90.81 81.74,93.1 81.74,94.46 82.63,95.34 98.88,95.34 100.02,96.48 104.61,96.48 107.22,93.87 118.78,93.87 123.31,98.39 127.6,98.39 128.74,99.54 128.74,102.55 132.18,105.99 133.74,105.99 134.53,106.78 134.76,106.78 v1(135.31,107.33)
  BOTTOM w0.076: RC153.2 134.41,107.96 RC152.2 134.83,107.51 135.13,107.51 v1(135.31,107.33)
  BOTTOM w0.102: PR607.1 79.16,87.92 v1(78.88,88.2)
VIDSCLK: length 77.5
  IN1 w0.084: v1(137.03,106.75) 136.48,106.2 134.73,106.2 133.97,105.44 132.4,105.44 129.28,102.33 129.28,99.31 127.82,97.85 123.53,97.85 119.01,93.33 106.99,93.33 104.38,95.94 100.25,95.94 99.11,94.8 82.85,94.8 82.28,94.23 82.28,92.87 80,90.59 80,88.15 v1(78.88,87.03)
  BOTTOM w0.076: v1(137.03,106.75) 137.65,106.75 137.96,106.44 137.96,104.76 138.17,104.55 138.17,103.35 UC1.A63
  BOTTOM w0.102: PR606.1 v1(78.88,87.03)
VIDSOUT: length 78.4
  IN1 w0.084: v1(134.48,107.32) 134.29,107.32 133.49,106.53 131.95,106.53 128.2,102.77 128.2,99.76 127.37,98.94 123.08,98.94 118.56,94.41 107.44,94.41 104.83,97.02 99.8,97.02 98.66,95.88 82.4,95.88 78.88,92.36 v1(78.88,89.37)
  BOTTOM w0.076: RC157.2 134.13,107.32 v1(134.48,107.32) 134.77,107.32 135.27,106.83 135.56,106.83 136.52,105.87 136.52,105.42 137.84,104.09 137.84,102.58 138.06,102.36 138.06,102.12 137.77,101.82 UC1.D64
  BOTTOM w0.102: v1(78.88,89.37) 78.9,89.37 PR609.1
VMM3320_LPM_DIS: length 85.1
  TOP w0.089: UV8.B2 213.74,113.47 212.93,113.47 211,111.54
  TOP w0.102: 211,111.54 209.84,110.38 RV79.1 ; RV516.1 RV79.1 ; RV79.1 209.25,109.01 208.72,108.48 208.72,107.32 v2(209.4,106.65) 209.76,106.28 v1(210.51,106.28)
  IN2 w0.102: v1(194.76,99.56) 196.82,101.62 196.82,102.32 199.26,104.75 208.16,104.75 209.69,106.28 v1(210.51,106.28)
  IN3 w0.102: v1(194.76,99.56) 195.88,98.45 195.88,96.73 196.54,96.07 196.54,94.59 195.61,93.66 195.61,90.66 195.87,90.4 195.87,87.67 192.66,84.46 192.66,82.24 191.53,81.11 191.53,76.81 188.36,73.64 180.88,73.64 176.05,78.48 v1(176.05,78.78)
  BOTTOM w0.076: UC1.BA8 169.77,81.53 169.77,80.26 171.89,78.14 175.41,78.14 v1(176.05,78.78)
VRALERT#: length 16.5
  TOP w0.102: RC73.1 174.6,75.51 175,75.92 175,76.3 174.46,76.84 v2(172.79,76.84) 172.76,76.84 170.03,79.57 170.03,81.89 168.67,83.24 168.67,84.2 167.74,85.12 167.74,86.14 167.34,86.54 v1(167.3,86.54)
  BOTTOM w0.076: UC1.AM11 167.71,86.95 v1(167.3,86.54)
VSA_SEN+: length 143.8
  TOP w0.127: v1(86.89,91.95) PR649.2 PC640.2
  IN1 w0.254: v1(154.32,104.58) 154.35,104.54 154.35,103.6 155.65,102.29 156.65,102.29 157.02,101.93 157.02,99.21 157.75,98.48 161.33,98.48 161.41,98.4 162.27,98.4 v1(162.72,98.85)
  IN2 w0.254: v1(154.32,104.58) 154.37,104.63 154.37,107.61 150.04,111.94 150.04,113.71 147.23,116.52 147.23,119.83 146.28,120.79 146.28,122.94 144.94,124.28 137.14,124.28 134.93,122.07 132.68,122.07 131.55,120.94 125.03,120.94 124.75,120.66 120.36,120.66 117.36,117.66 104.22,117.66 103.28,116.72 98.66,116.72 98,117.38 94.05,117.38 93.46,116.79 89.45,116.79 88.92,117.32 86.65,117.32 86,116.67 85.07,116.67 84.33,117.42 79.1,117.42 78.51,118.01 78.51,118.53 v1(78.45,118.59)
  BOTTOM w0.254: v1(154.32,104.58) 154.35,104.62 154.35,105.33 RC168.2 ; v1(78.45,118.59) 78.48,118.55 78.48,115.18 79.44,114.23 79.44,104.69 82.76,101.36 84.72,101.36 87.7,98.38 87.7,94.99 86.89,94.18 PC640.2 PR649.2 v1(86.89,91.95) ; v1(162.72,98.85) 163.04,98.54 UC1.H20
VSA_SEN-: length 143
  TOP w0.127: v1(86.92,91.21) PU602.26
  IN1 w0.254: v1(161.78,98.86) 161.65,98.99 157.96,98.99 157.53,99.42 157.53,102.14 156.86,102.8 155.86,102.8 154.86,103.81 154.86,104.56 v1(154.89,104.58)
  IN2 w0.254: v1(79.03,118.59) 79.02,118.58 79.02,118.22 79.31,117.93 84.54,117.93 85.29,117.18 85.79,117.18 86.44,117.83 89.13,117.83 89.66,117.29 93.25,117.29 93.84,117.89 98.21,117.89 98.87,117.23 103.07,117.23 104.01,118.17 117.15,118.17 120.14,121.17 124.54,121.17 124.82,121.45 131.34,121.45 132.47,122.58 134.72,122.58 136.93,124.78 145.16,124.78 146.78,123.16 146.78,121 147.74,120.04 147.74,116.73 150.54,113.92 150.54,112.15 154.87,107.82 154.87,104.59 v1(154.89,104.58)
  BOTTOM w0.254: v1(86.92,91.21) 86.92,91.22 87.4,91.7 87.4,92.21 PC650.2 PC649.1 88.67,94.51 88.21,94.97 v2(88.21,95.14) 88.21,98.59 84.93,101.87 82.97,101.87 79.94,104.9 79.94,114.44 78.99,115.39 78.99,118.55 v1(79.03,118.59) ; RC166.1 154.86,105.3 154.86,104.61 v1(154.89,104.58) ; v1(161.78,98.86) 162.1,98.54 UC1.H21
VSET_5085: length 4.7
  TOP w0.102: v2(249.12,59.3) 249.97,60.16 RE77.1 250.71,59.44 CE38.1 250.87,59.72 250.5,60.09 250.5,61.16 250.62,61.28 UE2.A17
WIGIG_32KHZ: length 4.9
  TOP w0.102: RZ56.2 256.44,52.71 256.44,53.32 v1(257.1,53.98)
  BOTTOM w0.102: JNGFF1.42 255.85,53.31 256.12,53.58 256.69,53.58 v1(257.1,53.98)
WLAN_DISBL#: length 50.2
  TOP w0.102: v1(237.4,60.83) 237.4,61.76 237.17,61.99 UE1.B68 ; v1(251.76,97.83) 252.18,97.41 252.18,96.8 252.28,96.7 UL2.4
  IN4 w0.102: v1(244.19,82.29) 245.08,83.18 249.37,83.18 249.64,83.45 250.28,83.45 251.29,84.46 251.83,84.46 252.17,84.81 252.17,97.42 v1(251.76,97.83)
  BOTTOM w0.102: v1(244.19,82.29) 243.73,81.83 243.45,81.83 241.74,80.12 241.74,75.28 237.93,71.47 237.93,63.29 237.28,62.64 237.28,60.95 v1(237.4,60.83)
WLAN_WIGIG60GHZ_DIS#: length 29.2
  TOP w0.102: DZ1.1 253.59,48.23 251.62,50.2 247.74,50.2 247.13,50.81 247.13,52.9 245.51,54.52 245.01,54.52 242.99,56.54 242.99,56.84 v2(241.95,57.88) 241.48,58.35 240.79,58.35 240.34,58.8 240.34,59.47 240.83,59.95 240.83,62.21 RE8.2 239.81,63.23 UE1.A1
WLAN_WIGIG60GHZ_DIS#_R: length 3.3
  TOP w0.102: DZ1.2 257.53,50.05 v1(256.85,50.73)
  BOTTOM w0.102: v1(256.85,50.73) 257.35,51.23 JNGFF1.48
WWAN_PWR_EN: length 4
  TOP w0.102: v1(274.77,90.37) 274.5,90.64 v2(274.18,90.64) RZ43.2
  BOTTOM w0.102: JNGFF2.6 273.54,89.85 274.06,90.37 v1(274.77,90.37)
WWAN_RADIO_DIS#: length 92.1
  TOP w0.102: RE10.2 230.99,59.5 v1(230.99,60.44) 231.42,60.87 UE1.A53 ; v1(268.17,90.29) 269.14,90.29 270.49,91.65 DZ5.1 ; v1(221.83,72.25) 221.83,71.81 v2(221.91,71.73) 222.07,71.57 222.07,69.93 223.9,68.11 225.22,68.11 v1(225.84,68.73)
  IN2 w0.102: v1(237.25,82.75) 237.96,82.04 237.96,79.46 236.6,78.1 234.4,78.1 232.28,75.98 224.5,75.98 222.72,74.2 222.72,72.79 222.18,72.25 v1(221.83,72.25)
  IN3 w0.102: v1(237.25,82.75) 237.54,83.04 239.08,83.04 241,84.96 244.07,84.96 244.74,84.29 245.51,84.29 246.26,85.04 246.92,85.04 248.02,86.14 252.07,86.14 254.06,88.13 255.02,88.13 255.23,87.92 261.2,87.92 264.84,84.29 266.85,84.29 267.43,84.87 267.43,88.87 268.17,89.61 v1(268.17,90.29)
  BOTTOM w0.102: v1(230.99,60.44) 230.99,61.02 230.52,61.49 226.12,61.49 224.44,63.17 224.44,64.69 225,65.25 225,67.89 v1(225.84,68.73)
WWAN_RADIO_DIS#_R: length 3.9
  TOP w0.102: v2(274.74,91.94) 274.37,91.58 v1(274.21,91.58) 274.14,91.65 DZ5.2
  BOTTOM w0.102: v1(274.21,91.58) 274.21,90.99 273.57,90.35 JNGFF2.8

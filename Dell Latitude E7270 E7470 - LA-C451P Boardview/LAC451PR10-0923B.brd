# Allegro board LAC451PR10-0923B.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
KB_DET#: length 166.3
  IN3 w0.102: v1(203.15,74.52) 205.34,72.32 210.52,72.32 213.31,69.53 214.25,69.53 216.47,67.3 216.95,67.3 v1(217.28,66.98)
  IN4 w0.102: v1(270.38,48.42) 270.38,48.87 266.89,52.36 256.73,52.36 253.4,55.69 247.89,55.69 246.83,54.63 245.06,54.63 244.1,55.58 241.9,55.58 241.28,56.21 240.3,56.21 239.89,56.61 238.63,56.61 238.25,56.23 229.69,56.23 228.88,57.04 227.27,57.04 220.75,63.57 220.75,64.09 218.34,66.5 217.75,66.5 v1(217.28,66.98)
  BOTTOM w0.076: 177.3,77.92 177.04,77.92 176.58,78.38 176.58,78.76 176.15,79.19 172.39,79.19 171.51,80.07 170.88,80.07 UC1.BB7
  BOTTOM w0.102: v1(270.38,48.42) 270.38,44.12 273.1,41.4 273.1,20.15 274.35,18.9 274.35,9.94 277.75,6.54 277.75,5.14 279.11,3.77 JKBTP1.1 ; 177.3,77.92 178.09,77.92 178.28,77.73 179.36,77.73 RC288.1 181.37,75.73 181.95,75.73 183.17,74.5 188.13,74.5 189.18,75.55 191.04,75.55 192.06,74.53 194.93,74.53 195.74,75.35 198.33,75.35 199.75,73.92 202.55,73.92 v1(203.15,74.52)
LAN_ACTLED_YEL#: length 2.6
  TOP w0.102: QL1.6 287.82,120.23 287.75,120.29 RL14.1 v2(288.72,120.86)
LAN_ACTLED_YEL_R#: length 20.9
  TOP w0.102: RL14.2 v1(287.75,122.55) v2(287.75,123.17)
  IN3 w0.102: JLOM1.10 271.89,125.71 285.81,125.71 287.75,123.77 v1(287.75,122.55)
LAN_DISABLE#_R: length 100.1
  TOP w0.102: v1(281.37,86.32) 279.97,86.32 279.59,85.94 v2(272.01,85.94) 270.58,85.94 269.55,86.97 269.55,88.43 269.22,88.76 RL7.2 RL9.1 RL5.2 266.63,89.25 266.02,89.25 265.07,90.19 265.07,91.46 264.05,92.49 UL1.3 ; v1(230.17,63.6) 229.78,63.22 229.78,62.76 229.67,62.65 UE1.B53
  IN3 w0.102: v1(281.37,86.32) 281.14,86.09 281.14,81.58 283.49,79.23 283.49,74.65 280.69,71.85 280.69,67.61 278.33,65.25 263.34,65.25 262.91,65.68 259.91,65.68 259.67,65.92 251.83,65.92 251.63,66.12 250.18,66.12 248.95,64.89 247.87,64.89 247.38,65.39 246.32,65.39 246.05,65.12 243.05,65.12 241.55,66.62 238.81,66.62 238.64,66.46 236.62,66.46 236.1,65.93 236.1,65.09 235.05,64.04 230.6,64.04 v1(230.17,63.6)
LAN_MDIN0: length 7.5
  TOP w0.089: UL1.14 262,97.43 262.03,97.47 262.03,99.98 v5(264.07,102.02) 264.42,102.37 264.42,102.61 RL72.1
LAN_MDIN0_L: length 4.1
  TOP w0.089: UL4.11 262.47,106.49 262.55,106.4 262.55,105.95 v5(262.84,105.65) 263.19,105.31 264.24,105.31 264.41,105.15 264.41,105.08 RL72.2
LAN_MDIN1: length 7
  TOP w0.089: RL74.1 261.63,102.61 261.63,102.05 v5(261.33,101.75) 260.43,100.86 260.43,97.6 260.4,97.56 UL1.18
LAN_MDIN1_L: length 2.8
  TOP w0.089: RL74.2 261.64,105.11 261.64,105.25 261.54,105.35 v5(261.54,105.69) 261.54,106.38 261.47,106.46 261.47,107.02
LAN_MDIN2: length 6.7
  TOP w0.089: UL1.21 259.2,97.56 259.23,97.6 259.23,99.88 258.83,100.28 v5(258.83,102.04) 258.83,102.62 RL76.1
LAN_MDIN2_L: length 3.6
  TOP w0.089: UL4.6 259.97,106.49 260.06,106.4 260.06,106.02 259.73,105.7 259.17,105.7 258.83,105.36 258.83,105.09 RL76.2
LAN_MDIN3: length 7.3
  TOP w0.089: UL1.24 258,97.5 257.9,97.6 257.9,99.46 v5(256.54,100.82) 256.03,101.33 256.03,102.62 RL78.1
LAN_MDIN3_L: length 4.4
  TOP w0.089: RL78.2 256.03,105.08 256.03,105.33 256.33,105.63 v5(256.73,105.63) 257.66,105.63 258.06,106.03 258.06,106.39 257.97,106.48 UL4.2
LAN_MDIP0: length 7.5
  TOP w0.089: UL1.13 262.4,97.47 262.35,97.51 262.35,99.85 v5(263.32,100.81) 264.74,102.24 264.74,102.62 RL71.1
LAN_MDIP0_L: length 4.1
  TOP w0.089: UL4.12 262.97,106.5 262.87,106.4 262.87,106.08 263.32,105.63 v5(264.14,105.63) 264.38,105.63 264.73,105.28 264.73,105.1 RL71.2
LAN_MDIP1: length 7
  TOP w0.089: UL1.17 260.8,97.54 260.75,97.59 v5(260.75,100.25) 260.75,100.73 261.94,101.92 261.94,102.61 RL73.1
LAN_MDIP1_L: length 2.8
  TOP w0.089: RL73.2 261.96,105.07 261.96,105.38 261.86,105.48 261.86,106.36 261.97,106.46 UL4.10
LAN_MDIP2: length 6.7
  TOP w0.089: UL1.20 259.6,97.6 259.55,97.64 v5(259.55,99.56) 259.55,100.01 259.14,100.42 259.14,102.61 RL75.1
LAN_MDIP2_L: length 3.6
  TOP w0.089: RL75.2 259.15,105.09 259.15,105.23 259.3,105.38 259.86,105.38 v5(260.11,105.63) 260.38,105.89 260.38,106.39 260.47,106.48 UL4.7
LAN_MDIP3: length 7.4
  TOP w0.089: RL77.1 256.35,102.61 256.35,101.46 v5(257.72,100.09) 258.21,99.59 258.21,97.73 258.4,97.55 UL1.23
LAN_MDIP3_L: length 4.4
  TOP w0.089: RL77.2 256.35,105.1 256.35,105.2 256.47,105.32 257.79,105.32 v5(258.16,105.68) 258.38,105.9 258.38,106.37 258.47,106.46 UL4.3
LAN_TEST_EN: length 3.3
  TOP w0.102: UL1.30 256.26,94.09 v2(256.05,93.89) 255.95,93.79 255.95,93.4 255.31,92.76 255.08,92.76 RL12.1
LAN_WAKE#: length 157.1
  TOP w0.102: RC323.2 181.81,71.04 v1(181.02,71.83) ; RL70.2 266.18,88.76 264.68,90.25 v1(264.68,90.45) 264.68,91.25 v2(264.39,91.53) 263.84,92.09 UL1.2 ; v1(254.37,63.66) 254.87,63.16 UE2.B27
  IN1 w0.076: 174.15,76.94 174.15,77.52 171.52,80.15 169.9,80.15 168.83,81.22 168.01,81.22 166.01,83.21 166.01,86.17 v1(166.38,86.54)
  IN1 w0.102: v1(254.37,63.66) 254.83,64.12 256.15,64.12 256.99,64.95 260.04,64.95 260.57,64.42 263.21,64.42 263.91,63.72 266.44,63.72 267.04,64.32 268.15,64.32 v1(268.26,64.21) ; 174.15,76.94 174.15,76.01 177.83,72.34 180.51,72.34 v1(181.02,71.83) 181.02,71.54 182.29,70.27 196.87,70.27 206.09,61.05 229.23,61.05 229.44,61.26 233.8,61.26 v1(234.43,60.63)
  IN4 w0.102: v1(234.43,60.63) 234.43,60.91 234.73,61.21 238.1,61.21 239.02,60.28 245.53,60.28 246.33,59.49 247.28,59.49 249.76,61.96 252.92,61.96 253.9,62.94 253.9,63.18 v1(254.37,63.66)
  BOTTOM w0.076: UC1.AM15 v1(166.38,86.54)
  BOTTOM w0.102: v1(264.68,90.45) 264.68,87.71 266,86.39 266,79.33 265.5,78.84 265.5,66.72 268.02,64.21 v1(268.26,64.21)
LCD_CBL_DET#: length 261.1
  TOP w0.102: v1(187.96,67.91) 187.96,67.88 187.98,67.86 187.98,67.41 188.53,66.86 189.86,66.86 192.95,69.95 192.95,73.76 192.2,74.51 RC287.1 192.55,75.09 193.18,74.47 197.45,74.47 200.7,77.72 200.7,78.37 201.82,79.49 201.82,84.21 199.97,86.05 198.58,86.05 197.58,87.05 194.07,87.05 v1(193.76,86.75)
  IN2 w0.102: v1(85.19,59.09) 85.43,59.33 92.18,59.33 92.98,60.13 93.37,60.13 94.12,59.38 182.17,59.38 184.99,62.19 184.99,64.15 188,67.16 188,67.56 187.97,67.59 187.97,67.89 v1(187.96,67.91)
  IN3 w0.102: v1(66.75,59.66) 66.77,59.64 67.4,59.64 68.12,58.91 69.81,58.91 70.19,58.53 72.43,58.53 72.81,58.91 74.6,58.91 75.68,59.99 84.29,59.99 v1(85.19,59.09) ; v1(193.76,86.75) 195.23,88.22 195.23,90.17 193.79,91.61 186.07,91.61 184.71,90.25 183.01,90.25 182.65,89.9 179.05,89.9 178.51,90.45 177.51,90.45 v1(177.06,90.89)
  IN4 w0.102: v1(66.75,59.66) 66.47,59.94 64.72,59.94 64.04,60.62 64.04,61.76 63.13,62.68 63.13,68.62 69.1,74.59 69.1,77.07 76.76,84.73 76.76,94.2 84.95,102.39 91.68,102.39 92.3,101.76 v1(92.3,101.38)
  BOTTOM w0.076: v1(177.06,90.89) 176.67,91.28 174.68,91.28 174.61,91.21 174.33,91.21 173.8,91.36 173.8,91.36 172.72,91.36 UC1.AC3
  BOTTOM w0.102: v1(92.3,101.38) 91.92,101 91.29,101 91.03,101.25 91.03,101.38 JEDP1.40
LCD_TST: length 244
  TOP w0.102: RE20.2 225.41,70.52 v1(225.71,70.22) 226.7,69.23 UE1.A36 ; v1(78.01,93.14) 77.54,93.61 77.54,94.66 78.12,95.24 81.47,95.24 84.99,98.76 90.5,98.76 94.51,102.78 94.51,105 94.08,105.44 v1(94.08,105.44)
  IN1 w0.102: v1(77.57,52.65) 77.57,53.01 76.25,54.33 72.17,54.33 67.6,58.9 67.6,59.39 66.68,60.31 v1(66.68,61.41)
  IN2 w0.102: v1(225.71,70.22) 222.44,70.22 221.23,69 221.23,66.36 210.69,55.83 89.06,55.83 88.81,56.08 88.81,56.64 88.54,56.9 87.81,56.9 87.11,56.21 84.67,56.21 81.74,53.29 78.75,53.29 78.12,52.65 v1(77.57,52.65) ; v1(66.82,66.61) 66.55,66.61 64.42,64.48 64.42,62.31 65.4,61.34 66.61,61.34 v1(66.68,61.41)
  BOTTOM w0.102: v1(66.82,66.61) 65.76,67.67 65.76,72.67 75.26,82.17 75.26,91.17 76.4,92.31 77.41,92.31 78.01,92.92 v1(78.01,93.14) ; v1(94.08,105.44) 94.08,105.94 JEDP1.29
LCD_VCC_TEST_EN: length 245.3
  TOP w0.102: v1(83.82,106.18) 83.12,106.18 v2(82.94,106.36) 82.67,106.36 82.38,106.65 DV3.2 ; UE1.A40 226.92,67.23 v1(226.42,67.73)
  IN1 w0.102: v1(68.16,49.49) 68.16,49.77 66.9,51.02 62.6,51.02 61.19,52.44 61.19,59.08 60.63,59.64 60.63,65.39 v1(61.66,66.42)
  IN2 w0.102: v1(68.16,49.49) 68.7,49.49 71.38,52.17 75.96,52.17 76.85,51.28 80.91,51.28 85.03,55.4 87.25,55.4 87.86,54.8 215.17,54.8 222.83,62.46 222.83,66.97 223.59,67.73 v1(226.42,67.73)
  IN4 w0.102: v1(83.82,106.18) 83.41,105.77 83.41,102.58 75.54,94.7 75.54,85.24 67.88,77.58 67.88,75.1 61.66,68.87 v1(61.66,66.42)
LED_10_GRN#: length 2.8
  TOP w0.102: v2(281.79,116.58) 282.01,116.58 RL19.1 283.15,115.45 QL2.6
LED_10_GRN_R#: length 11.6
  TOP w0.102: RL19.2 282.43,117.08 282.43,124.53 v2(281.96,124.99) JLOM1.11
LED_100_ORG#: length 2.1
  TOP w0.102: QL1.3 284.81,118 RL20.1 284.01,118 v2(283.91,117.9)
LED_100_ORG_R#: length 8.9
  TOP w0.102: RL20.2 282.78,120.95 v2(282.78,123.19) 282.78,124.6 282.41,124.96 JLOM1.13
LED_SATA_DIAG_OUT#: length 80.2
  TOP w0.102: v1(239.38,54.52) 239.38,55.42 239.46,55.5 v2(239.46,55.79) ; v1(239.34,67.59) 239.2,67.73 UE1.A10 ; v1(278.41,20.46) 278.48,20.38 DZ4.1
  IN2 w0.102: v1(239.34,67.59) 239.34,67.05 238.76,66.47 238.76,63.94 239.58,63.13 239.58,61.46 239.16,61.04 239.16,56.48 239.8,55.84 239.8,54.94 v1(239.38,54.52)
  IN4 w0.102: v1(278.41,20.46) 277.24,20.46 275.47,22.22 275.47,37.89 272.5,40.86 270.23,40.86 266.55,44.55 263.7,44.55 263.02,45.23 256.98,45.23 256.51,45.7 256.51,47.24 254.79,48.96 254.03,48.96 252.68,50.31 247.77,50.31 245.51,52.57 241.58,52.57 239.63,54.52 v1(239.38,54.52)
LID_CL#: length 96.3
  TOP w0.102: UZ10.2 v1(279.21,15.02) ; RE26.1 v2(226.62,56.98) v1(228.83,54.77)
  IN4 w0.102: v1(228.83,54.77) 229.84,53.76 240.11,53.76 241.49,52.37 245.43,52.37 247.69,50.11 250.46,50.11 251.62,48.95 251.62,46.46 252.44,45.64 256.1,45.64 256.71,45.03 262.93,45.03 263.62,44.34 266.46,44.34 270.14,40.66 272.42,40.66 275.27,37.81 275.27,21.73 277.49,19.51 277.49,17.23 279.21,15.51 v1(279.21,15.02)
  BOTTOM w0.102: JLED1.7 288.53,15.95 288.25,15.67 287.64,15.67 287.35,15.96 285.65,15.96 284.33,14.64 281.4,14.64 281.09,14.32 279.91,14.32 v1(279.21,15.02)
LID_CL_SIO#: length 9.8
  TOP w0.102: v1(228.33,62.48) 228.31,62.45 v2(228.31,60.47) 228.31,59.51 CE8.1 RE25.2 RE26.2 ; UE1.B54 v1(230.17,63.02)
  IN2 w0.102: v1(230.17,63.02) 230.55,63.41 230.55,63.79 230.3,64.04 229.23,64.04 228.33,63.14 v1(228.33,62.48)
LOM_ACTLED_YEL#: length 22
  TOP w0.102: UL1.26 v1(256.36,95.69) ; UL4.15 264.47,106.39 265.96,104.9 265.96,102.51 v1(266.19,102.28) v2(266.19,101.65)
  IN3 w0.102: v1(266.19,102.28) 258.73,102.28 256.36,99.91 v1(256.36,95.69)
LOM_SPD10LED_GRN#: length 26.9
  TOP w0.102: UL1.25 255.44,96.09 v1(255.39,96.05) UL2.2 ; UL4.42 256.22,108 256.11,107.88 v2(251.41,107.88) 249.65,107.88 v1(247.61,105.84)
  IN1 w0.102: v1(247.61,105.84) 248.79,105.84 255.8,98.83 255.8,96.45 v1(255.39,96.05)
LOM_SPD100LED_ORG#: length 24.9
  TOP w0.102: UL2.1 v1(255.41,95.4) 255.82,95.4 255.92,95.29 UL1.27 ; v1(266.75,102.27) 266.75,102.87 v2(266.64,102.97) 266.16,103.45 266.16,104.98 264.97,106.18 UL4.16
  IN3 w0.102: v1(266.75,102.27) 266.35,102.66 258.82,102.66 255.78,99.61 255.78,95.76 v1(255.41,95.4)
LPC_AD0: length 173.6
  TOP w0.102: UE1.A27 231.92,73.18 v1(231.76,73.34) ; UE2.A30 257.12,60.8 v1(257.62,60.3)
  IN1 w0.102: v1(258.85,41.45) 261.09,41.45 263.55,43.91 264.03,43.91 265.2,45.08 265.2,46.2 266.18,47.18 268.16,47.18 271.37,50.38 271.37,51.1 272.39,52.12 274.76,52.12 277.19,54.55 277.19,56.68 275.45,58.43 272.54,58.43 270.98,59.99 v1(270.28,59.99)
  IN3 w0.102: v1(270.28,59.99) 268.17,62.1 261.13,62.1 260.59,61.55 260.59,61.01 259.88,60.3 v1(257.62,60.3) 257.58,60.3 255.53,58.25 250.97,58.25 249.11,60.11 247.83,60.11 247.42,59.69 245.32,59.69 243.49,57.86 242.89,57.86 242.61,58.14 240.96,58.14 237.22,61.88 233.36,61.88 233.06,62.19 233.06,63.24 v1(232.69,63.61)
  BOTTOM w0.076: 167.42,77.72 166.74,78.41 166.74,78.71 166.61,78.84 166.61,80.29 166.49,80.41 166.49,80.69 166.54,80.81 166.54,80.95 166.48,81.18 166.48,81.3 166.55,81.5 166.65,81.62 166.75,81.73 UC1.AY13
  BOTTOM w0.102: v1(258.85,41.45) 258.85,41.55 258.06,42.34 255.71,42.34 255.5,42.13 JLPDE1.3 ; 167.42,77.72 168.11,77.03 v2(168.37,77.03) 168.64,77.03 169.99,75.69 169.99,74.85 170.96,73.88 175.54,73.88 176.13,73.29 195.76,73.29 196.14,73.67 197.76,73.67 198.02,73.41 198.02,72.87 198.18,72.7 204.35,72.7 205.71,74.06 213.97,74.06 214.14,73.88 221.15,73.88 221.57,74.31 226.3,74.31 226.89,74.9 230.2,74.9 v1(231.76,73.34) 231.76,73 230.13,71.37 229.55,71.37 229.28,71.1 229.28,70.67 230.21,69.74 230.21,69.47 232.46,67.23 232.46,63.84 v1(232.69,63.61)
LPC_AD1: length 167
  TOP w0.102: UE2.B32 257.37,63.04 v1(257.41,63.08) ; UE1.A26 232.42,73.11 v1(232.59,73.27)
  IN1 w0.102: v1(257.41,63.08) 257.41,62.68 257.73,62.37 259.49,62.37 260.49,63.37 263.29,63.37 263.58,63.08 266.73,63.08 266.86,63.22 268.2,63.22 269.35,62.06 269.35,59.64 271.22,57.77 275.24,57.77 276.58,56.43 276.58,54.81 274.55,52.78 272.11,52.78 267.12,47.79 265.83,47.79 263.74,45.69 263.74,44.96 261.15,42.38 260.19,42.38 259.76,42.81 259.38,42.81 258.86,42.29 v1(258.86,42.07)
  IN3 w0.102: v1(234.12,63.65) 234.43,63.65 234.82,63.25 235.2,63.25 236.26,64.31 239.71,64.31 240.66,63.36 249.6,63.36 249.88,63.64 250.89,63.64 251.72,64.46 256.16,64.46 256.93,63.69 256.93,63.56 v1(257.41,63.08)
  BOTTOM w0.076: UC1.BA13 166.75,81.03 167.02,80.76 167.02,79.42 167.93,78.51 v2(167.93,78.32) 169.89,76.37
  BOTTOM w0.102: v1(234.12,63.65) 233.79,63.98 233.79,67.28 230.63,70.44 230.63,71.13 232.59,73.08 v1(232.59,73.27) 232.59,73.36 231.79,74.16 231.79,74.91 231.37,75.32 220.5,75.32 220.28,75.1 219.23,75.1 218.41,74.29 214.31,74.29 214.14,74.47 205.54,74.47 204.38,73.31 199.5,73.31 198.74,74.07 195.97,74.07 195.59,73.69 176.3,73.69 175.71,74.28 171.13,74.28 170.4,75.02 170.4,75.85 169.89,76.37 ; JLPDE1.4 255,42.3 255.24,42.54 258.39,42.54 v1(258.86,42.07)
LPC_AD2: length 177.6
  TOP w0.102: v1(230.43,70.07) 230.9,70.07 231.33,70.51 233.13,70.51 233.31,70.68 233.31,71.07 233.17,71.21 UE1.B26 ; v1(270.28,60.63) v2(270.28,61.25) ; UE2.A31 v1(257.62,60.88)
  IN1 w0.102: v1(270.28,60.63) 270.79,60.63 272.76,58.65 275.51,58.65 277.39,56.77 277.39,54.47 274.83,51.9 272.46,51.9 271.57,51.02 271.57,50.3 268.25,46.97 266.29,46.97 265.41,46.09 265.41,45 264.12,43.71 263.64,43.71 260.99,41.07 v1(259.36,41.07)
  IN3 w0.102: v1(233.47,63.6) 233.26,63.38 233.26,62.27 233.44,62.09 237.3,62.09 241.05,58.34 242.69,58.34 242.97,58.06 243.41,58.06 245.24,59.89 247.33,59.89 247.75,60.31 249.2,60.31 251.05,58.45 255.45,58.45 257.01,60.02 257.01,60.26 v1(257.62,60.88) 258,60.5 259.79,60.5 260.36,61.07 260.36,61.68 260.98,62.3 268.6,62.3 v1(270.28,60.63)
  BOTTOM w0.076: UC1.BB13 166.75,80.39 166.85,80.3 166.85,78.83 166.91,78.77 166.91,78.48 167.55,77.85 168.12,77.85 169.89,76.08
  BOTTOM w0.102: v1(259.36,41.07) 259.24,41.18 259.24,42.29 258.79,42.74 255.08,42.74 254.5,42.17 JLPDE1.5 ; 169.89,76.08 170.19,75.77 170.19,74.93 171.05,74.08 175.62,74.08 176.21,73.49 195.68,73.49 196.06,73.87 198.65,73.87 199.41,73.11 204.47,73.11 205.62,74.27 214.05,74.27 214.23,74.09 221.07,74.09 221.49,74.51 226.22,74.51 226.81,75.1 231.3,75.1 231.58,74.82 231.58,74.08 232.15,73.5 232.15,73.11 230.43,71.38 v1(230.43,70.07) 230.81,69.69 231.1,69.69 232.7,68.09 232.7,64.37 v1(233.47,63.6)
LPC_AD3: length 171
  TOP w0.102: UE1.B25 233.67,70.75 233.01,70.1 v1(232.32,70.1) ; v1(257.41,63.66) 257.87,63.2 UE2.B33
  IN1 w0.102: v1(259.62,42.4) 259.85,42.17 261.24,42.17 263.94,44.88 263.94,45.6 265.92,47.58 267.2,47.58 272.2,52.57 274.64,52.57 276.78,54.72 276.78,56.52 275.32,57.98 271.3,57.98 269.55,59.72 269.55,62.15 268.28,63.42 266.78,63.42 266.64,63.28 263.75,63.28 263.46,63.57 260.35,63.57 259.35,62.57 258.07,62.57 257.86,62.78 257.86,63.21 v1(257.41,63.66)
  IN3 w0.102: v1(257.41,63.66) 257.25,63.66 256.24,64.66 251.63,64.66 250.81,63.84 247.77,63.84 247.49,64.12 245.37,64.12 244.88,63.62 240.68,63.62 239.79,64.51 235.81,64.51 v1(234.96,63.66)
  BOTTOM w0.076: UC1.AY12 167.32,82.02 167.02,81.71 167.02,81.29 167.18,81.12 167.18,79.49 168.36,78.31 168.36,78.18 169.89,76.65
  BOTTOM w0.102: v1(234.96,63.66) 234.03,64.59 v2(234.03,69) 232.93,70.1 v1(232.32,70.1) 232.03,70.1 231.43,70.7 231.43,71.22 232.98,72.77 232.98,73.45 232.71,73.72 232.51,73.72 231.99,74.24 231.99,74.99 231.46,75.52 220.42,75.52 220.2,75.31 219.14,75.31 218.58,74.75 205.53,74.75 204.3,73.51 199.58,73.51 198.82,74.28 195.88,74.28 195.49,73.9 177.25,73.9 176.66,74.49 171.22,74.49 170.6,75.1 170.6,75.94 169.89,76.65 ; v1(259.62,42.4) 259.08,42.95 254.84,42.95 254,42.1 JLPDE1.6
LPC_FRAME#: length 176
  TOP w0.102: UE1.A21 234.92,73.04 v1(235.4,73.53) ; UE2.B31 256.87,63.18 v1(256.4,63.66)
  IN1 w0.102: v1(256.4,63.66) 256.78,64.04 257.58,64.04 258.16,63.46 259.74,63.46 260.06,63.78 263.54,63.78 263.83,63.49 266.56,63.49 266.69,63.62 268.37,63.62 269.76,62.23 269.76,59.81 271.37,58.19 275.39,58.19 276.99,56.6 276.99,54.64 274.71,52.36 272.26,52.36 267.29,47.38 266.09,47.38 265,46.29 265,45.17 263.95,44.12 263.47,44.12 261.19,41.84 v1(259.64,41.84)
  IN2 w0.102: v1(235.4,73.53) 235.39,73.55 235.39,74.54 235.9,75.05 235.9,76.87 v1(235.57,77.2)
  IN3 w0.102: v1(235.57,63.04) 235.57,63.11 236.56,64.11 239.62,64.11 240.57,63.15 245.39,63.15 246.12,62.42 249.22,62.42 250.24,63.43 250.97,63.43 251.8,64.26 255.69,64.26 256.29,63.66 v1(256.4,63.66)
  BOTTOM w0.076: UC1.BA12 167.35,81.53 167.35,79.56 168.6,78.3 168.6,78.23 170,76.83
  BOTTOM w0.102: v1(235.4,73.53) 235.4,72.86 233.72,71.17 233.72,70.23 234.38,69.57 234.38,66.48 235.46,65.4 235.46,63.15 v1(235.57,63.04) ; v1(235.57,77.2) 234.31,75.94 v2(234.17,75.94) 233.96,75.73 220.33,75.73 220.12,75.51 219.06,75.51 218.5,74.95 205.45,74.95 204.21,73.72 199.67,73.72 198.91,74.48 195.79,74.48 195.41,74.1 177.55,74.1 176.81,74.84 171.16,74.84 170.8,75.19 170.8,76.02 170,76.83 ; JLPDE1.7 253.5,41.89 254.76,43.15 259.26,43.15 259.52,42.88 259.7,42.88 260,42.58 260,42.21 v1(259.64,41.84)
LPC_LDRQ1#: length 3.4
  TOP w0.102: UE1.A22 234.42,73.2 v2(234.87,73.66) 236.08,74.86 RPE8.1
LX_1.8VALW: length 1.3
  TOP w0.102: PR502.1 v2(288.71,2.07)
LX_1V_PRIM: length 0.6
  TOP w0.102: 236.5,94.45 v2(235.91,94.45)
LX_1VS_VCCIO: length 1.1
  TOP w0.102: 235.77,48.59 235.04,49.32 v2(235.04,49.42)
LX_3V:
  vias: v1(218.44,89.11) v1(219.02,89.11) v2(216.34,91.35)
LX_5V:
  vias: v1(209.36,89.15) v1(209.94,89.15) v2(209.29,89.73)
M2_DEVSLP: length 271.4
  TOP w0.102: v1(179.59,100.1) 179.54,100.15 176.69,100.15 176.34,99.79 v1(176.34,99.22) ; v2(17.61,38.81) 17.23,38.81 RN37.2 16.58,38.16 v1(16.58,37.33)
  IN1 w0.102: v1(189.71,76.18) 189.71,75.92 186.51,72.72 v1(186.51,71.84)
  IN2 w0.102: v1(93.17,59.74) 93.73,59.18 182.26,59.18 185.19,62.11 185.19,64.06 188.38,67.25 188.38,69.66 186.51,71.52 v1(186.51,71.84) ; JNGFF3.38 16.2,33.85 16.58,34.24 v1(16.58,37.33) 16.58,40.08 19.02,42.52 21.44,42.52 22.51,43.6 35.3,43.6 40.33,38.57 55.27,38.57 56.56,39.85 63.41,39.85 67.41,43.85 v1(80.43,43.85)
  IN3 w0.102: v1(189.71,76.18) 189.86,76.33 189.86,77.24 191.12,78.5 191.12,81.28 192.16,82.32 192.16,84.54 195.44,87.81 195.44,90.26 195.2,90.49 195.2,93.83 196.14,94.76 196.14,95.82 192.5,99.45 189.54,99.45 188.81,100.17 181.89,100.17 181.26,100.8 180.29,100.8 v1(179.59,100.1)
  IN4 w0.102: v1(93.17,59.74) 93.46,59.44 93.46,42.84 93.01,42.39 81.42,42.39 80.43,43.38 v1(80.43,43.85)
  BOTTOM w0.076: UC1.J3 173.06,98.08 174.22,98.08 174.52,98.37 175.49,98.37 v1(176.34,99.22)
MASK_BASE_LEDS#: length 12.2
  TOP w0.102: UZ10.4 282.58,14.37 282.72,14.51 v1(282.72,15.02) ; v1(284.78,22.13) 284.38,22.54 v2(283.7,22.54) 282.95,22.54 282.42,22.01 QZ7.5
  IN4 w0.102: v1(282.72,15.02) 283.61,15.91 283.61,20.67 284.78,21.84 v1(284.78,22.13)
MASK_SATA_LED#: length 83
  TOP w0.102: v1(236.59,65.82) 236.59,66.33 237.24,66.98 UE1.B9 ; QZ3.5 v1(281.26,17.56) ; v2(237.8,55.56) 237.82,55.58 v1(239.02,55.58)
  IN2 w0.102: v1(236.59,65.82) 236.59,65.62 236.82,65.38 237.45,65.38 237.72,65.11 237.72,63.32 238.06,62.98 238.06,62 238.56,61.5 238.56,59.48 237.98,58.9 237.98,56.62 v1(239.02,55.58)
  IN4 w0.102: v1(281.26,17.56) 280.52,18.31 280.52,19.48 277.98,22.02 277.98,23.45 276.08,25.35 276.08,38.15 272.76,41.47 270.48,41.47 266.8,45.16 263.95,45.16 263.27,45.84 262.3,45.84 261.09,47.05 259.31,47.05 258.22,48.13 257.26,48.13 253.83,51.56 253.05,51.56 251.43,53.18 241.83,53.18 239.43,55.58 v1(239.02,55.58)
MCARD_PCIE#_SATA: length 13.1
  TOP w0.102: T131.1 v1(242.37,69.32) ; UE2.B8 250.4,67.54 250.77,67.17 251.22,67.17 251.37,67.32 251.37,68.17 v1(251.01,68.53)
  IN1 w0.102: v1(242.37,69.32) 246.42,69.32 246.48,69.26 247.76,69.26 247.9,69.4 248.9,69.4 249.27,69.03 250.82,69.03 251.01,68.84 v1(251.01,68.53)
ME_FWP: length 119.2
  TOP w0.102: v1(172.39,64.36) 165.8,64.36 RC223.1
  IN2 w0.102: v1(203.49,83.3) 203.92,83.73 203.92,88.03 196.79,95.16 194.3,95.16 192.55,96.9 192.55,109.19 191.62,110.13 191.62,115.87 192.92,117.18 192.92,119.19 192.11,120 188.6,120 v1(187.76,120.84) ; v1(185.99,75.93) 185.99,76.25 185.65,76.59 185.18,76.59 185,76.41 185,75.8 185.89,74.91 185.89,72.97 185.72,72.8 185.72,71.66 185.29,71.23 185.29,66.09 184.4,65.2 184.4,64.07 183.44,63.1 173.64,63.1 v1(172.39,64.36)
  BOTTOM w0.102: SW1.3 186.3,123.78 186.18,123.67 RC221.1 187.27,120.35 v1(187.76,120.84) ; v1(185.99,75.93) 186.88,76.82 191.53,76.82 191.73,76.62 194.96,76.62 195.23,76.88 196.81,76.88 197.2,77.28 200.43,77.28 202.54,79.38 202.54,80.51 203,80.97 203,82.8 v1(203.49,83.3)
ME_FWP_EC: length 129.7
  TOP w0.102: v1(236.83,60.8) 236.92,60.89 UE1.A64 ; v1(180.74,117.85) 180.21,117.85 v2(179.79,117.43)
  IN3 w0.102: v1(238.24,72.35) 238.06,72.17 230.13,72.17 229.32,72.97 228.25,72.97 226.32,71.04 223.62,71.04 222.9,71.76 222.9,72.92 222.3,73.52 219.62,73.52 218.19,74.94 209.45,74.94 209.32,75.07 205.89,75.07 205.19,75.76 201.72,75.76 200.55,76.93 200.55,80.92 199.25,82.22 199.25,86.08 199.55,86.38 199.55,88.53 200.64,89.62 200.64,91.42 198.14,93.93 198.14,96.03 196.96,97.21 196.96,99.59 195.54,101.02 195.54,109.51 192.87,112.18 192.87,116.29 192.34,116.82 181.3,116.82 180.74,117.38 v1(180.74,117.85)
  BOTTOM w0.102: v1(236.83,60.8) 236.83,62.48 237.73,63.38 237.73,71.84 v1(238.24,72.35) ; v1(180.74,117.85) 180.74,118.6 181.59,119.44 RC221.2 188.36,119.44 189.09,120.16 189.09,121.26 188.71,121.65 188.71,123.43 190.3,125.02 SW1.1
ME_RESET#: length 4.1
  BOTTOM w0.102: v2(179.74,114.13) 178.97,114.91 RC227.1 177.8,114.03 RC225.2 177.8,113.61 177.9,113.51 UC12.2
ME_SUS_PWR_ACK: length 104.2
  TOP w0.102: v1(247.65,66.79) 248.15,67.29 UE2.A8 ; v1(189.79,80.43) 190.01,80.2 RC74.2
  IN1 w0.076: 178.5,81.75 178.05,82.2
  IN1 w0.102: 178.05,82.2 v1(178.05,82.41) ; v1(246.82,72.41) 245.97,72.41 244.16,70.6 241.71,70.6 240.66,71.65 237.51,71.65 236.89,72.27 229.89,72.27 229.32,72.85 226.5,72.85 225.47,73.87 214.3,73.87 214.17,74 209.26,74 207.27,72.01 204.1,72.01 198.18,77.93 198.18,78.67 197.13,79.72 197.13,80.9 196.67,81.36 196.38,81.36 195.98,81.76 191.65,81.76 190.32,80.43 v1(189.79,80.43) 187.37,80.43 185.14,78.19 182.08,78.19 178.52,81.75 178.5,81.75
  IN2 w0.102: v1(246.82,72.41) 247.53,72.41 247.98,71.97 247.98,70.7 247.52,70.24 247.2,70.24 246.99,70.02 246.99,67.45 v1(247.65,66.79)
  IN4 w0.076: 173.98,83.8 173.68,83.8 172.79,82.91 171.09,82.91 170.4,83.6 169.78,83.6 169.67,83.71 169.67,84.73 169.4,85.01 168.69,85.01 168.53,84.85 167.54,84.85 v1(167.31,84.62)
  IN4 w0.102: v1(178.05,82.41) 178.05,83.02 177.26,83.8 173.98,83.8
  BOTTOM w0.076: v1(167.31,84.62) 166.93,85 UC1.AR13
MEC_XTAL1: length 9
  TOP w0.102: 251.48,74.32 250.34,75.46 249.22,75.46 248.43,76.25 CE28.1 248.43,78.42 248.54,78.52 YE1.1 ; 251.48,74.32 251.81,73.99 251.81,73.47 252.12,73.15 UE2.A61 ; 251.48,74.32 v2(251.48,74.33)
MEC_XTAL2: length 3.7
  TOP w0.102: YE1.2 247.36,78.52 247.44,78.43 CE29.1 246.53,75.95 RE290.2
MEC_XTAL2_R: length 6.3
  TOP w0.102: UE2.A62 251.62,72.83 251.2,73.25 251.2,73.73 250.14,74.8 250.1,74.8 250.09,74.81 v2(248.89,74.81) 248.68,75.03 247.9,75.03 247.44,75.48 RE290.1
MEDIACARD_IRQ#: length 132.2
  TOP w0.102: v1(266.65,84.7) 266.82,84.53 RR19.2 266.92,83.82 UR2.32 ; v1(199.79,98.04) 199.81,98.05 199.96,98.05 v2(200.28,98.37)
  IN2 w0.102: v1(199.79,98.04) 198.94,97.19 v1(194.08,97.19)
  IN3 w0.102: v1(175.87,97) 177.16,97 177.83,96.32 179.31,96.32 180.33,97.34 181.33,97.34 182.17,96.5 183.88,96.5 184.29,96.1 190.51,96.1 192.3,94.31 193.62,94.31 194.08,94.76 v1(194.08,97.19) ; v1(199.79,98.04) 199.91,98.15 199.91,104.21 200.82,105.13 208.59,105.13 210.77,102.95 225.13,102.95 225.57,102.51 225.57,101.34 225.84,101.08 236,101.08 237.82,99.26 237.82,96.78 235.32,94.28 235.32,85.85 237.6,83.56 239.32,83.56 240.92,85.16 244.15,85.16 244.83,84.49 245.43,84.49 246.18,85.24 246.83,85.24 247.94,86.34 251.94,86.34 253.93,88.34 255.1,88.34 255.32,88.12 261.29,88.12 264.7,84.7 v1(266.65,84.7)
  BOTTOM w0.076: UC1.M1 174.32,97.05 174.65,97.38 175.49,97.38 v1(175.87,97)
MEM_SMBCLK: length 12.3
  TOP w0.102: RC12.1 177.21,98.4 v1(177.21,97.53) 177.3,97.44 177.3,96.55 177.01,96.27 QC2.6
  IN1 w0.076: v1(177.21,97.53) 177.4,97.73 177.4,97.89 177.3,97.99 175.62,97.99 172.87,95.23 170.86,95.23 170.76,95.14 170.76,95.04 v1(170.98,94.82)
  BOTTOM w0.076: UC1.R7 170.69,95.11 v1(170.98,94.82)
MEM_SMBDATA: length 11.7
  TOP w0.102: QC2.3 177.83,97.57 v1(177.79,97.53) 177.79,98.49 RC14.1
  IN1 w0.076: v1(177.79,97.53) 177.61,97.72 177.61,97.97 177.39,98.19 175.54,98.19 172.78,95.44 170.77,95.44 170.56,95.22 170.56,95.03 170.35,94.82 v1(170.34,94.82)
  BOTTOM w0.076: UC1.R8 170.04,95.12 v1(170.34,94.82)
MIC1_L: length 2.9
  TOP w0.203: UA1.19 289.26,65.62 290.01,64.88 CA43.1
MIC1_R: length 3.3
  TOP w0.203: UA1.20 289.66,65.82 v2(289.92,65.56) 291.07,64.41 CA44.1
MPHYP_PWR_EN: length 162.2
  TOP w0.254: PR301.2 232.26,89.06 233.02,88.3 v2(233.02,86.37) 233.02,83.52 232.52,83.03 v1(231.01,83.03)
  IN1 w0.076: v1(168.21,86.54) 167.79,86.12 167.79,83.76 167.84,83.7 167.84,83.07 168.17,82.75 168.67,82.75 169,82.42 169.41,82.42 170.95,80.88 171.57,80.88 175.47,76.97 176.72,76.97 176.75,76.94
  IN1 w0.102: v1(194.31,72.18) 193.87,72.61 193.42,72.61 191.95,71.14 184.18,71.14 183.91,71.42 183.91,71.99 182.22,73.67 180.02,73.67 176.75,76.94
  IN2 w0.102: v1(194.31,72.18) 197.25,72.18 197.94,72.87 197.94,74.27 199.16,75.48 199.94,75.48 v1(202.06,77.6) 202.06,79.4 200.25,81.21 200.25,82.36 201.51,83.61 201.51,85.41 200.75,86.17 200.75,88.02 199.31,89.45 199.31,90.9 197.37,92.85 196.52,92.85 194.9,94.46 194.42,94.46 192.15,96.73 192.15,109.03 191.21,109.97 191.21,116.04 192.52,117.35 192.52,119.02 191.94,119.59 178.5,119.59 175.87,116.96 174.57,116.96 v1(173.84,117.7)
  IN3 w0.102: v1(202.06,77.6) 202.12,77.54 209.44,77.54 210.62,76.36 225.81,76.36 226.8,77.35 229.65,77.35 231.57,79.27 231.57,82.47 v1(231.01,83.03)
  BOTTOM w0.076: UC1.AM10 168.62,86.95 v1(168.21,86.54)
  BOTTOM w0.102: v1(173.84,117.7) 173.39,117.26 173.01,117.26 172.69,117.57 RZ83.2
MSCLK: length 78.2
  TOP w0.102: UE2.B43 258.25,67.04 257.72,66.51 v1(257.72,66.39) ; JDEG1.6 278.92,9.37 279.71,10.17 RE72.2 279.98,10.54 279.98,13.59 277.87,15.69 277.87,16.52 278.22,16.86 278.22,19.19 275.74,21.66 275.74,39.38 273.63,41.49 v2(273.63,43.63) 273.63,43.85 273.96,44.18 v1(274.44,44.18)
  IN1 w0.084: v1(257.72,66.39) 258.14,66.81 260.51,66.81 261.12,66.2 265.85,66.2 v1(266.52,66.87)
  IN2 w0.122: v1(266.1,55.53) 266.35,55.79 266.35,58.41 266.8,58.86 266.8,59.53 266.33,60.01 266.33,66.68 v1(266.52,66.87)
  BOTTOM w0.102: v1(274.44,44.18) 273.94,44.69 273.94,46.61 270.94,49.6 270.36,49.6 268.57,51.39 268.57,53.08 266.11,55.53 v1(266.1,55.53)
MSDATA: length 75.3
  TOP w0.102: v1(266.9,57.71) 266.56,57.37 266.56,55.58 266.88,55.27 RE86.2 v1(266.88,54.14) ; v1(266.55,67.47) 266.14,67.07 261.25,67.07 v2(261.13,66.95) 260.71,66.95 260.55,66.79 UE2.A40 ; RE75.2 279.19,8.87 JDEG1.7 274.69,8.87 v1(274.18,9.38)
  IN2 w0.102: v1(266.9,57.71) 266.9,58.27 267.29,58.65 267.29,60 266.83,60.47 266.83,66.46 266.99,66.62 266.99,67.17 266.69,67.47 v1(266.55,67.47) ; v1(266.88,54.14) 266.88,46.76 266.58,46.47 266.58,44.62 273.34,37.86 273.34,18.42 273.81,17.95 273.81,9.74 v1(274.18,9.38)
NB_PSID: length 12.4
  TOP w0.254: v1(78.28,103.97) v2(75.49,106.76) 74.11,108.14 PD6.3 PD6.2 74.11,112.89 PL4.2
NB_PSID_TS5A63157: length 6.9
  TOP w0.254: PU1.3 76.19,115.87 77.23,116.91 v2(77.23,117.5) 77.23,120.7 PR6.1 PR7.2
NRB_BIT: length 21.4
  TOP w0.102: RC186.2 v2(183.26,74.37) 183.26,75.43 182.29,76.4 v1(182.06,76.4)
  IN1 w0.076: v1(170.04,84.56) 170.12,84.56 170.43,84.26 171.85,84.26 172.25,84.65 173,84.65 173.72,83.93 173.72,82.87 174.12,82.47 174.12,81.33 174.86,80.59 177.11,80.59 179.01,78.69
  IN1 w0.102: v1(182.06,76.4) 181.65,76.81 180.89,76.81 179.01,78.69
  BOTTOM w0.076: v1(170.04,84.56) 170.48,85 UC1.AR7
NTC_IA: length 3.7
  TOP w0.203: PU602.15 90.2,87.65 90.27,87.58 90.63,87.58 90.7,87.65 91.17,87.65 91.31,87.51 v2(91.31,86.83) 91.31,86.65 v1(91.6,86.36)
  BOTTOM w0.254: PR635.2 v1(91.6,86.36)
NVME_LED#: length 330
  TOP w0.102: v1(282.69,16.21) 283.68,16.21 RZ118.1 ; v1(140.33,40.24) 139.98,39.89 v2(139.08,39.89)
  IN1 w0.102: v1(140.33,40.24) 139.69,40.88 79.79,40.88 77.76,42.91 75.46,42.91 73.85,41.3 73.85,39.39 73.04,38.57 61.13,38.57 59.85,39.85 56.61,39.85 55.37,38.62 39.94,38.62 35.99,42.57 33.68,42.57 29.79,38.68 28.55,38.68 27.23,37.36 27.23,35.38 25.75,33.9 23.53,33.9 23.2,33.57 JNGFF3.10
  IN3 w0.102: v1(282.69,16.21) 282,15.53 282,10.35 280.65,9 280.65,2.87 279.88,2.09 275.44,2.09 274.98,2.55 274.98,7.95 273.72,9.2 273.72,17.9 273.25,18.37 273.25,37.4 271.85,38.79 270.3,38.79 266.82,42.27 263.62,42.27 259.93,38.58 239.71,38.58 237.78,40.51 235.27,40.51 234.07,39.32 223.31,39.32 222.58,38.58 166.99,38.58 165.71,39.86 161.44,39.86 158.54,42.76 155.45,42.76 153.27,40.59 140.68,40.59 v1(140.33,40.24)
ONE_DIMM#: length 5.7
  BOTTOM w0.076: UC1.M2 173.69,96.78 174.33,96.78 174.72,97.18 175.09,97.18 175.78,96.49 v2(176.39,96.49) 176.87,96.49 RC267.2 RC268.1
P33ALW: length 4.7
  TOP w0.102: PR931.1 93.91,73.35 95.02,73.35 v2(95.16,73.49)
  TOP w0.254: PR931.1 92.3,71.74 92.3,71.41 92.03,71.14 PU901.18
P33ALW2: length 4.3
  TOP w0.102: v2(93.29,63.99) PR932.2
  TOP w0.254: PR932.2 92.3,64.88 91.75,65.43 91.04,65.43 90.69,65.78 PU901.9
PANEL_BKEN_EC: length 246.3
  TOP w0.102: v1(229.24,69.4) 229.17,69.48 UE1.B38 ; DV2.2 94.76,102.73 90.59,98.56 85.07,98.56 81.55,95.04 78.49,95.04 v1(77.95,94.5)
  IN1 w0.102: v1(67.17,59.24) 67.17,59.03 72.12,54.07 76.21,54.07 77.19,53.1 v1(77.19,51.88)
  IN2 w0.102: v1(77.19,51.88) 77.98,51.88 78.97,52.87 81.9,52.87 84.84,55.81 87.42,55.81 88.03,55.2 215,55.2 221.71,61.91 221.71,63.11 222.3,63.69 222.3,68.04 223.66,69.4 v1(229.24,69.4)
  BOTTOM w0.102: v1(77.95,94.5) 77.22,94.5 74.29,91.57 74.29,82.57 63.27,71.55 63.27,62.2 64.35,61.12 65.02,61.12 65.92,60.22 65.92,59.75 66.58,59.09 67.02,59.09 v1(67.17,59.24)
PANEL_BKLEN: length 101.9
  TOP w0.102: v1(167.15,94.77) v2(167.15,94.26) ; DV2.3 95.5,107.82 93.37,107.82 92.94,108.25 92.94,108.94 v1(93.13,109.13)
  IN1 w0.076: 150.03,102.37 150.03,100.48 150.46,100.06 150.46,99.19 151.06,98.59 156.58,98.59 156.87,98.3 156.87,97.76 157.26,97.37 157.26,97.07 157.48,96.86 158.13,96.86 159.45,95.54 159.45,94.54 159.89,94.1 160.74,94.1 161.11,94.47 163.2,94.47 163.39,94.28 164.74,94.28 165.12,94.66 167.04,94.66 v1(167.15,94.77)
  IN1 w0.102: v1(93.13,109.13) 93.13,109.64 94.51,111.02 96.12,111.02 99.67,114.58 100.23,114.58 100.48,114.32 104.61,114.32 105.06,114.77 108.76,114.77 109.57,113.95 119.31,113.95 122.35,116.99 123.08,116.99 123.86,117.77 127.8,117.77 127.97,117.6 133.36,117.6 133.66,117.9 137.97,117.9 138.52,117.34 139.94,117.34 140.67,118.07 142.11,118.07 143.91,116.27 143.91,115.68 145.12,114.47 145.12,113.86 146.83,112.15 146.83,111.1 150.03,107.9 150.03,102.37
  BOTTOM w0.076: v1(167.15,94.77) 167.44,95.06 UC1.R12
PANEL_ID: length 11.7
  TOP w0.102: UE2.A10 248.31,66.29 v1(248.23,66.21) ; CE47.1 243.25,61.24 v2(243.09,61.39) 242.75,61.74 RE300.2 242.17,62.1 v1(242.75,62.67)
  IN4 w0.102: v1(248.23,66.21) 248.18,66.26 246.75,66.26 245.82,65.34 244.52,65.34 242.75,63.56 v1(242.75,62.67)
PBAT_PRES#: length 283.5
  TOP w0.102: v1(257.62,73.78) 258.12,73.28 UE2.A49
  TOP w0.254: v1(63.99,65.45) 63.89,65.35 55.61,65.35 49.36,59.11 PR828.1 ; PRP1.1 66.02,43.34 PD3.2 65.62,41.88 v1(65.83,41.66) 65.97,41.66 v2(67.22,40.42) PD4.1 69.39,39.17 PR3.2 ; PU902.1 66.03,74.34 66.39,74.71 67.66,74.71 69.82,72.55 69.82,70.4 68.51,69.08 68.51,68.76 67.66,67.92 67.66,66.25 66.9,65.49 65.93,65.49 65.48,65.04 v1(65.48,64.87)
  IN1 w0.254: v1(65.48,64.87) 64.84,64.87 64.26,65.45 v1(63.99,65.45) 63.12,65.45 62.2,64.54 62.2,57.39 63.04,56.55 64.55,56.55 66.01,55.09 66.01,53.26 68.19,51.09 69.06,51.09 v1(69.12,51.02)
  IN2 w0.102: v1(69.12,51.02) 70.88,52.78 75.8,52.78 76.08,53.06 78.23,53.06 78.68,53.5 81.65,53.5 85.46,57.31 88.94,57.31 89.82,56.43 210.44,56.43 220.62,66.61 220.62,69.26 222.88,71.51 225.84,71.51 226.35,72.02 226.35,74.54 226.97,75.17 231.63,75.17 v1(232.43,74.37)
  IN3 w0.254: v1(65.83,41.66) 65.83,45.27 67.13,46.57 69.02,46.57 69.64,47.19 69.64,50.1 69.12,50.62 v1(69.12,51.02)
  IN4 w0.102: v1(232.43,74.37) 232.43,74.24 232.92,73.76 233.51,73.76 233.73,73.54 234.08,73.54 235.45,72.17 237.3,72.17 237.6,71.87 238.66,71.87 238.96,72.17 242.15,72.17 243.3,71.02 244.19,71.02 245.34,72.17 246.02,72.17 246.64,72.79 247.06,72.79 247.6,72.25 248.68,72.25 248.84,72.42 256.87,72.42 257.21,72.75 257.21,73.36 v1(257.62,73.78)
PBAT_PRES#_C: length 6.1
  TOP w0.102: v2(65.03,47.35) 65.16,47.23 v1(66.02,47.23)
  TOP w0.254: PRP1.8 v1(66.02,47.23)
  BOTTOM w0.254: v1(66.02,47.23) 64.64,48.61 64.64,48.99 PBATT1.6
PBAT_SMBCLK: length 247.5
  TOP w0.102: PRP1.3 67.02,44.37 66.9,44.24 66.9,44.05 67.32,43.63 67.32,43.32 PD2.2 67.7,42.54 v1(67.47,42.31) ; UE2.A56 254.62,72.98 v1(254.8,73.16) ; v1(262.27,70.95) 262.35,71.04 RPE6.4
  IN2 w0.122: v1(254.8,73.16) 254.71,73.07 254.71,70.45 255.02,70.14 255.02,64.5 254.78,64.25 254.78,61.9 254.84,61.84 254.84,59.94 256.63,58.15 256.63,56.73 257.41,55.95 257.41,54.43 257.57,54.27 257.57,52 257.26,51.7 257.26,49.83 258.16,48.94 258.16,43.99 256.01,41.85 256.01,40.16 254.68,38.83 239.82,38.83 237.88,40.78 235.1,40.78 234.06,39.73 191.95,39.73 191.23,39.01 167.14,39.01 166.02,40.13 161.66,40.13 158.73,43.05 155.41,43.05 153.19,40.83 141.48,40.83 140.49,39.84 139.82,39.84 138.8,38.83 82.26,38.83 77.9,43.19 73.2,43.19 71.64,41.63 67.52,41.63 67.34,41.81 67.34,42.18 v1(67.47,42.31)
  IN3 w0.122: v1(254.8,73.16) 255.46,72.5 257.75,72.5 258.28,73.03 259.11,73.03 259.82,72.32 261.46,72.32 261.83,71.95 262.49,71.95 262.71,71.74 262.71,71.2 262.46,70.95 v1(262.27,70.95)
PBAT_SMBCLK_C: length 7.9
  TOP w0.102: PRP1.6 67.02,46.4 66.89,46.54 66.89,47.19 v5(67.11,47.41) 67.36,47.66 67.36,48.62 v1(67.52,48.79)
  BOTTOM w0.102: v1(67.52,48.79) 67.33,48.98 67.33,49.33 66.31,50.35 66.31,50.68 66.1,50.89 66,50.96 65.97,51.11 66.22,51.46 66.2,51.6 65.21,52.29 PBATT1.4
PBAT_SMBDAT: length 245.7
  TOP w0.102: v1(255.37,70.4) 254.87,70.9 UE2.B59 ; RPE6.3 v1(262.25,71.54) ; PRP1.2 66.52,44.39 66.68,44.24 66.67,44.24 66.67,43.95 67.09,43.53 67.09,43.32 66.99,43.22 PD2.3 66.7,42.54 v1(66.9,42.34)
  IN2 w0.122: v1(66.9,42.34) 67.09,42.15 67.09,41.71 67.42,41.38 71.74,41.38 73.31,42.94 77.8,42.94 82.15,38.58 138.91,38.58 139.92,39.59 140.6,39.59 141.59,40.59 153.3,40.59 155.51,42.8 158.63,42.8 161.55,39.88 165.92,39.88 167.04,38.76 191.34,38.76 192.06,39.48 234.16,39.48 235.21,40.53 237.78,40.53 239.72,38.58 254.79,38.58 256.26,40.06 256.26,41.74 258.4,43.89 258.4,49.04 257.51,49.94 257.51,51.59 257.82,51.9 257.82,54.38 257.66,54.53 257.66,56.05 256.88,56.83 256.88,58.25 255.08,60.05 255.08,61.95 255.03,62.01 255.03,64.15 255.27,64.39 255.27,70.3 v1(255.37,70.4)
  IN3 w0.122: v1(255.37,70.4) 254.95,70.82 254.95,71.48 255.71,72.25 257.85,72.25 258.39,72.78 259.01,72.78 259.71,72.07 261.36,72.07 261.89,71.54 v1(262.25,71.54)
PBAT_SMBDAT_C: length 7.7
  TOP w0.102: PRP1.7 66.52,46.4 66.66,46.54 66.66,47.28 67.13,47.75 67.13,48.6 v1(66.94,48.79)
  BOTTOM w0.102: v1(66.94,48.79) 67.1,48.95 67.1,49.23 66.08,50.26 66.08,50.59 65.95,50.72 65.87,50.78 65.72,50.75 65.48,50.4 65.34,50.37 PBATT1.5
PBATT+_C:
  vias: v1(67.41,52.87) v1(67.79,53.37) v1(68.17,53.88) v1(68.17,52.87) v1(68.55,54.39) v1(68.55,53.37) v1(68.93,53.88) v1(68.93,52.87) v1(69.31,54.39) v1(69.31,53.37) v1(69.7,53.88) v1(70.01,54.39) v3(67.5,54.86) v3(68.06,51.65) v3(69.56,52.8)
PCH_ALW_ON: length 91.7
  TOP w0.102: UE2.A34 260.86,63.79 261.33,63.32 261.33,61.95 v1(261.55,61.72) 261.81,61.72 262.02,61.93 RPE10.4 ; v1(196.49,74.95) 195.98,74.95 194.43,76.5 RZ65.1 ; v1(207.73,71.03) v2(207.73,71.52)
  IN2 w0.102: v1(207.73,71.03) 207.3,71.46 193.63,71.46 193.27,71.83 193.27,72.3 193.54,72.57 194.11,72.57 v1(196.49,74.95)
  IN3 w0.102: v1(207.73,71.03) 208.11,70.65 208.46,70.65 211.69,67.41 214.04,67.41 215.67,65.77 217.4,65.77 218.08,65.08 222,65.08 223.72,63.37 228.14,63.37 229.13,62.39 231.57,62.39 232.66,61.3 232.98,61.3 233.25,61.03 233.25,60.54 233.65,60.13 236.51,60.13 236.75,60.37 238.15,60.37 240.79,57.73 242.44,57.73 242.73,57.44 245.42,57.44 245.83,57.84 248.49,57.84 249.78,56.55 251.18,56.55 251.72,57.1 255.6,57.1 257.34,58.84 259.81,58.84 261.55,60.57 v1(261.55,61.72)
PCH_BATLOW#: length 22.3
  TOP w0.102: RC72.1 180.63,71.4 180.63,73.9 178.98,75.54 v2(178.46,75.54) 178.15,75.54 176.71,76.98 175.92,76.98 173.39,79.51 172.01,79.51 v1(171.78,79.28)
  IN4 w0.076: v1(171.78,79.28) 171.63,79.14 170.2,79.14 166.38,82.95 v1(166.38,83.37)
  BOTTOM w0.076: UC1.AU13 166.71,83.7 v1(166.38,83.37)
PCH_CL_CLK1: length 145
  IN2 w0.122: v1(241.44,60.82) 240.62,61.63 240.62,64.02 240.42,64.22 240.42,65.24 240.91,65.73 240.91,67.88 240.26,68.54 240.26,72.42 239.78,72.89 239.78,84.39 239.13,85.05 236.71,85.05 235.12,86.64 235.12,93.36 238.07,96.32 238.07,99.28 234.19,103.16 230.34,103.16 229.96,102.77 216.28,102.77 215.42,103.63 199.72,103.63 198,101.91 198,101.23 198.24,100.99 v1(198.4,100.99)
  BOTTOM w0.076: 176.98,103.86 176.38,103.25 176.38,103.01 174.63,101.26 173.93,101.26 173.78,101.11 173.78,100.86 173.42,100.5 173.42,100.14 172.98,99.7 UC1.G3
  BOTTOM w0.102: v2(177.82,104.69) 177.82,104.7 ; 177.82,104.7 176.98,103.86 ; 177.82,104.7 181.22,108.1 185.13,108.1 190.03,103.2 194.79,103.2 196.04,101.95 197.81,101.95 198,101.75 198,101.39 v1(198.4,100.99) ; v1(241.44,60.82) 242.28,59.98 244.09,59.98 245.32,58.74 245.32,57.79 246.04,57.07 246.66,57.07 246.87,56.86 246.87,54.22 246.32,53.66 246.32,50.52 247.32,49.51 251.99,49.51 253.85,51.37 JNGFF1.34
PCH_CL_DATA1: length 147.5
  IN2 w0.122: v1(242,60.82) 241.02,61.79 241.02,63.87 241.29,64.14 241.29,68.04 240.63,68.69 240.63,72.64 240.16,73.12 240.16,84.55 239.29,85.42 236.87,85.42 235.49,86.79 235.49,93.21 239.5,97.21 239.5,99.8 238.86,100.44 237.44,100.44 234.35,103.53 230.19,103.53 229.81,103.15 216.62,103.15 214.84,104.94 211.38,104.94 211.26,104.81 211.26,104.13 211.13,104.01 210.89,104.01 210.77,104.13 210.77,104.81 210.65,104.94 210.4,104.94 210.28,104.81 210.28,104.13 210.16,104.01 209.88,104.01 209.75,104.14 209.75,104.54 209.62,104.67 209.31,104.67 209.18,104.54 209.18,104.14 209.05,104.01 199.57,104.01 197.6,102.05 v1(197.6,101.56)
  BOTTOM w0.076: UC1.G2 173.82,100.1 175.05,100.1 175.33,100.38 175.33,101.73 176.57,102.97 176.62,102.97 177.12,103.46
  BOTTOM w0.102: 177.12,103.46 v2(180.3,106.64) 181.4,107.74 184.98,107.74 189.88,102.84 194.64,102.84 195.91,101.56 v1(197.6,101.56) ; JNGFF1.32 253.35,51.37 251.84,49.87 247.47,49.87 246.67,50.66 246.67,53.52 247.23,54.07 247.23,57.01 246.81,57.43 246.19,57.43 245.68,57.93 245.68,58.89 244.19,60.38 242.43,60.38 v1(242,60.82)
PCH_CL_RST1#: length 147.2
  IN2 w0.122: v1(242.55,60.83) 241.43,61.95 241.43,63.75 241.67,63.98 241.67,68.19 241.07,68.79 241.07,75.4 240.54,75.94 240.54,84.7 239.44,85.8 237.02,85.8 235.87,86.95 235.87,93.05 239.88,97.06 239.88,99.96 239.02,100.82 237.6,100.82 234.51,103.91 230.03,103.91 229.65,103.53 216.84,103.53 214.86,105.51 214.65,105.51 214.53,105.63 214.53,105.93 214.4,106.05 214.07,106.05 213.94,105.93 213.94,105.63 213.82,105.51 213.58,105.51 213.46,105.63 213.46,105.94 213.33,106.07 213.08,106.07 212.95,105.94 212.95,105.63 212.82,105.51 212.52,105.51 212.39,105.63 212.39,106.02 212.27,106.14 211.94,106.14 211.81,106.02 211.81,105.63 211.68,105.51 209.49,105.51 208.37,104.38 199.41,104.38 197.19,102.17 197.19,101.39 v1(197.6,100.99)
  BOTTOM w0.076: UC1.G1 174.3,99.93 175.12,99.93 175.5,100.31 175.5,101.58 176.59,102.68
  BOTTOM w0.102: 176.59,102.68 176.87,102.68 181.58,107.39 184.83,107.39 189.74,102.48 194.49,102.48 195.99,100.99 v1(197.6,100.99) ; v1(242.55,60.83) 244.24,60.83 246.03,59.04 246.03,58.08 246.33,57.78 246.96,57.78 247.58,57.16 247.58,53.93 247.03,53.37 247.03,50.81 247.61,50.22 251.7,50.22 252.85,51.38 JNGFF1.30
PCH_DPWROK: length 129.7
  TOP w0.102: v1(261.16,65.01) 260.94,64.79 UE2.A36 ; CC266.1 RC220.1 RC215.1 175.1,67.2 169.43,67.2 v2(167.58,69.05) 167.08,69.55 v1(167.08,71.81)
  IN4 w0.084: v1(261.16,65.01) 261.16,65.52 260.72,65.96 256.66,65.96 254.68,67.94 249.87,67.94 249.58,68.23 239.02,68.23 237.72,66.92 236.46,66.92 235.13,68.26 221.79,68.26 220.86,69.19 220.75,69.19 v1(219.19,70.74)
  BOTTOM w0.076: v1(167.08,71.81) 167.1,71.78 167.1,71.32 ; 164.94,76.86 164.75,77.05 164.75,77.75 163.73,78.78 163.73,79.17 163.33,79.56 163.33,80.36 UC1.BB20
  BOTTOM w0.102: 167.1,71.32 167.1,69.87 169.03,67.95 175.68,67.95 177.05,66.58 208.18,66.58 210.7,69.11 211.93,69.11 213.01,70.19 213.01,70.87 214.18,72.04 217.89,72.04 v1(219.19,70.74) ; v1(167.08,71.81) 164.94,73.95 164.94,76.86
PCH_JTAG_TCK: length 39.3
  TOP w0.102: v1(133.56,119.03) 133.89,119.03 v3(134.11,119.25)
  IN4 w0.076: v1(141.04,106.63) 140.66,107.01 140.66,107.62 142.16,109.11 142.16,110.57 143.43,111.84 143.43,112.62 143.39,112.66 143.39,113.08
  IN4 w0.084: 143.39,113.08 143.39,113.43 144.22,114.26 144.22,116.46 142.84,117.84 142.02,117.84 141.42,117.25 139.19,117.25 138.94,117 134.65,117 133.91,117.74 133.91,118.09 133.56,118.44 v1(133.56,119.03)
  BOTTOM w0.076: RC86.2 140.66,107.7 140.66,107.01 v1(141.04,106.63) 141.23,106.63 141.41,106.45 141.41,106.16 141.65,105.91 141.65,105.11 142.08,104.68 142.08,103.55 141.9,103.37 141.9,103.1 141.95,102.99 141.95,102.77 UC1.B56
  BOTTOM w0.102: JXDP1.55 131.89,124.86 133.56,123.19 v1(133.56,119.03)
PCH_JTAG_TDI: length 37.2
  IN4 w0.076: 144.85,112.45 144.84,112.44 144.47,112.44 144.23,112.2 144.23,111.68 142.82,110.26 142.82,108.72 142.02,107.92 142.02,107.62 142.78,106.85 142.78,105.46 142.54,105.22 142.19,105.22 141.48,105.93 v1(141.01,105.93)
  IN4 w0.102: v1(139.41,119.5) 139.88,119.97 140.38,119.97 140.76,120.35 145.11,120.35 146.82,118.64 146.82,114.94 145.88,113.99 145.88,113.48 144.85,112.45
  BOTTOM w0.076: 139.7,109.14 139.47,108.91 139.47,108.13 CC304.1 140.47,107.14 140.47,106.54 141.01,105.99 v1(141.01,105.93) 141.09,105.86 141.09,103.59 141.24,103.44 141.24,103.07 141.21,102.98 141.21,102.79 141.24,102.69 141.24,102.45 141.23,102.4 141.18,102.25 141.1,101.97 141.1,101.85 141.03,101.59 UC1.D59
  BOTTOM w0.102: RC81.2 139.7,109.14 ; v1(139.41,119.5) 138.35,119.5 RC229.2
PCH_JTAG_TDO: length 27.4
  TOP w0.102: v2(141.45,108.23) 141.04,107.82 v1(141.04,107.2)
  IN4 w0.076: v1(141.04,107.2) 141.04,107.76 142.32,109.04 142.32,110.5 143.6,111.77 143.6,112.61 143.88,112.89 143.88,113.08
  IN4 w0.102: 143.88,113.08 143.88,113.23 144.69,114.05 144.69,114.51 145.12,114.94 145.12,117.27 144.07,118.32 141.82,118.32 141.22,117.72 139.32,117.72 v1(138.9,118.14)
  BOTTOM w0.076: UC1.A56 142.26,103.31 142.26,104.73 141.81,105.18 141.81,105.98 141.57,106.22 141.57,106.63 141.04,107.16 v1(141.04,107.2) 141.72,107.88 CC303.1 142.24,108.4 RC82.2
  BOTTOM w0.102: RC230.2 138.49,117.74 v1(138.9,118.14)
PCH_JTAG_TMS: length 24.1
  IN4 w0.076: v1(141.78,110.19) 141.78,108.97 140.42,107.61 v1(140.42,106.01)
  BOTTOM w0.076: v1(140.42,106.01) 140.42,105.8 140.91,105.31 140.91,103.54 141.08,103.37 141.08,103.1 141.02,102.99 141.02,102.84 141.08,102.65 141.08,102.47 140.99,102.22 UC1.C59
  BOTTOM w0.102: RC130.2 RC228.2 146.81,120.81 147.08,120.54 147.08,117.36 145.73,116.01 145.23,116.01 142.05,112.83 142.05,110.98 141.78,110.71 v1(141.78,110.19)
PCH_PCIE_WAKE#: length 147.3
  TOP w0.102: v1(258.31,68.74) 258.61,68.74 258.81,68.54 UE2.B46 ; RC67.2 176.92,67.8 v1(177.04,67.92) ; RE274.2 267.82,57.14 v1(267.67,57.28)
  IN1 w0.084: v1(267.67,57.28) 267.67,57.73 267.31,58.09 266.57,58.09 266.44,57.96 266.44,56.5 265.23,55.29 261.69,55.29 261.49,55.09 260.09,55.09 259.71,55.47 258.93,55.47 258.37,56.04 258.03,56.04 257.79,55.8 255.77,55.8 255.15,55.18 253.94,55.18 252.94,56.17 247.62,56.17 247.52,56.07 245.39,56.07 244.62,56.83 243.42,56.83 242.83,56.24 241.72,56.24 240.76,57.2 238.17,57.2 237.65,56.68 188.76,56.68 187.88,57.56 186.5,57.56 181.33,62.72 181.33,66.19 180,67.52 177.43,67.52 v1(177.04,67.92) 176.92,68.03 173.84,68.03 171.91,69.96 171.42,69.96 169.87,71.51 169.87,74.52 169.4,75 169.29,75 v1(169.2,75.08) ; v1(269.34,64.16) 269.34,65.04 267.98,66.41 267.98,68.08 267.34,68.72 265.34,68.72 264.94,68.32 263.78,68.32 262.78,69.33 258.89,69.33 v1(258.31,68.74)
  IN4 w0.084: v1(267.67,57.28) 267.67,57.81 269.08,59.22 269.08,63.48 269.34,63.74 v1(269.34,64.16)
  BOTTOM w0.076: UC1.BB15 165.44,80.5 165.44,79.3 166.24,78.51 166.24,77.96 166.56,77.64 166.75,77.64 168.84,75.55 168.84,75.45 v1(169.2,75.08)
PCH_PLTRST#: length 30.6
  IN2 w0.122: v1(186.61,87.83) 185.99,87.21 182.29,87.21 179.98,84.9 178.19,84.9 177.53,85.56 172.64,85.56 171.24,86.96 169.67,86.96 169.15,86.43 v1(169.15,85.97)
  BOTTOM w0.102: UC7.1 190.65,88.74 190.8,88.59 190.8,88.09 ; 190.8,88.09 UC7.2 186.87,88.09 v1(186.61,87.83) ; 190.8,88.09 190.99,88.09 RC62.2 RC60.2 RC244.2 RC64.2 RC61.2
  BOTTOM w0.254: UC1.AN10 v1(169.15,85.97)
PCH_PLTRST#_AND: length 494.6
  TOP w0.102: v1(197.55,73.17) 197.55,70.39 v2(196.63,69.48) 193.89,69.48 191.51,67.1 v1(191.51,64.06) ; v1(265.48,82.19) 265.72,81.95 UR2.1
  IN1 w0.084: v1(188.54,86) 190.8,86 191.09,85.71 193.8,85.71 194.62,86.53 196.19,86.53 197.36,85.36 197.36,84.96 198.26,84.06 198.26,81.93 200.04,80.16 200.04,79.49 201.32,78.22 201.32,77.11 202.61,75.81 203.33,75.81 205.13,74.02 207.68,74.02 v1(208.02,73.68) 208.25,73.68 208.97,74.4 214.33,74.4 214.46,74.27 225.63,74.27 226.18,73.72 229.01,73.72 230.06,72.67 236.77,72.67 237.59,71.84 241.03,71.84 241.88,71 243.85,71 245.68,72.83 246.95,72.83 247.84,71.94 249.3,71.94 249.6,72.24 250.8,72.24 251.13,71.92 258.26,71.92 258.5,71.68 259.22,71.68 259.46,71.92 260.64,71.92 260.8,71.75 261.68,71.75 262.02,72.08 263.96,72.08 v1(264.75,71.29)
  IN2 w0.102: JNGFF3.50 13.2,33.56
  IN2 w0.122: v1(295.4,12.33) 294.4,11.33 294.4,7.8 291.3,4.69 280.17,4.69 279.85,5.01 278.61,5.01 275.96,7.67 274.66,7.67 273.6,8.73 273.6,17.86 273.12,18.33 273.12,37.49 265.41,45.2 265.41,48.45 264.98,48.88 264.98,49.91 265.41,50.34 v1(265.41,50.93) 265.45,50.97 265.45,54.47 265.68,54.7 265.68,55.83 265.81,55.95 265.81,60.57 265.45,60.93 265.45,61.68 264.86,62.28 264.86,63.48 265.17,63.79 265.17,66.67 265.55,67.05 265.55,70.6 264.86,71.29 v1(264.75,71.29) ; v1(191.51,64.06) 191.51,60.19 189.88,58.56 85.24,58.56 81.21,54.53 78.24,54.53 77.8,54.08 73.83,54.08 73.64,54.27 70.82,54.27 70.1,54.99 65.95,54.99 64.03,56.9 62.81,56.9 62.08,57.63 60.62,57.63 60.18,57.2 51.23,57.2 50.65,56.61 50.65,55.85 49.77,54.97 43.1,54.97 42.22,55.85 39.34,55.85 38.78,55.28 22.83,55.28 22.45,55.66 8.35,55.66 6.49,53.79 6.49,49.56 5.98,49.06 5.98,45.32 6.94,44.36 9.59,44.36 13.99,39.95 13.99,36.79 13.2,35.99 13.2,33.56
  IN4 w0.084: v1(256.8,50.1) 259.12,50.1 260.77,51.75 264.59,51.75 v1(265.41,50.93)
  BOTTOM w0.102: v1(188.54,86) 189.08,86 189.3,86.22 RC325.2 187.21,86.45 187.03,86.64 RC65.1 187.26,87.44 UC7.4 ; v1(264.75,71.29) 264.75,72.17 265.1,72.51 265.1,73.74 264.68,74.16 264.68,81.48 265.39,82.19 v1(265.48,82.19) 265.48,84.45 263.52,86.41 263.52,90.07 264.34,90.89 266.1,90.89 269.38,94.17 269.38,100.11 270.12,100.85 JNGFF2.42 ; JNGFF1.58 259.85,51.12 258.82,50.1 v1(256.8,50.1) 256.35,50.55 JNGFF1.44 ; v1(197.55,73.17) 197.55,72.8 198.02,72.34 206.17,72.34 207.52,73.68 v1(208.02,73.68) ; v1(295.4,12.33) CZ68.1 294.75,11.63 RZ114.1
PCH_PLTRST#_EC: length 149.1
  TOP w0.102: v1(256.4,63.08) 256.37,63.05 UE2.B30
  IN1 w0.084: v1(238.47,77.15) 238.26,77.15 237.77,76.65 213.93,76.65 213.44,77.14 206.13,77.14 202.68,80.59 202.68,83.4 200.57,85.5 200.57,87.33 199.11,88.79 197.73,88.79 197.32,89.21 193.55,89.21 v1(193.14,89.62) ; v1(256.4,63.08) 257.5,61.97 259.7,61.97 260.29,62.57 262.85,62.57 263.57,61.84 267.53,61.84 267.64,61.95 268.15,61.95 268.95,61.15 268.95,59.48 271.05,57.38 275.07,57.38 276.18,56.27 276.18,54.97 274.39,53.17 271.78,53.17 270.6,51.99 269.4,51.99 268.62,51.21 268.62,49.85 267.33,48.56 265.13,48.56 264.07,47.49 264.07,46.58 263.34,45.85 263.34,45.13 260.99,42.78 260.35,42.78 v1(259.88,43.25)
  IN2 w0.122: v1(239.05,61.98) 238.69,62.35 238.69,63.23 238.34,63.58 238.34,66.97 238.53,67.16 238.53,71.64 238.83,71.94 238.83,72.79 238.53,73.09 238.53,74.19 238.47,74.25 v1(238.47,77.15)
  IN4 w0.084: v1(256.4,63.08) 256.01,62.69 255.13,62.69 254.86,62.96 254.86,63.85 254.52,64.19 251.03,64.19 249.84,63 249.66,63 247,60.35 246.61,60.35 245.07,61.88 239.15,61.88 v1(239.05,61.98)
  BOTTOM w0.102: v1(259.88,43.25) 259.57,43.56 254.57,43.56 253.69,42.68 253.26,42.68 253,42.42 JLPDE1.8 ; RC244.1 v1(193.14,89.62)
PCH_POPIRCOMP: length 17.1
  TOP w0.102: v2(173.8,72.37) RC89.1
  TOP w0.381: v1(173,73.21) 173,73.01 172.82,72.83 RC89.1
  IN1 w0.203: v1(164.55,83.37) 164.7,83.22 164.7,82.52 169.16,78.06 170.79,78.06 172.78,76.07 172.78,73.43 v1(173,73.21)
  BOTTOM w0.254: UC1.AU16 v1(164.55,83.37)
PCH_PWROK: length 158.5
  TOP w0.102: PR614.1 81.48,85.25 v1(81.21,84.98)
  IN1 w0.084: v1(81.21,84.98) 78.88,84.98 70.2,76.3 70.2,74.02 65.96,69.79 65.96,66.65 66.63,65.99 66.63,64.15 65.69,63.21 64.52,63.21 64.3,62.99 64.3,59.86 65.22,58.94 v1(65.3,58.94)
  IN2 w0.122: v1(166.67,71.42) 166.67,68.46 163.15,64.94 92.31,64.94 91.51,64.15 84.73,64.15 84.12,63.53 82.8,63.53 79.27,60 76.32,60 75.6,59.28 75.6,58.64 75.4,58.44 74.85,58.44 74.53,58.77 72.15,58.77 72.08,58.7 71.6,58.7 71.15,59.15 67.97,59.15 66.97,60.15 66.43,60.15 65.63,59.34 65.63,59.27 v1(65.3,58.94)
  BOTTOM w0.076: 164.71,76.77 164.71,76.84 164.59,76.96 164.59,77.68 163.55,78.72 163.55,79.11 163.17,79.5 163.17,80.1 162.84,80.43 162.84,80.97 UC1.BA20
  BOTTOM w0.102: v1(166.67,71.42) 164.71,73.38 164.71,76.77

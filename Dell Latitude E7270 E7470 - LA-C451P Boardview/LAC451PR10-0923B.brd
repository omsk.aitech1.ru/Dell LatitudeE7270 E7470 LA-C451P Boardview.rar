# Allegro board LAC451PR10-0923B.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
CPU_DP1_P1: length 112.3
  IN4 w0.084: v1(234.57,124.27) 234.8,124.5 234.8,125.38 234.46,125.71 229.19,125.71 227.66,124.18 221.5,124.18 220.88,123.57 215.52,123.57 214.9,124.18 212.19,124.18 207.18,119.17 204.92,119.17 203.88,118.13 198.77,118.13 198.41,118.49 193.45,118.49 192.84,117.88 189.43,117.88 188.82,118.49 168.86,118.49 167.94,119.4 165.76,119.4 162.64,116.28 161.62,116.28 157.57,112.23 157.57,111.6 157.22,111.25 157.22,110.73 156.66,110.17 152.32,110.17 149.48,107.32 149.48,104.97 148.37,103.86 148.37,103.48 147.63,102.74 143.4,102.74 141.81,101.15 141.44,101.15 141.31,101.02 141.31,100.71 140.78,100.18 v1(140.78,100.08)
  BOTTOM w0.076: UC1.F58 v1(140.78,100.08)
  BOTTOM w0.094: v1(234.57,124.27) 234.77,124.47 234.77,124.95 CV21.2
CPU_DP1_P2: length 106
  IN4 w0.084: v1(143.52,99.44) 143.52,99.63 143.6,99.7 143.91,99.7 144.06,99.86 144.06,100.9 144.34,101.18 149.25,101.18 150.24,102.17 150.24,104.05 150.81,104.62 150.81,106.99 152.69,108.87 156.94,108.87 158.33,110.26 158.33,110.79 161.11,113.57 161.64,113.57 164.86,116.79 169.25,116.79 169.56,116.48 177.35,116.48 177.61,116.23 179.34,116.23 179.6,116.48 180.24,116.48 180.61,116.11 183.66,116.11 184.03,116.48 200.22,116.48 200.59,116.11 205.69,116.11 212.65,123.08 214.44,123.08 215.1,122.41 221.3,122.41 221.9,123.02 228.06,123.02 229.65,124.61 231.24,124.61 231.35,124.49 231.35,124.37 231.06,124.08 v1(231.01,124.08)
  BOTTOM w0.076: UC1.G53 v1(143.52,99.44)
  BOTTOM w0.094: v1(231.01,124.08) 231.21,124.28 231.21,124.95 CV28.2
CPU_DP1_P3: length 119.7
  IN4 w0.076: 140.23,101.52 140.23,101.5 140.24,101.49 140.24,99.12 140.45,98.91 141.02,98.91 141.32,99.21 141.32,99.37 141.39,99.44 v1(141.69,99.44)
  IN4 w0.084: 140.23,101.52 140.23,102.31 141.38,103.46 147.13,103.46 147.53,103.86 147.53,104.19 148.38,105.03 148.38,107.98 151.29,110.89 156.37,110.89 156.5,111.02 156.5,111.57 156.85,111.92 156.85,112.54 161.31,117 162.34,117 165.46,120.12 168.3,120.12 169.2,119.22 189.73,119.22 190.35,118.6 192.52,118.6 193.15,119.22 198.78,119.22 199.15,118.86 201.11,118.86 201.52,119.26 203.93,119.26 204.6,119.93 206.93,119.93 211.89,124.9 215.2,124.9 215.81,124.29 217.8,124.29 218.41,124.9 227.36,124.9 228.89,126.43 235,126.43 235.91,125.52 235.91,124.32 236.17,124.06 236.44,124.06 236.54,124.16 236.54,124.26 v1(236.33,124.47)
  BOTTOM w0.076: UC1.G56 v1(141.69,99.44)
  BOTTOM w0.094: CV13.2 236.53,124.97 236.53,124.67 v1(236.33,124.47)
CPU_DP2_AUXN: length 131.1
  TOP w0.094: CV80.1 250.14,127.06 250.21,127.14 250.21,127.37 v1(249.86,127.72)
  IN1 w0.084: v1(146.26,100.08) 146.23,100.04 146.23,99.93 146.35,99.81 146.59,99.81 146.64,99.86 146.64,101.03 147.33,101.72 147.33,107.11 146.89,107.55 146.58,107.55 146.5,107.47 v1(146.5,107.34)
  IN4 w0.084: v1(249.86,127.72) 250.07,127.93 250.07,128.02 249.97,128.13 246.17,128.13 244.96,126.92 237.39,126.92 236.88,127.43 229.23,127.43 227.17,125.37 211.7,125.37 207.22,120.89 204.87,120.89 203.72,119.73 180.69,119.73 180.5,119.92 169.18,119.92 168.52,120.58 165.27,120.58 162.15,117.46 160.09,117.46 157.5,114.88 150.9,114.88 150.45,114.43 150.45,111.81 147.11,108.47 147.11,107.74 146.92,107.55 146.7,107.55 146.5,107.35 v1(146.5,107.34)
  BOTTOM w0.076: UC1.E48 146.72,100.29 146.51,100.08 v1(146.26,100.08)
  BOTTOM w0.094: RC181.2 147.83,109.89 147.83,107.88 147.48,107.52 146.68,107.52 v1(146.5,107.34)
CPU_DP2_AUXN_C: length 3.5
  TOP w0.094: UV7.25 248.43,124.62 248.56,124.75 248.56,125.08 248.96,125.47 249.57,125.47 249.6,125.44 249.87,125.44 250.11,125.68 250.11,125.79 CV80.2
CPU_DP2_AUXP: length 130.8
  TOP w0.094: v1(250.45,127.72) 250.4,127.67 250.4,127.31 CV79.1
  IN1 w0.084: v1(146.5,107.92) 146.7,107.72 146.95,107.72 147.5,107.18 147.5,101.65 146.81,100.96 146.81,99.79 146.66,99.64 146.46,99.64 v1(146.26,99.44)
  IN4 w0.084: v1(146.5,107.92) 146.5,107.92 146.7,107.71 146.85,107.71 146.95,107.81 146.95,108.54 150.29,111.88 150.29,114.5 150.84,115.05 157.44,115.05 160.02,117.63 162.08,117.63 165.2,120.75 168.59,120.75 169.25,120.09 180.57,120.09 180.76,119.89 203.65,119.89 204.81,121.05 207.15,121.05 211.63,125.53 227.1,125.53 229.16,127.6 236.94,127.6 237.46,127.08 244.9,127.08 246.11,128.29 250.04,128.29 250.24,128.09 250.24,127.93 v1(250.45,127.72)
  BOTTOM w0.076: UC1.F48 146.66,99.84 v1(146.26,99.44)
  BOTTOM w0.094: RC182.2 147.65,109.89 147.65,107.95 147.41,107.71 v5(147.13,107.71) 146.71,107.71 v1(146.5,107.92)
CPU_DP2_AUXP_C: length 3.5
  TOP w0.094: UV7.24 248.83,124.64 248.74,124.73 248.74,125 248.99,125.25 v5(249.27,125.25) 249.95,125.25 250.3,125.6 250.3,125.79 CV79.2
CPU_DP2_CTRL_CLK: length 109
  TOP w0.102: v1(249.9,124.88) 249.63,124.61 UV7.22 ; v1(170.33,95.84) 170.12,95.63 170.12,95.53 170.22,95.44 171.84,95.44 172.35,95.95 172.35,96.24 172.66,96.55 172.96,96.55 RC176.1
  IN2 w0.122: v1(193.63,100.47) 193.8,100.3 194.31,100.3 194.88,100.87 194.88,109.94 194.37,110.45 194.37,113.41 201.11,120.15 203.54,120.15 205.2,121.81 211.4,121.81 212.05,122.46 213.14,122.46 213.41,122.19 217.89,122.19 218.22,122.53 221.08,122.53 221.69,123.13 239.72,123.13 240.98,124.39 247.88,124.39 249.03,125.54 249.5,125.54 249.75,125.29 249.75,125.03 v1(249.9,124.88)
  IN4 w0.084: v1(170.33,95.84) 170.11,95.63 170.11,95.51 170.21,95.42 172.02,95.42 172.08,95.47 173.07,95.47 174.94,93.6 176.26,93.6 176.5,93.85 177.47,93.85 179.11,95.49 179.42,95.49 180.1,96.16 180.55,96.16 181.02,96.63 183.93,96.63 184.68,97.38 187.79,97.38 188.33,97.91 190.8,97.91 193.17,100.28 193.44,100.28 v1(193.63,100.47)
  BOTTOM w0.076: v1(170.33,95.84) 170.69,96.2 UC1.N7
CPU_DP2_CTRL_DATA: length 109.3
  TOP w0.102: RC177.1 172.95,96.32 172.75,96.32 172.58,96.15 172.58,95.86 171.93,95.21 170.13,95.21 169.89,95.44 169.89,95.64 v1(169.69,95.84) ; UV7.23 249.23,124.79 v1(249.32,124.88)
  IN2 w0.122: v1(249.32,124.88) 249.5,125.06 249.5,125.18 249.4,125.29 249.13,125.29 247.99,124.14 241.08,124.14 239.83,122.88 221.79,122.88 221.18,122.28 218.32,122.28 217.99,121.94 213.31,121.94 213.03,122.21 212.16,122.21 211.5,121.56 205.3,121.56 203.64,119.9 201.22,119.9 194.62,113.3 194.62,110.55 195.13,110.04 195.13,100.77 194.41,100.05 193.8,100.05 v1(193.63,99.89)
  IN4 w0.084: v1(169.69,95.84) 169.9,95.63 169.9,95.43 170.12,95.21 172.11,95.21 172.16,95.26 172.98,95.26 174.85,93.39 176.34,93.39 176.59,93.64 177.56,93.64 179.2,95.28 179.51,95.28 180.18,95.95 180.64,95.95 181.11,96.42 184.02,96.42 184.77,97.17 187.88,97.17 188.41,97.7 190.88,97.7 193.25,100.07 193.44,100.07 v1(193.63,99.89)
  BOTTOM w0.076: UC1.N8 170.04,96.19 v1(169.69,95.84)
CPU_DP2_HPD: length 118.4
  TOP w0.102: v1(171.68,96.8) 172.03,97.15 v2(172.03,97.19) 172.03,97.84 172.87,98.67 RC242.2 ; UV7.3 v1(251.59,116.55)
  IN2 w0.102: v1(190.89,101.31) 190.89,102.02 190.76,102.15 190.76,117.08 191.92,118.23 v1(191.92,119.07)
  IN3 w0.102: v1(191.92,119.07) 192.68,119.83 199.65,119.83 200.31,119.17 203.71,119.17 206.76,122.22 208.64,122.22 211.1,124.68 215,124.68 215.6,124.09 217.94,124.09 218.59,124.74 225.49,124.74 227.95,122.28 227.95,118.58 228.96,117.57 250.57,117.57 v1(251.59,116.55) ; v1(171.68,96.8) 171.68,98.41 173.19,99.92 173.19,101.18 172.54,101.82 172.54,102.45 173.06,102.97 176.86,102.97 177.64,102.19 181.07,102.19 182.27,100.99 190.57,100.99 v1(190.89,101.31)
  BOTTOM w0.076: UC1.L7 171.04,97.58 171.49,97.58 171.68,97.39 v1(171.68,96.8)
CPU_DP2_N0: length 151.6
  TOP w0.094: v1(254.89,117.66) 254.73,117.51 254.44,117.51 254.4,117.46 254.21,117.46 CV72.1
  IN4 w0.084: v1(254.89,117.66) 254.41,117.66 254.21,117.86 254.21,121.8 254.9,122.49 255.3,122.49 255.86,123.05 255.86,125.31 251.77,129.4 245.62,129.4 244.92,128.7 228.7,128.7 226.64,126.64 211.17,126.64 206.73,122.2 204.31,122.2 203.12,121 188.82,121 188.41,121.41 187.55,121.41 187.16,121.01 181.51,121.01 181.22,121.31 171.87,121.31 170.71,122.46 163.86,122.46 160.86,119.46 160.12,119.46 159.71,119.88 157.21,119.88 154.27,122.82 151.17,122.82 149.06,120.71 149.06,113.62 148.26,112.82 148.26,111.37 147.03,110.14 144.52,110.14 144.19,109.81 144.19,108.17 144.36,107.99 144.52,107.99 144.72,107.79 v1(144.72,107.78)
  BOTTOM w0.076: v1(144.72,107.78) 144.72,107.84 145.01,108.12 145.3,108.12 145.58,107.85 145.58,107.37 145.59,107.35 145.59,106.39 145.95,106.03 145.95,103.6 146.04,103.51 146.04,103.12 146,103.01 146,102.76 146.03,102.66 146.03,102.47 145.99,102.34 145.98,102.33 145.98,102.27 145.92,102.21 145.6,102.21 145.45,102.05 145.45,101.82 145.51,101.76 145.71,101.76 145.77,101.82 UC1.C50
CPU_DP2_N0_C: length 2.8
  TOP w0.094: UV7.7 251.35,118.15 251.46,118.05 251.8,118.05 v5(252.11,117.74) 252.49,117.36 252.69,117.36 CV72.2
CPU_DP2_N1: length 154
  TOP w0.094: v1(254.59,119.58) 254.73,119.58 254.81,119.51 254.81,119.14 254.7,119.03 253.77,119.03 253.68,119.12 253.68,119.21 CV74.1
  IN4 w0.084: v1(143.61,106.53) 143.61,106.32 143.53,106.24 143.33,106.24 143.23,106.35 143.23,106.68 143.65,107.1 143.65,107.72 143.37,108 143.37,110.1 144.42,111.16 146.55,111.16 147.18,111.79 147.18,113.11 148.08,114.02 148.08,121.91 149.94,123.78 154.65,123.78 157.57,120.86 160.28,120.86 160.51,121.1 161.02,121.1 163.71,123.78 171.02,123.78 172.49,122.32 182.11,122.32 183.61,123.82 188.3,123.82 188.85,124.37 191.5,124.37 193.92,121.94 202.73,121.94 205.24,124.46 207.66,124.46 210.78,127.58 226.25,127.58 228.31,129.65 244.52,129.65 245.22,130.34 252.16,130.34 256.85,125.65 256.85,122.1 255.01,120.26 255.01,119.96 254.64,119.58 v1(254.59,119.58)
  BOTTOM w0.076: UC1.C52 144.46,102.22 144.37,102.47 144.37,102.65 144.43,102.84 144.43,102.99 144.37,103.1 144.37,103.37 144.51,103.5 144.51,104.29 143.98,104.81 143.98,106.16 v1(143.61,106.53)
CPU_DP2_N1_C: length 2.6
  TOP w0.094: UV7.10 251.35,119.35 251.46,119.25 v5(252.08,119.25) 252.4,119.25 252.51,119.14 252.7,119.14 CV74.2
CPU_DP2_N2: length 148.9
  TOP w0.094: v1(254.59,121.36) 255,120.96 255,120.79 254.92,120.71 254.65,120.71 254.56,120.81 253.79,120.81 253.73,120.87 253.73,121.04 253.96,121.27 CV76.1
  IN4 w0.084: v1(254.59,121.36) 255.24,122 255.37,122 256.3,122.93 256.3,125.43 251.93,129.79 245.45,129.79 244.76,129.09 228.54,129.09 226.48,127.03 211.01,127.03 206.84,122.86 204.43,122.86 202.96,121.39 193.65,121.39 191.23,123.81 189.33,123.81 187.28,121.76 187.27,121.76 187.02,121.51 182.14,121.51 181.89,121.76 172.26,121.76 170.79,123.23 163.96,123.23 161.25,120.52 160.75,120.52 160.53,120.3 157.34,120.3 154.43,123.21 150.98,123.21 148.65,120.89 148.65,113.78 147.83,112.96 147.83,111.76 146.62,110.56 144.49,110.56 143.84,109.91 143.84,108.1 144.26,107.68 144.26,107.03 144.36,106.93 144.59,106.93 144.7,107.04 v1(144.7,107.22)
  BOTTOM w0.076: UC1.A50 145.77,103.42 145.68,103.52 145.68,105.83 145.07,106.43 145.07,106.74 144.83,106.97 144.78,106.97 144.7,107.06 v1(144.7,107.22)
CPU_DP2_N2_C: length 2.7
  TOP w0.094: UV7.13 251.35,120.55 251.46,120.45 251.64,120.45 v5(251.88,120.68) 252.13,120.94 252.72,120.94 CV76.2
CPU_DP2_N3: length 134.7
  TOP w0.094: CV78.1 253.72,122.8 253.72,122.69 253.82,122.59 254.49,122.59 254.62,122.46 254.83,122.46 254.94,122.58 254.94,122.78 v1(254.59,123.14)
  IN4 w0.084: v1(144.7,104.77) 144.9,104.97 145.44,104.97 145.81,105.34 145.81,109.01 146.27,109.47 147.36,109.47 149.04,111.15 149.04,112.56 149.78,113.29 149.78,114.65 150.58,115.45 157.24,115.45 160.53,118.74 161.18,118.74 162.36,119.92 163.83,119.92 165.65,121.74 170.41,121.74 171.64,120.52 180.7,120.52 180.94,120.28 203.42,120.28 204.6,121.46 207.01,121.46 211.47,125.92 226.94,125.92 229,127.99 245.24,127.99 245.93,128.68 251.48,128.68 252.97,127.19 252.97,126.44 254.75,124.67 254.75,123.29 v1(254.59,123.14)
  BOTTOM w0.076: UC1.D51 145.2,101.76 144.91,102.05 144.91,102.39 145.13,102.61 145.13,104.34 v1(144.7,104.77)
CPU_DP2_N3_C: length 3.3
  TOP w0.094: CV78.2 252.68,122.68 252.46,122.68 252.08,122.3 v5(252.08,122.04) 252.08,121.78 251.95,121.65 251.46,121.65 251.35,121.75 UV7.16
CPU_DP2_P0: length 151.6
  TOP w0.094: v1(254.89,117.08) 254.64,117.33 254.52,117.33 254.47,117.28 254.07,117.28 253.96,117.17 CV71.1
  IN4 w0.084: v1(254.89,117.08) 254.47,117.5 254.35,117.5 254.05,117.8 254.05,121.87 254.83,122.65 255.23,122.65 255.7,123.12 255.7,125.24 251.7,129.23 245.69,129.23 244.99,128.54 228.77,128.54 226.71,126.47 211.24,126.47 206.8,122.03 204.38,122.03 203.19,120.84 188.75,120.84 188.35,121.24 187.62,121.24 187.23,120.85 181.44,120.85 181.15,121.14 171.8,121.14 170.64,122.3 163.93,122.3 160.93,119.3 160.06,119.3 159.64,119.72 157.14,119.72 154.2,122.66 151.24,122.66 149.22,120.64 149.22,113.55 148.42,112.75 148.42,111.31 147.09,109.98 144.59,109.98 144.35,109.74 144.35,108.24 144.43,108.16 144.63,108.16 144.72,108.25 v1(144.72,108.37)
  BOTTOM w0.076: UC1.D50 146.15,101.64 146.15,102.28 146.2,102.45 146.2,102.69 146.16,102.79 146.16,102.98 146.2,103.07 146.21,103.08 146.21,103.58 146.12,103.67 146.12,106.1 145.76,106.46 v5(145.76,107.64) 145.76,107.9 145.37,108.29 144.8,108.29 v1(144.72,108.37)
CPU_DP2_P0_C: length 2.8
  TOP w0.094: CV71.2 252.7,117.17 252.42,117.17 252.21,117.38 252.16,117.38 251.68,117.86 251.46,117.86 251.35,117.75 UV7.6
CPU_DP2_P1: length 154
  TOP w0.094: CV73.1 254.21,118.85 254.77,118.85 254.99,119.07 254.99,119.36 v1(255.2,119.58)
  IN4 w0.084: v1(143.61,105.87) 143.61,105.9 143.43,106.08 143.27,106.08 143.06,106.28 143.06,106.74 143.48,107.16 143.48,107.65 143.2,107.93 143.2,110.17 144.35,111.32 146.48,111.32 147.01,111.86 147.01,113.18 147.91,114.09 147.91,121.98 149.88,123.94 154.72,123.94 157.64,121.03 160.21,121.03 160.45,121.26 160.95,121.26 163.64,123.95 171.09,123.95 172.55,122.48 182.04,122.48 183.55,123.99 188.23,123.99 188.78,124.53 191.57,124.53 193.99,122.11 202.66,122.11 205.17,124.62 207.59,124.62 210.71,127.75 226.18,127.75 228.24,129.81 244.46,129.81 245.15,130.51 252.23,130.51 257.02,125.72 257.02,122.03 255.2,120.21 v1(255.2,119.58)
  BOTTOM w0.076: UC1.D52 144.42,101.59 144.35,101.85 144.35,101.97 144.27,102.25 144.22,102.4 144.21,102.45 144.21,102.67 144.27,102.86 144.27,102.95 144.23,103.03 144.21,103.06 144.21,103.44 144.34,103.57 144.34,104.22 143.81,104.75 143.81,105.74 143.67,105.87 v1(143.61,105.87)
CPU_DP2_P1_C: length 2.6
  TOP w0.094: UV7.9 251.35,118.95 251.46,119.06 251.75,119.06 251.79,119.03 252.36,119.03 252.43,118.95 252.7,118.95 CV73.2
CPU_DP2_P2: length 148.9
  TOP w0.094: v1(255.18,121.36) 255.18,120.71 255,120.53 254.58,120.53 254.48,120.63 254.21,120.63 CV75.1
  IN4 w0.084: v1(255.18,121.36) 255.18,121.71 255.31,121.84 255.44,121.84 256.46,122.86 256.46,125.49 252,129.95 245.38,129.95 244.69,129.26 228.47,129.26 226.41,127.19 210.94,127.19 206.77,123.02 204.36,123.02 202.89,121.56 193.72,121.56 191.3,123.97 189.26,123.97 187.22,121.93 187.2,121.93 186.95,121.67 182.21,121.67 181.96,121.93 172.32,121.93 170.86,123.4 163.89,123.4 161.18,120.68 160.68,120.68 160.46,120.47 157.41,120.47 154.5,123.38 150.91,123.38 148.49,120.96 148.49,113.85 147.66,113.03 147.66,111.83 146.56,110.73 144.42,110.73 143.67,109.98 143.67,108.03 144.09,107.61 144.09,106.96 144.29,106.76 144.5,106.76 v1(144.7,106.57)
  BOTTOM w0.076: v1(144.7,106.57) 145.51,105.76 145.51,103.4 145.48,103.37 145.48,102.85 UC1.B50
CPU_DP2_P2_C: length 2.7
  TOP w0.094: UV7.12 251.35,120.15 251.46,120.26 251.76,120.26 252.26,120.76 252.67,120.76 CV75.2
CPU_DP2_P3: length 134.7
  TOP w0.094: CV77.1 254.21,122.41 254.42,122.41 254.54,122.28 254.91,122.28 255.13,122.5 255.13,123.08 v1(255.18,123.14)
  IN4 w0.084: v1(144.7,105.42) 144.7,105.23 144.79,105.14 145.37,105.14 145.64,105.41 145.64,109.08 146.2,109.64 147.29,109.64 148.88,111.22 148.88,112.62 149.61,113.36 149.61,114.72 150.51,115.62 157.17,115.62 160.46,118.91 161.11,118.91 162.29,120.09 163.76,120.09 165.58,121.91 170.48,121.91 171.7,120.68 180.77,120.68 181.01,120.45 203.35,120.45 204.53,121.62 206.94,121.62 211.4,126.09 226.87,126.09 228.93,128.15 245.17,128.15 245.86,128.85 251.54,128.85 253.13,127.26 253.13,126.51 254.91,124.74 254.91,123.4 v1(255.18,123.14)
  BOTTOM w0.076: UC1.C51 145.16,102.28 145.16,102.4 145.3,102.54 145.3,104.41 145.07,104.63 145.07,104.93 144.86,105.14 144.75,105.14 144.7,105.19 v1(144.7,105.42)
CPU_DP2_P3_C: length 3.2
  TOP w0.094: UV7.15 251.35,121.35 251.46,121.46 252.02,121.46 252.3,121.74 252.3,122.26 252.54,122.5 252.71,122.5 CV77.2
CPU_DP3_AUXN: length 1.1
  TOP w0.102: T1.1 148.38,99.73 v1(148.11,99.45)
  BOTTOM w0.076: UC1.G46 147.84,99.19 v1(148.11,99.45)
CPU_DP3_AUXP: length 1.1
  TOP w0.102: v1(147.19,100.08) 146.85,99.74 T2.1
  BOTTOM w0.076: UC1.F46 v1(147.19,100.08)
CPU_ID: length 7.4
  TOP w0.102: UE1.B60 233.17,62.78 233.4,63.01 v1(233.73,63.01) ; v1(233.66,60.79) 233.66,60.37 RE298.1 RE299.1 235.72,59.42 236.4,60.09 v2(236.4,60.33)
  IN2 w0.102: v1(233.73,63.01) 233.66,62.95 v1(233.66,60.79)
CPU_POPIRCOMP: length 20.5
  TOP w0.381: v1(171.14,71.85) 171.54,72.25 171.8,72.25 RC88.1
  IN1 w0.203: v1(171.14,71.85) 172.57,71.85 173.49,72.78 173.49,76.37 171.51,78.35 169.28,78.35 165,82.64 165,83.56 v1(164.55,84)
  BOTTOM w0.254: UC1.AT16 v1(164.55,84)
CPU_XDP_PRDY#: length 54.2
  IN4 w0.102: v1(141.51,104.52) 141.26,104.77 140.24,104.77 140.13,104.89 139.62,104.89 139.34,104.61 137.39,104.61 135.48,106.51 134.07,106.51 133.64,106.08 130.57,106.08 126.71,109.93 122.76,109.93 122.63,110.06 122.63,115.1 123.12,115.59 123.93,115.59 126.97,118.63 126.97,124.84 126.04,125.76 124.88,125.76 123.29,127.35 123.29,127.91 123,128.2 122.69,128.2 122.5,128.39 122.5,128.65 122.33,128.82 121.82,128.82 v1(121.43,128.44)
  BOTTOM w0.076: v1(141.51,104.52) 141.88,104.15 141.88,103.59 141.73,103.44 141.73,103.06 141.77,102.99 141.77,102.79 141.75,102.75 141.75,102.73 141.74,102.72 141.73,102.69 141.73,102.45 141.74,102.4 141.79,102.25 141.87,101.97 141.87,101.85 141.95,101.59 UC1.D56
  BOTTOM w0.102: JXDP1.5 119.39,127.92 119.91,128.44 v1(121.43,128.44)
CPU_XDP_PREQ#: length 61.1
  IN4 w0.102: v1(139.78,104.49) 139.68,104.39 137.31,104.39 135.4,106.31 134.16,106.31 133.72,105.88 130.48,105.88 126.63,109.73 122.67,109.73 122.43,109.98 122.43,115.18 123.04,115.79 123.84,115.79 126.76,118.72 126.76,124.76 125.96,125.56 124.09,125.56 122.5,127.15 122.5,127.99 v1(122.04,128.44)
  BOTTOM w0.076: UC1.D61 139.96,101.53 139.96,101.71 139.98,101.73 139.98,102.09 139.96,102.12 139.96,102.36 139.98,102.38 139.98,104.29 v1(139.78,104.49)
  BOTTOM w0.102: RC138.2 113.84,125.99 114.83,125 115.91,125 116.21,124.7 118.62,124.7 118.89,124.97 JXDP1.3 118.89,128.08 119.71,128.9 121.59,128.9 v1(122.04,128.44)
CPU_XDP_TCLK: length 44.1
  TOP w0.102: v1(142.42,114.99) 142.43,114.98 143.34,114.98 v3(143.49,114.83)
  IN2 w0.122: v1(142.42,114.99) 142.42,115.65 141.88,116.19 140.22,116.19 137.4,119.01 134.33,119.01 v1(133.93,118.61)
  IN4 w0.076: 140.21,111.35 140.18,111.32 140.18,110.41 137.86,108.09 137.86,106.55 138.81,105.6 v1(138.82,105.6) ; 140.21,111.35 141.54,111.35 142.02,111.83 142.02,112.87 141.82,113.08 141.81,113.08 ; 140.21,111.35 138.68,111.35 138.08,110.75
  IN4 w0.084: v1(135.71,111.04) 136.15,110.6 137.94,110.6 138.08,110.74 138.07,110.74 138.08,110.75 ; 141.81,113.08 141.81,114.38 v1(142.42,114.99)
  BOTTOM w0.076: UC1.B61 139.48,102.77 139.48,102.99 139.42,103.1 139.42,103.37 139.59,103.54 139.59,103.92 138.99,104.53 138.99,105.43 v1(138.82,105.6)
  BOTTOM w0.102: v1(135.71,111.04) RC328.2 ; JXDP1.57 132.39,125.04 134.11,123.32 134.11,118.79 v1(133.93,118.61) 133.89,118.58 133.66,118.58 133.22,118.13 132.9,118.13 132.52,117.75 RC139.2
CPU_XDP_TDI: length 26.2
  TOP w0.102: v1(139.93,120.86) v3(140.57,120.86)
  IN2 w0.102: v1(142.43,116.92) 142.43,118.36 v1(139.93,120.86)
  IN4 w0.076: 142.71,113.08 142.71,111.76 141.78,110.83 141.36,110.83 140.22,109.69 140.22,109.14 139.56,108.48 139.56,107.46 139.13,107.04 v1(139.13,106.93)
  IN4 w0.102: v1(142.43,116.92) 142.79,116.56 142.79,115.94 143.34,115.39 143.34,114.44 142.71,113.8 142.71,113.08
  BOTTOM w0.076: UC1.D60 140.25,101.82 140.54,102.12 140.54,102.36 140.32,102.58 140.32,105.02 139.64,105.7 139.64,106.42 v1(139.13,106.93)
  BOTTOM w0.102: UC8.6 139.99,120.8 v1(139.93,120.86) 139.74,121.05 139.1,121.05 RC134.2
CPU_XDP_TDO: length 25.7
  TOP w0.102: v1(138.33,107.34) v3(137.79,107.34)
  IN4 w0.076: v1(138.33,107.34) 138.33,108.02 139.66,109.36 139.66,109.6 141.23,111.17 141.62,111.17 142.3,111.86 142.3,113.08
  IN4 w0.102: v1(137.84,116.57) 137.91,116.51 139.35,116.51 139.85,116.01 141.97,116.01 142.8,115.18 142.8,114.54 142.3,114.04 142.3,113.08
  BOTTOM w0.076: v1(138.33,107.34) 138.76,106.9 138.76,106.19 139.23,105.72 139.23,104.52 139.77,103.98 139.77,103.3 UC1.A61
  BOTTOM w0.102: v1(137.84,116.57) 138.07,116.8 138.07,118.28 RC135.2 140.05,119.05 140.3,119.3 UC8.3
CPU_XDP_TMS: length 28.4
  TOP w0.102: v3(138.96,121.6) 139.23,121.87 v1(139.46,121.87)
  IN2 w0.102: v1(139.46,121.87) 140.12,122.53 141.72,122.53 v1(142.11,122.13) 142.85,121.4 142.85,116.45 v1(143.22,116.09)
  IN4 w0.076: v1(139.13,106.34) 139.16,106.34 139.81,106.99 139.81,108.37 140.38,108.94 140.38,109.62 141.41,110.65 141.88,110.65 142.91,111.68 142.91,113.08
  IN4 w0.102: v1(143.22,116.09) 143.58,115.72 143.58,114.32 142.91,113.65 142.91,113.08
  BOTTOM w0.076: v1(139.13,106.34) 139.45,106.02 139.45,105.66 140.16,104.95 140.16,102.33 UC1.C60
  BOTTOM w0.102: v1(142.11,122.13) 142.26,121.98 UC8.8 ; v1(139.46,121.87) 139.29,121.7 RC131.2
CPU_XDP_TRST#: length 34.2
  TOP w0.102: v1(139.1,107.54) v3(139.63,107.54)
  IN4 w0.076: 142.5,113.08 142.5,111.79 141.72,111.01 141.3,111.01 139.93,109.64 139.93,109.26 139.1,108.43 v1(139.1,107.54)
  IN4 w0.102: 142.5,113.08 142.5,113.9 143.08,114.47 143.08,115.29 142.4,115.96 v1(142.4,116.37)
  BOTTOM w0.076: UC1.B59 140.49,102.89 140.49,105.09 139.89,105.69 139.89,106.75 v1(139.1,107.54) 138.92,107.72 138.14,107.72 137.93,107.51 137.93,107.18 138.45,106.66 138.45,105.43 138.82,105.06 138.82,104.46 139.43,103.86 139.43,103.61 139.25,103.44 139.25,103.06 139.27,103.04 139.29,102.98 139.29,102.37 139.3,102.36 139.3,102.29 UC1.C61
  BOTTOM w0.102: v1(142.4,116.37) 142.63,116.59 145.74,116.59 146.28,117.13 146.28,117.61 145.4,118.49 CC308.1 145.06,119.21 RC136.2 UC8.11
CS_1.2V: length 1.7
  BOTTOM w0.203: PR203.2 79.25,76.21 PU201.13
CSI2_COMP: length 20.4
  TOP w0.102: RC3.1 v2(164.82,111.06) 164.82,110.93 162.46,108.57 159.75,108.57 159.38,108.2 159.38,104.77 160.94,103.22 163.92,103.22 165.18,101.96 165.18,101.93 v1(166.38,100.73)
  BOTTOM w0.254: v1(166.38,100.73) 166.62,100.73 166.84,100.51 UC1.E13
CSS_GC: length 133.7
  TOP w0.254: PU901.10 92.44,67.14 v1(92.56,67.03)
  IN1 w0.254: v1(68.36,45.06) 68.08,44.78 68.08,43.11 68.39,42.81 68.39,40.33 67.1,39.04 61.32,39.04 60.04,40.32 56.42,40.32 55.2,39.1 40.17,39.1 36.09,43.18 33.58,43.18 29.62,39.22 28.22,39.22 26.63,37.62 26.63,35.94 25.29,34.59 14.76,34.59 13.78,35.57 13.78,45.72 16.48,48.42 v1(18.77,48.42)
  IN3 w0.254: v1(68.36,45.06) 68.74,45.06 70.37,46.68 70.37,50.44 70.1,50.7 70.1,53.02 72.32,55.24 74.41,55.24 75.25,54.4 77.7,54.4 78.54,55.24 84.62,55.24 86.49,57.12 87.39,57.12 92.56,62.28 v1(92.56,67.03)
  IN4 w0.102: v1(18.02,55.1) 18.02,49.17 v1(18.77,48.42)
  BOTTOM w0.254: PR804.1 v1(18.02,55.1)
CSSN_1: length 9.1
  TOP w0.254: v1(20.29,49.06) 20.34,49.01 PR809.1 21.18,49.13 v2(21.18,50.58) 20.42,51.34 19.27,51.34 PQ805.3
  BOTTOM w0.254: PR807.1 21.16,49.74 PR805.1 v1(20.29,49.06) 20.29,48.36 19.49,47.55 PQ803.3
CSSP_1: length 12.7
  TOP w0.254: v1(18.51,50.58) 18.13,50.2 18.13,47.66 18.43,47.36 PQ804.3 20.21,47.36 20.42,47.15 20.42,46.52 20.62,46.31 PR808.1
  BOTTOM w0.102: PR806.1 21.17,51.95 v2(21.06,52.06)
  BOTTOM w0.254: PR806.1 20.3,50.64 PR805.2 20.29,51.23 19.97,51.54 PQ801.3 18.49,50.6 v1(18.51,50.58)
CV2_ON: length 102.6
  TOP w0.102: v1(248.24,66.79) UE2.A9 ; v1(264.34,64.49) 264.13,64.28 262.49,64.28 262.19,63.98 262.19,63.19 262.45,62.93 RPE10.2 ; v1(272.97,59.51) v2(272.97,58.86)
  IN1 w0.102: v1(284.86,20.87) 286.36,22.37 289.62,22.37 290.34,21.65 290.34,12.89 288.44,10.98 286.55,10.98 285.53,9.96 v1(285.53,9.37) ; v1(272.97,59.51) 272.97,59.79 268.88,63.88 268.88,64.23 268.24,64.87 264.72,64.87 v1(264.34,64.49) 263.73,64.49 262.48,65.73 260.92,65.73 260.64,66.01 249.53,66.01 248.76,66.79 v1(248.24,66.79)
  IN2 w0.102: v1(272.97,59.51) 272.97,57.88 272.17,57.08 272.17,52.52 271.9,52.25 271.9,48.64 273.17,47.37 273.17,44.13 272.59,43.54 272.59,41.77 276.45,37.91 276.45,31.37 278.53,29.29 278.53,25.18 282.84,20.87 v1(284.86,20.87)
  BOTTOM w0.102: v1(285.53,9.37) 285.4,9.25 JUSH1.24
D_CLKRUN#: length 138.4
  TOP w0.102: RPE8.4 237.58,74.58 237.42,74.43 v1(237.42,74.39) 235.92,72.89 UE1.A19 ; v1(248.49,83.67) 248.49,83.86 v2(248.21,84.15)
  IN1 w0.102: v1(164.08,128.7) 164.62,128.16 165.15,128.16 166.8,126.51 166.8,126.11 171.64,121.27 181.71,121.27 192.95,110.02 205.54,110.02 209.9,105.66 215.36,105.66 215.76,105.25 218.73,105.25 219.41,104.57 227.88,104.57 228.39,104.05 242.86,104.05 250.97,95.94 250.97,91.36 251.7,90.64 251.7,86.31 249.06,83.67 v1(248.49,83.67)
  BOTTOM w0.102: v1(248.49,83.67) 247.95,83.13 247.48,83.13 247.3,82.94 243.62,82.94 241.25,80.57 241.25,76.41 239.94,75.1 238.14,75.1 v1(237.42,74.39) ; JDOCK1.111 163.5,129.34 164.08,128.76 v1(164.08,128.7)
D_DLDRQ1#: length 145.6
  TOP w0.102: v2(246.8,84.34) 247.34,83.79 247.34,83.74 v1(247.35,83.73) ; UE1.B24 v1(234.17,70.66) ; RPE8.2 236.58,74.69 v1(236.28,74.39)
  IN1 w0.102: v1(165.04,129.15) 165.52,128.67 165.52,128.37 167.21,126.68 167.21,126.27 171.81,121.67 181.88,121.67 193.12,110.43 205.7,110.43 209.22,106.91 210.61,106.91 211.46,106.07 215.53,106.07 215.93,105.66 218.89,105.66 219.58,104.97 227.93,104.97 230.25,107.3 237.05,107.3 238.59,105.75 239.72,105.75 241.02,104.46 243.03,104.46 251.38,96.11 251.38,91.53 252.1,90.8 252.1,86.14 248.99,83.03 248.05,83.03 v1(247.35,83.73)
  BOTTOM w0.102: v1(234.17,70.66) 234.28,70.54 234.88,70.54 235.07,70.74 235.07,71.95 236.28,73.16 v1(236.28,74.39) 237.4,75.51 239.78,75.51 240.84,76.57 240.84,80.74 243.45,83.35 246.97,83.35 v1(247.35,83.73) ; v1(165.04,129.15) 165,129.19 JDOCK1.117
D_LAD0: length 143.4
  TOP w0.102: UE1.B29 231.67,71.06 v1(231.81,70.91)
  IN1 w0.102: v1(248.13,85.61) 248.93,85.61 250.68,87.36 250.68,90.17 249.95,90.9 249.95,95.52 242.43,103.03 227.97,103.03 227.45,103.55 216.02,103.55 214.92,104.64 209.48,104.64 205.11,109.01 192.53,109.01 181.29,120.25 171.22,120.25 165.18,126.28 v1(164.56,126.28)
  BOTTOM w0.102: v1(248.13,85.61) 248.13,84.82 247.66,84.35 245.9,84.35 245.61,84.06 243.3,84.06 240.23,80.99 240.23,76.83 239.52,76.12 236.89,76.12 235.48,74.71 235.48,74.45 234.71,73.68 234.71,72.97 233.58,71.84 232.74,71.84 v1(231.81,70.91) ; v1(164.56,126.28) 164.16,126.69 162.83,126.69 160,129.53 JDOCK1.97
D_LAD1: length 143.6
  TOP w0.102: v1(248.51,85.19) v2(249.04,85.19) ; v1(232.37,70.89) 232.17,71.09 UE1.B28
  IN1 w0.102: v1(248.51,85.19) 248.83,85.19 250.88,87.24 250.88,90.27 250.16,91 250.16,95.6 242.52,103.24 228.05,103.24 227.54,103.75 216.1,103.75 215.01,104.85 209.56,104.85 205.2,109.21 192.61,109.21 181.37,120.45 171.3,120.45 165.96,125.79 165.96,126.2 165.42,126.74 164.37,126.74 v1(163.99,127.12)
  BOTTOM w0.102: JDOCK1.99 160.5,129.46 162.84,127.12 v1(163.99,127.12) ; v1(232.37,70.89) 232.37,71.17 232.84,71.64 233.66,71.64 234.91,72.89 234.91,73.59 235.68,74.37 235.68,74.63 236.97,75.92 239.61,75.92 240.43,76.74 240.43,80.91 243.38,83.86 245.69,83.86 245.98,84.15 247.74,84.15 248.51,84.91 v1(248.51,85.19)
D_LAD2: length 142.3
  TOP w0.102: v1(233.36,73.36) 232.92,72.92 UE1.A25
  IN1 w0.102: v1(163.38,127.72) 163.56,127.54 164.9,127.54 166.19,126.26 166.19,125.85 171.39,120.66 181.45,120.66 192.7,109.41 205.28,109.41 209.65,105.05 215.09,105.05 215.5,104.64 218.47,104.64 219.16,103.96 227.62,103.96 228.14,103.44 242.6,103.44 250.36,95.68 250.36,91.08 251.09,90.36 251.09,86.59 249.31,84.81 248.13,84.81 v1(247.7,85.24)
  BOTTOM w0.102: 163.33,127.72 161.5,129.55 JDOCK1.103 ; 163.33,127.72 v1(163.38,127.72) ; 163.33,127.72 162.73,127.72 v2(162.06,128.38) ; v1(247.7,85.24) 247.41,85.24 246.96,84.79 245.77,84.79 245.44,84.47 243.13,84.47 239.82,81.16 239.82,77 239.35,76.53 236.72,76.53 235.07,74.88 235.07,74.62 234.01,73.55 233.55,73.55 v1(233.36,73.36)
D_LAD3: length 140.7
  TOP w0.102: UE1.A24 233.42,72.84 233.73,73.15 v1(233.93,73.15)
  IN1 w0.102: v1(247.44,84.73) 247.57,84.6 249.39,84.6 251.29,86.5 251.29,90.44 250.56,91.17 250.56,95.77 242.69,103.64 228.22,103.64 227.71,104.16 219.24,104.16 218.56,104.85 215.58,104.85 215.18,105.25 209.73,105.25 205.37,109.62 192.78,109.62 181.54,120.86 171.47,120.86 166.39,125.94 166.39,126.34 164.99,127.75 163.9,127.75 163.45,128.2 163.45,128.3 v1(163.18,128.57)
  BOTTOM w0.102: v1(247.44,84.73) 247.27,84.55 245.82,84.55 245.53,84.26 243.21,84.26 240.03,81.08 240.03,76.91 239.44,76.32 236.8,76.32 235.28,74.8 235.28,74.54 233.93,73.19 v1(233.93,73.15) ; JDOCK1.105 162,129.34 162.77,128.57 v1(163.18,128.57) 163.52,128.23 v2(163.52,128.22)
D_LFRAME#: length 142.2
  TOP w0.102: v1(246.78,83.73) 246.78,83.74 v2(245.42,83.74) ; v1(234.68,70.93) 234.67,70.94 UE1.B23
  IN1 w0.102: v1(164.08,128.13) 164.25,127.95 165.07,127.95 166.6,126.43 166.6,126.02 171.56,121.06 181.62,121.06 192.86,109.82 205.45,109.82 209.81,105.46 215.27,105.46 215.68,105.05 218.64,105.05 219.33,104.36 227.79,104.36 228.31,103.85 242.77,103.85 250.77,95.85 250.77,91.25 251.49,90.53 251.49,86.42 249.23,84.16 247.21,84.16 v1(246.78,83.73)
  BOTTOM w0.102: v1(234.68,70.93) 234.68,71.84 236.08,73.24 236.08,74.02 235.89,74.21 235.89,74.54 237.06,75.71 239.69,75.71 240.64,76.66 240.64,80.82 243.47,83.65 246.71,83.65 v1(246.78,83.73) ; v1(164.08,128.13) 163.7,128.51 163.7,128.85 163,129.55 JDOCK1.109
D_SERIRQ: length 138.5
  TOP w0.102: RPE8.3 237.08,74.6 v1(236.86,74.39) v2(236.24,73.76) 235.42,72.94 UE1.A20
  IN1 w0.102: v1(247.93,83.73) 247.93,83.56 248.25,83.24 248.91,83.24 251.9,86.23 251.9,90.72 251.17,91.45 251.17,96.02 242.94,104.25 228.48,104.25 227.96,104.77 219.5,104.77 218.81,105.46 215.85,105.46 215.44,105.86 209.98,105.86 205.62,110.23 193.03,110.23 181.79,121.47 171.72,121.47 167,126.19 167,126.59 165.03,128.56 v1(165.03,128.58)
  BOTTOM w0.102: v1(236.86,74.39) 237.78,75.31 239.86,75.31 241.04,76.49 241.04,80.66 243.54,83.15 247.14,83.15 247.34,83.35 247.55,83.35 v1(247.93,83.73) ; v1(165.03,128.58) 164.5,129.12 JDOCK1.115
DAI_12MHZ#: length 182
  TOP w0.102: RA30.1 286.71,63.94 v1(286.71,63.08)
  IN1 w0.084: v1(167.57,127.4) 167.57,127.23 172.2,122.61 182.27,122.61 192.67,112.21 206.44,112.21 208.48,110.17 208.48,109.6 210.23,107.85 214.8,107.85 215.24,107.41 219.74,107.41 221.2,108.87 225.93,108.87 226.23,108.57 226.23,107.84 227.12,106.95 228.58,106.95 229.87,108.23 237.43,108.23 238.5,107.17 239.8,107.17 241.58,105.39 243.41,105.39 250.54,98.27 251.84,98.27 252.38,97.73 252.38,91.85 253.04,91.19 253.04,83.65 257.08,79.61 257.08,79.08 261.3,74.86 263.23,74.86 263.63,74.46 265.58,74.46 267.6,76.48 270.76,76.48 271.78,77.5 272.77,77.5 273.31,76.96 273.31,73.82 275.18,71.95 277.85,71.95 280.21,69.59 280.21,64.32 281.41,63.13 286.66,63.13 v1(286.71,63.08)
  BOTTOM w0.102: v1(167.57,127.4) 167.07,126.89 167.07,126.09 166.21,125.23 163.61,125.23 161.73,127.11 v2(159.7,127.11) R41.1 156.73,127.99 157,128.26 JDOCK1.89
DAI_BCLK#: length 184.1
  TOP w0.102: RA31.1 288.43,62.7 v1(287.98,62.25)
  IN1 w0.084: v1(287.98,62.25) 287.57,62.66 281.99,62.66 279.82,60.49 274.57,60.49 272.64,62.41 271.65,62.41 270.99,63.07 270.99,67.28 270.14,68.13 270.14,70.73 269.78,71.09 268.62,71.09 265.71,74 263.43,74 263.04,74.39 261.11,74.39 259.33,76.17 258.25,76.17 257.46,76.96 257.46,77.9 256.61,78.75 256.61,79.42 252.58,83.46 252.58,91 251.92,91.66 251.92,96.23 243.22,104.93 241.21,104.93 239.92,106.22 238.79,106.22 237.24,107.77 230.06,107.77 227.73,105.45 219.78,105.45 218.28,106.94 215.04,106.94 214.6,107.38 212.99,107.38 212.33,106.73 211.47,106.73 210.81,107.38 209.42,107.38 205.81,110.99 193.22,110.99 182.07,122.15 172,122.15 168.08,126.07 v1(168.08,126.12)
  BOTTOM w0.102: JDOCK1.77 154,129.56 153.97,129.53 153.97,127.17 R6.1 154.51,126.63 154.51,126 155.19,125.31 157.27,125.31 157.68,125.71 161.76,125.71 163.24,124.24 166.58,124.24 168.08,125.74 v1(168.08,126.12)
DAI_DI: length 198.2
  TOP w0.203: UA1.24 291.26,66.66 291.4,66.52 291.77,66.52 v1(292.01,66.28)
  IN1 w0.102: v1(155.45,128.44) 156.92,126.97 161.17,126.97 169.88,118.26 179.99,118.26 180.16,118.09 180.16,117.61 183.7,114.07 183.7,113.73 187.87,109.56 189.76,109.56 191.86,107.46 204.47,107.46 209.32,102.61 213.43,102.61 214.04,102 214.04,101.68 215.04,100.69 229.27,100.69 229.78,101.19 242.09,101.19 248.05,95.23 248.05,88.33 247.53,87.81 247.53,86.27 244.59,83.33 244.59,80.92 244.54,80.87 244.54,74.52 246.03,73.02 247.03,73.02 247.92,72.14 249.22,72.14 249.52,72.44 250.89,72.44 251.21,72.11 258.34,72.11 258.58,71.87 259.14,71.87 259.38,72.11 261.07,72.11 261.13,72.05 261.71,72.05 261.94,72.28 266.18,72.28 267.61,70.85 267.61,68.88 268.17,68.32 268.17,66.49 269.92,64.73 269.92,63.13 271.32,61.74 272.36,61.74 274.42,59.68 280.09,59.68 282.39,61.98 287.29,61.98 287.62,61.65 288.21,61.65 288.62,62.06 288.62,67.65 288.95,67.98 290.31,67.98 v1(292.01,66.28)
  BOTTOM w0.102: JDOCK1.83 155.5,129.56 155.62,129.43 155.62,128.62 v1(155.45,128.44)
DAI_DO#: length 188.8
  TOP w0.102: RA32.1 288.11,63.97 v1(288.24,63.84)
  IN1 w0.102: v1(288.24,63.84) 288.39,63.69 288.39,62.12 288.13,61.86 287.71,61.86 287.38,62.19 282.31,62.19 280.04,59.91 274.47,59.91 272.45,61.94 271.45,61.94 270.13,63.26 270.13,64.87 268.39,66.61 268.39,68.39 267.82,68.97 267.82,70.93 266.27,72.48 261.85,72.48 261.63,72.26 261.21,72.26 260.67,72.79 258.5,72.79 258.02,72.31 251.3,72.31 250.97,72.64 249.43,72.64 249.13,72.34 248,72.34 247.11,73.23 246.12,73.23 244.74,74.61 244.74,80.78 244.8,80.84 244.8,83.25 247.73,86.18 247.73,87.72 248.25,88.25 248.25,95.31 242.18,101.39 229.69,101.39 229.19,100.89 215.13,100.89 214.25,101.77 214.25,102.09 213.52,102.81 209.41,102.81 204.56,107.66 191.94,107.66 189.84,109.76 187.95,109.76 183.9,113.81 183.9,114.15 180.36,117.69 180.36,118.17 180.07,118.46 169.97,118.46 161.25,127.18 157.3,127.18 v1(156.03,128.44)
  BOTTOM w0.102: JDOCK1.85 156,129.51 155.83,129.33 155.83,128.65 v1(156.03,128.44)
DAI_LRCK#: length 193.1
  TOP w0.203: v1(288.24,64.4) 288.74,64.4 v2(288.75,64.41) 288.94,64.6 288.94,66.01 288.86,66.09 UA1.18
  IN1 w0.102: v1(288.24,64.4) 281.24,64.4 280.68,64.95 280.68,69.78 278.04,72.42 275.37,72.42 273.78,74.01 273.78,77.16 272.96,77.98 269.68,77.98 268.66,76.96 266.95,76.96 265.27,75.27 264.3,75.27 263.82,75.75 263.33,75.75 262.91,75.33 261.5,75.33 257.55,79.28 257.55,79.81 254.68,82.68 254.68,84.2 253.51,85.37 253.51,87.7 254.2,88.39 254.2,91.31 252.86,92.66 252.86,97.93 252.04,98.75 250.73,98.75 241.29,108.19 239.22,108.19 238.21,109.2 230.09,109.2 228.32,107.42 227.32,107.42 226.71,108.04 226.71,108.96 225.9,109.76 221.23,109.76 219.35,107.88 215.43,107.88 214.99,108.32 210.42,108.32 208.95,109.79 208.95,111.89 208.16,112.68 192.86,112.68 185.21,120.33 185.21,123.29 184.58,123.92 182.71,123.92 181.87,123.08 172.39,123.08 168.21,127.27 v1(168.21,127.39)
  BOTTOM w0.102: JDOCK1.79 154.5,129.43 154.45,129.38 154.45,127.56 154.99,127.02 154.99,126.2 155.39,125.79 157.07,125.79 157.58,126.3 161.86,126.3 163.41,124.75 166.41,124.75 167.56,125.9 167.56,126.71 168.21,127.35 v1(168.21,127.39)
DAT_KBD: length 179
  TOP w0.102: v1(262.23,65.3) 262.37,65.44 RPE2.7 ; UE2.B41 258.57,66.04 258.48,65.95 258.16,65.95 v1(257.75,65.54)
  IN1 w0.084: v1(256.24,85.21) 256.04,85.42 256.04,86.15 256.72,86.83 256.72,91.96 254.9,93.78 254.9,98.78 252.32,101.36 251.02,101.36 240.49,111.88 229.56,111.88 229.16,111.48 227.18,111.48 225.84,112.83 225.84,114.25 226.29,114.71 226.29,122.94 223.16,126.08 216.64,126.08 215.55,127.17 201.17,127.17 200.08,126.08 192.65,126.08 190.73,127.99 190.73,128.75 186.93,132.56 182.58,132.56 180.73,134.41 180.73,139.49 179.68,140.54 172.75,140.54 171.45,139.23 160.51,139.23 160.01,139.73 157.54,139.73 157.1,139.29 154.69,139.29 154.36,139.62 154.36,140.02 v1(154.54,140.21)
  IN2 w0.122: v1(262.23,65.3) 262.07,65.46 262.07,65.58 262.25,65.76 262.58,65.76 262.9,66.07 262.9,69.75 261.23,71.41 261.23,75.01 259.89,76.35 259.89,81.66 258.64,82.91 258.64,83.65 257.57,84.72 256.23,84.72 256.08,84.88 256.08,85.04 v1(256.24,85.21)
  IN4 w0.084: v1(262.23,65.3) 262.23,65.02 261.81,64.6 259.73,64.6 259.31,65.02 258.26,65.02 v1(257.75,65.54)
  BOTTOM w0.102: JDOCK1.80 154.5,139.51 154.36,139.65 154.36,140.03 v1(154.54,140.21)
DAT_MSE: length 162
  TOP w0.102: UE2.B42 258.44,66.54 v1(258.29,66.39) ; RPE2.5 262.37,66.44 v1(262.23,66.58)
  IN1 w0.084: v1(250.28,88.98) 250.09,88.79 249.86,88.79 249.45,89.21 249.45,95.35 242.24,102.56 227.77,102.56 227.26,103.08 214.54,103.08 213.93,103.69 209.76,103.69 204.92,108.53 192.33,108.53 181.09,119.78 171.02,119.78 165.05,125.75 164.55,125.75 161.79,128.5 158.36,128.5 157.76,129.1 157.76,129.3 156.74,130.32 154.78,130.32 153.98,129.52 153.98,129.12 153.4,128.53 152.98,128.53 152.86,128.65 152.86,128.78 v1(153.04,128.96)
  IN4 w0.084: v1(258.29,66.39) 258.44,66.54 261.04,66.54 261.4,66.18 261.82,66.18 v1(262.23,66.58)
  BOTTOM w0.102: v1(262.23,66.58) 262.07,66.73 262.07,66.88 263.23,68.04 263.23,76.48 262.61,77.1 262.61,79.61 261.91,80.3 261.91,87.62 261.12,88.41 254.13,88.41 253.79,88.07 252.27,88.07 251.54,88.8 250.46,88.8 v1(250.28,88.98) ; v1(153.04,128.96) 152.86,129.14 152.86,129.39 153,129.53 JDOCK1.73
DAT_TP_SIO: length 75.7
  TOP w0.102: v1(283.28,11.43) 283.46,11.61 283.73,11.61 CZ30.1 ; UE2.B40 v1(258.33,65.54)
  IN2 w0.122: v1(277.19,25.01) 277.37,24.83 277.37,23.76 276.95,23.34 276.95,22.14 277.11,21.98 277.11,21.36 276.9,21.14 276.9,20.01 279.72,17.19 279.72,12.29 280.4,11.6 283.11,11.6 v1(283.28,11.43)
  BOTTOM w0.102: v1(258.33,65.54) 259.18,65.54 259.5,65.22 259.5,64.73 259.97,64.26 261.63,64.26 264.06,61.84 264.06,60.85 265.11,59.8 266.8,59.8 270.6,56 v5(270.82,55.78) 271.8,54.8 271.8,54.36 272.76,53.4 276.21,53.4 278.62,50.99 278.62,39.95 277.38,38.71 277.38,25.21 v1(277.19,25.01) ; RZ22.2 282.93,11.6 283.11,11.6 v1(283.28,11.43) 283.46,11.61 283.77,11.61 RZ18.2
DAT_TP_SIO_R: length 5.6
  TOP w0.102: v1(281.06,11.11) 281.5,11.55 281.5,12.7 v2(282.08,13.28)
  BOTTOM w0.102: RZ22.1 281.22,11.27 v1(281.06,11.11) 280.88,10.93 280.88,10.05 280.61,9.77 JKBTP1.13
DC_BLOCK_GC: length 137.4
  TOP w0.254: PU901.7 89.69,65.51 v1(90.02,65.19)
  IN1 w0.254: v1(68.36,45.75) 67.73,45.12 67.73,42.97 68.03,42.66 68.03,40.48 66.95,39.4 61.47,39.4 60.19,40.68 56.27,40.68 55.05,39.45 40.31,39.45 36.23,43.53 33.43,43.53 29.47,39.57 28.08,39.57 26.27,37.77 26.27,36.08 25.14,34.95 14.9,34.95 14.13,35.72 14.13,44.36 v1(16.04,46.26)
  IN3 w0.254: v1(90.02,65.19) 91.92,63.28 91.92,62.15 87.24,57.47 86.34,57.47 84.47,55.6 72.17,55.6 69.75,53.17 69.75,50.56 70.01,50.29 70.01,46.92 68.84,45.75 v1(68.36,45.75)
  IN4 w0.254: v1(16.04,46.26) 16.04,52.31 10.47,57.88 v1(7.15,57.88)
  BOTTOM w0.102: v2(6.21,58.59) 6.45,58.35 PR803.2
  BOTTOM w0.254: PR803.2 6.91,57.64 v1(7.15,57.88)
DC_IN_SS: length 3.1
  TOP w0.102: v2(84.11,66.46) PR935.2
  TOP w0.203: PU901.34 85.03,68.14 84.62,67.73 PR935.2
DDR_A_ACT#: length 64.7
  IN1 w0.076: v1(140.57,73.53) 140.89,73.53 140.99,73.43 140.99,71.73 140.82,71.56 140.42,71.56
  IN1 w0.132: v1(110.29,44.21) 109.82,44.21 109.49,44.55 109.49,47.86 109.16,48.18 109.16,50.34 109.74,50.91 109.74,51.82 120.21,62.29 120.21,62.29 120.8,62.88 122.52,62.88 122.53,62.88 123.75,62.88 124.46,62.17 130.47,62.17 139.86,71.56 140.42,71.56
  BOTTOM w0.076: v1(140.57,73.53) 140.77,73.33 141.22,73.33 141.36,73.47 141.36,75.66 140.59,76.44 140.59,76.81 141.29,77.51 141.29,77.73 142.78,79.22 142.78,79.55 142.45,79.88 142.45,80.17 142.59,80.31 142.59,80.72 142.53,80.85 142.53,80.96 142.59,81.09 142.59,81.55 142.66,81.62 142.76,81.62 UC1.BA55
  BOTTOM w0.17: v1(110.29,44.21) 110.73,43.77 110.73,43.38 111.62,42.48 JDIMM1.114
DDR_A_ALERT#: length 65
  IN1 w0.076: 139.09,69.3 140.48,70.68 140.68,70.68 141.49,71.5 141.49,76.2 142.36,77.07 143.34,77.07 v1(143.88,76.52)
  IN1 w0.132: v1(110.29,45.73) 110.74,46.18 110.74,48.19 110.22,48.72 110.22,49.9 111.27,50.96 111.27,51.86 120.52,61.12 130.91,61.12 139.09,69.3
  BOTTOM w0.076: v1(143.88,76.52) 144.12,76.52 144.79,77.2 144.79,78.08 145.14,78.43 145.14,79.15 145.75,79.76 145.75,80.25 145.57,80.43 145.57,80.69 145.61,80.81 145.61,80.98 145.55,81.2 145.55,81.29 145.61,81.45 145.61,81.6 arc(145.59,81.7) 145.56,81.8 145.56,82.32 UC1.AW50
  BOTTOM w0.17: v1(110.29,45.73) 111.39,44.64 111.39,43.29 112.12,42.55 JDIMM1.116
DDR_A_BA0: length 63.9
  IN1 w0.076: 147.24,69.3 147.24,71.22 147.47,71.44 147.47,79.38 145.35,81.5 v1(145.35,83.37)
  IN1 w0.132: v1(121.62,45.73) 121.22,46.13 121.22,48.91 122.98,50.67 122.98,51.55 124.47,53.04 135.44,53.04 139.82,57.43 140.17,57.43 140.5,57.09 140.69,57.09 140.88,57.28 140.88,57.47 140.5,57.86 140.5,58.1 140.68,58.28 141.88,58.28 146.49,62.89 146.49,63.08 146.27,63.29 146.27,63.48 146.47,63.68 146.66,63.68 146.87,63.46 147.06,63.46 147.24,63.64 147.24,69.3
  BOTTOM w0.076: v1(145.35,83.37) 145.02,83.7 UC1.AU52
  BOTTOM w0.17: JDIMM1.150 122.63,42.7 122.37,42.95 122.37,44.98 v1(121.62,45.73)
DDR_A_BA1: length 64.3
  IN1 w0.076: 147.65,69.3 147.65,71.18 147.71,71.23 147.71,79.38 145.63,81.45 145.63,82.7 145.83,82.9 145.83,83.64 v1(146.26,84.08)
  IN1 w0.132: v1(121.62,47.26) 122.02,47.65 122.02,49.12 122.98,50.08 124.07,51.17 124.07,51.72 124.98,52.63 135.61,52.63 137.61,54.63 137.81,54.63 138.19,54.25 138.37,54.25 138.56,54.44 138.56,54.62 138.18,55 138.18,55.19 138.37,55.37 138.56,55.37 138.93,55 139.12,55 139.31,55.18 139.31,55.37 138.93,55.75 138.93,55.93 139.12,56.12 139.3,56.12 139.68,55.74 139.87,55.74 140.06,55.93 140.06,56.12 139.68,56.49 139.68,56.68 139.88,56.89 140.07,56.89 140.48,56.48 140.66,56.48 141.48,57.3 141.67,57.3 141.95,57.02 142.13,57.02 142.32,57.2 142.32,57.39 142.04,57.67 142.04,57.86 147.65,63.47 147.65,69.3
  BOTTOM w0.076: v1(146.26,84.08) 146.62,84.35 UC1.AT48
  BOTTOM w0.17: JDIMM1.145 121.37,48.69 121.16,48.47 121.16,47.72 v1(121.62,47.26)
DDR_A_BG0: length 64.2
  IN1 w0.076: v1(140.95,76.63) 141.15,76.63 141.25,76.53 141.25,71.67 140.68,71.11 140.42,71.11
  IN1 w0.132: 140.42,71.11 140,71.11 130.65,61.76 123.84,61.76 123.71,61.89 123.71,62.34 123.58,62.47 123.31,62.47 123.18,62.34 123.18,61.89 123.05,61.76 122.78,61.76 122.65,61.89 122.65,62.34 122.52,62.47 122.25,62.47 122.12,62.34 122.12,61.89 121.99,61.76 121.73,61.76 121.59,61.89 121.59,62.34 121.46,62.47 121.2,62.47 121.07,62.34 121.07,61.89 120.93,61.76 120.26,61.76 110.35,51.85 110.35,50.95 109.58,50.17 109.58,48.35 109.9,48.03 109.9,47.65 v1(110.29,47.26)
  BOTTOM w0.076: UC1.AY55 142.59,82.08 142.59,81.96 142.64,81.91 142.92,81.91 143.01,81.81 143.09,81.66 143.09,81.47 143.03,81.32 143.03,81.17 143.09,80.95 143.09,80.84 143.06,80.76 143.05,80.73 143.05,80.36 143.25,80.16 143.25,79.46 141.47,77.68 141.47,76.72 141.37,76.63 v1(140.95,76.63)
  BOTTOM w0.17: JDIMM1.115 111.88,48.68 111.38,48.18 111.38,47.34 111.03,47 110.55,47 v1(110.29,47.26)
DDR_A_BG1: length 64.1
  IN1 w0.132: v1(108.77,47.26) 108.37,47.65 108.37,50.13 109.33,51.09 109.33,52.07 120.55,63.29 124.38,63.29 124.51,63.16 124.51,62.73 124.67,62.58 124.89,62.58 125.04,62.73 125.04,63.16 125.17,63.29 125.44,63.29 125.57,63.16 125.57,62.73 125.72,62.58 125.94,62.58 126.1,62.73 126.1,63.16 126.23,63.29 126.49,63.29 126.63,63.16 126.63,62.75 126.8,62.58 130.3,62.58 139.95,72.23 v1(140.57,72.23)
  BOTTOM w0.076: UC1.AY54 143.28,81.78 143.28,81.53 143.21,81.31 143.21,81.18 143.27,80.95 143.27,80.81 143.21,80.69 143.21,80.43 143.42,80.23 143.42,79.39 141.64,77.61 141.64,72.39 141.47,72.23 v1(140.57,72.23)
  BOTTOM w0.17: JDIMM1.113 111.37,48.81 111.01,48.45 110.09,48.45 109.68,48.04 109.68,47.5 109.44,47.26 v1(108.77,47.26)
DDR_A_CKE0: length 62.3
  IN1 w0.132: v1(107.25,47.26) 106.85,47.65 106.85,47.87 106.72,48 106.38,48 106.25,48.13 106.25,48.4 106.38,48.53 106.72,48.53 106.85,48.66 106.85,48.93 106.72,49.06 106.38,49.06 106.25,49.19 106.25,49.45 106.38,49.59 106.72,49.59 106.85,49.72 106.85,50.12 108.03,51.3 108.03,52.26 120.12,64.34 126.93,64.34 127.64,63.63 129.86,63.63 138.57,72.35 138.57,73.62 v1(140.47,75.52)
  BOTTOM w0.076: v1(140.47,75.52) 140.07,75.92 140.07,77.4 141.5,78.83 v2(141.5,79.15) 141.95,79.6 141.95,80.32 141.89,80.39 141.89,80.69 141.89,80.69 142.01,80.94 142.01,80.94 142.01,80.94 142.15,81.08 UC1.BA56
  BOTTOM w0.17: v1(107.25,47.26) 108.74,48.75 110.03,48.75 110.37,49.1 JDIMM1.109
DDR_A_CKE1: length 61.6
  IN1 w0.132: v1(140.46,74.83) 139.93,74.3 139.93,73.12 130.03,63.22 127.47,63.22 126.76,63.93 120.29,63.93 108.44,52.09 108.44,51.13 107.72,50.41 107.72,46.78 v1(108.77,45.73)
  BOTTOM w0.076: v1(140.46,74.83) 140.85,75.22 140.85,75.68 140.23,76.3 140.23,77.33 142.12,79.21 142.12,80.55 UC1.BB56
  BOTTOM w0.17: v1(108.77,45.73) 109.82,44.68 109.82,43.32 110.62,42.52 JDIMM1.110
DDR_A_CKE2: length 5.7
  BOTTOM w0.076: UC1.AW56 142.37,82.32 142.37,82.12 142.42,82.07 142.42,81.76 142.39,81.7 142.39,81.69 142.39,81.42 142.42,81.33 142.42,81.13 142.37,81.02 142.37,80.8 142.42,80.69 142.42,80.39 142.28,80.25 142.28,79 140.93,77.65 T3.1
DDR_A_CKE3: length 5.9
  BOTTOM w0.076: T4.1 139.68,77.25 141.12,78.69 141.12,79.24 141.72,79.84 141.72,80.72 141.74,80.77 141.74,80.77 141.89,81.13 141.89,81.41 142.15,81.68 UC1.AY56
DDR_A_CLK0: length 63.8
  IN1 w0.076: v1(143.52,84) 143.7,83.82 144,83.82 144.16,83.66 144.16,82.94 144.53,82.57 144.53,80.07 145.82,78.78 145.82,78.54 146.47,77.88 146.47,71.59 145.38,70.5 145.38,69.31 145.39,69.3 145.39,69.3
  IN1 w0.091: 145.39,69.3 145.39,65.61 134.68,54.9 123.37,54.9 120.65,52.18 120.65,50.96 118.99,49.3 118.99,48.92 118.8,48.73 118.69,48.73 118.59,48.62 118.59,48.33 118.69,48.23 118.8,48.23 118.99,48.04 118.99,46.47 118.82,46.31 118.63,46.31 v1(118.44,46.11)
  BOTTOM w0.076: v1(143.52,84) 143.87,84.35 UC1.AT53
  BOTTOM w0.102: v1(118.44,46.11) 118.3,46.25 117.64,46.25 117.43,46.46 117.43,47.37 117.62,47.57 117.76,47.57 117.84,47.65 117.84,48 117.76,48.08 117.62,48.08 117.37,48.33 JDIMM1.137
DDR_A_CLK1: length 63.3
  IN1 w0.076: v1(142.56,83.99) 142.82,83.73 142.96,83.73 143.15,83.54 143.15,80.99 145.33,78.81 145.33,71.28 144.71,70.66 144.71,69.36 144.72,69.35 144.72,69.3
  IN1 w0.091: 144.72,69.3 144.72,65.89 134.4,55.57 123.09,55.57 119.95,52.43 119.95,51.4 117.92,49.36 117.92,44.51 118.02,44.41 118.26,44.41 v1(118.44,44.59)
  BOTTOM w0.076: UC1.AT55 142.92,84.35 v1(142.56,83.99)
  BOTTOM w0.102: JDIMM1.138 117.63,42.65 117.73,42.75 117.73,44 117.95,44.23 118.08,44.23 v1(118.44,44.59)
DDR_A_CLK#0: length 63.7
  IN1 w0.076: v1(143.52,83.37) 143.51,83.38 143.51,83.5 143.67,83.66 143.93,83.66 144,83.59 144,82.88 144.37,82.51 144.37,80.01 145.66,78.72 145.66,78.47 146.31,77.82 146.31,71.66 145.22,70.57 145.22,69.32 145.21,69.31 145.21,69.3
  IN1 w0.091: 145.21,69.3 145.21,65.68 134.6,55.07 123.29,55.07 120.47,52.25 120.47,51.03 118.82,49.37 118.82,48.99 118.72,48.9 118.62,48.9 118.41,48.7 118.41,48.26 118.62,48.06 118.72,48.06 118.82,47.96 118.82,46.54 118.75,46.48 118.53,46.48 118.41,46.59 118.41,46.85 v1(118.44,46.87)
  BOTTOM w0.076: UC1.AU53 143.76,83.7 143.52,83.46 v1(143.52,83.37)
  BOTTOM w0.102: JDIMM1.139 117.88,48.96 117.59,48.68 117.59,48.42 117.71,48.29 117.85,48.29 118.06,48.09 118.06,47.56 117.85,47.35 117.71,47.35 117.64,47.28 117.64,46.55 117.73,46.47 118.29,46.47 118.44,46.62 v1(118.44,46.87)
DDR_A_CLK#1: length 63.2
  IN1 w0.076: v1(142.56,83.36) 142.78,83.57 142.89,83.57 143,83.47 143,80.92 145.17,78.75 145.17,71.35 144.55,70.73 144.55,69.36 144.54,69.35 144.54,69.3
  IN1 w0.091: v1(118.44,43.83) 118.44,44.09 118.29,44.24 117.95,44.24 117.74,44.44 117.74,49.44 119.78,51.47 119.78,52.5 123.02,55.74 134.33,55.74 144.54,65.96 144.54,69.3
  BOTTOM w0.076: v1(142.56,83.36) 142.91,83.7 UC1.AU55
  BOTTOM w0.102: JDIMM1.140 118.12,42.65 117.94,42.83 117.94,43.91 118.04,44.01 118.25,44.01 118.32,43.95 v1(118.44,43.83)
DDR_A_CS#0: length 66.8
  IN1 w0.076: v1(147.18,83.35) 147.88,82.64 147.88,81.56 149,80.44 149,77.1 149.23,76.87 149.23,71.26 149.12,71.15 149.12,69.3
  IN1 w0.132: 149.12,69.3 149.12,62.86 148.77,62.52 148.77,62.33 149.06,62.03 149.06,61.85 148.87,61.66 148.69,61.66 148.39,61.95 148.21,61.95 147.93,61.68 147.93,61.44 148.18,61.19 148.18,60.97 148.03,60.81 147.81,60.81 147.55,61.08 147.33,61.08 147.17,60.92 147.17,60.7 147.45,60.42 147.45,60.23 147.27,60.05 147.08,60.05 146.8,60.33 146.58,60.33 146.43,60.17 146.43,59.95 146.71,59.67 146.71,59.49 141.12,53.9 140.15,53.9 138.62,52.37 138.22,52.37 137.41,51.57 137.41,50.85 137.09,50.53 125.49,50.53 123.63,48.67 123.63,46.13 v1(123.24,45.73)
  BOTTOM w0.076: UC1.AU45 148.55,83.35 148.35,83.15 147.37,83.15 v1(147.18,83.35)
  BOTTOM w0.17: v1(123.24,45.73) 122.99,45.73 122.14,46.58 122.14,48.66 122.37,48.89 JDIMM1.149
DDR_A_CS#1: length 69.5
  IN1 w0.076: 151.22,69.3 151.22,69.71 150.76,70.18 150.76,78.57 150.63,78.7 150.63,81.42 149.01,83.04 v1(149.01,83.37)
  IN1 w0.132: v1(126.65,45.73) 126.19,46.19 126.19,48.12 126.5,48.42 132.09,48.42 132.22,48.29 132.22,47.72 132.38,47.57 132.6,47.57 132.75,47.72 132.75,48.29 132.88,48.42 133.15,48.42 133.28,48.29 133.28,47.71 133.43,47.56 133.65,47.56 133.81,47.71 133.81,48.29 133.94,48.42 134.66,48.42 134.79,48.29 134.79,47.68 134.92,47.54 135.19,47.54 135.32,47.68 135.32,48.29 135.45,48.42 135.72,48.42 135.85,48.29 135.85,47.68 135.98,47.54 136.24,47.54 136.38,47.68 136.38,48.29 136.51,48.42 138.62,48.42 140.29,50.1 140.29,51.07 141.02,51.8 141.99,51.8 142.85,52.66 143.87,52.66 146.85,55.63 147.9,55.63 149.07,56.81 149.07,57.86 151.22,60.01 151.22,69.3
  BOTTOM w0.076: UC1.AU43 v1(149.01,83.37)
  BOTTOM w0.17: JDIMM1.157 124.37,48.96 124.83,48.51 125.23,48.51 125.6,48.14 125.6,47.57 126.16,47.01 126.16,46.23 v1(126.65,45.73)
DDR_A_D0: length 75.7
  IN1 w0.084: v1(130.35,86.39) 128.56,88.19 122.57,88.19 111.34,76.95 111.34,76.84 111.59,76.58 111.59,76.46 111.47,76.34 111.35,76.34 111.1,76.6 110.98,76.6 110.86,76.48 110.86,76.36 111.12,76.11 111.12,75.99 111,75.87 110.88,75.87 110.62,76.12 110.51,76.12 110.39,76 110.39,75.89 110.67,75.6 110.67,75.48 110.55,75.36 110.44,75.36 110.15,75.65 110.03,75.65 109.91,75.53 109.91,75.41 110.2,75.12 110.2,75.01 110.08,74.89 109.96,74.89 109.67,75.17 109.56,75.17 109.44,75.06 109.44,74.94 109.72,74.65 109.72,74.53 109.61,74.41 109.49,74.41 109.2,74.7 109.08,74.7 108.96,74.58 108.96,74.46 109.25,74.18 109.25,74.06 109.13,73.94 109.01,73.94 108.73,74.23 108.61,74.23 86.19,51.81 86.19,50.37 84.15,48.32 v1(84.15,48.04)
  BOTTOM w0.076: UC1.AL71 133.42,87.38 133.28,87.38 133.28,87.39 131.95,87.39 131.61,87.04 131,87.04 v1(130.35,86.39)
  BOTTOM w0.102: JDIMM1.7 84.88,48.77 v1(84.15,48.04)

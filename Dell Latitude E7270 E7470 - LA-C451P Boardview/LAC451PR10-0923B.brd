# Allegro board LAC451PR10-0923B.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
EDP_AUXN: length 71.1
  TOP w0.094: v1(93.67,105) 93.47,104.8 93.25,104.8 93.07,104.98 CV1.1
  IN1 w0.084: v1(93.67,105) 95.09,105 99.54,109.44 100.33,109.44 102.38,111.5 110.97,111.5 111.43,111.03 114.21,111.03 117,108.24 125.3,108.24 125.54,108 133.01,108 133.85,108.84 141.68,108.84 143.78,110.94 144.98,110.94 146.07,109.85 146.49,109.85 147.93,108.42 147.93,101.38 147.74,101.19 147.74,100.52 147.84,100.42 147.98,100.42 148.12,100.55 v1(148.12,100.71)
  BOTTOM w0.076: v1(148.12,100.71) 148.55,100.49 UC1.E45
EDP_AUXN_C: length 3.9
  TOP w0.094: v1(91.77,106.5) 91.51,106.23 91.51,106.12 91.65,105.98 92.22,105.98 CV1.2
  BOTTOM w0.094: JEDP1.33 91.71,105.16 91.49,105.12 91.41,105.18 91.39,105.19 91.39,106.12 v1(91.77,106.5)
EDP_AUXP: length 71.1
  TOP w0.094: v1(93.67,104.41) 93.47,104.61 93.18,104.61 92.98,104.81 CV2.1
  IN1 w0.084: v1(148.12,100.07) 147.94,100.25 147.77,100.25 147.57,100.45 147.57,101.26 147.76,101.45 147.76,108.35 146.42,109.69 146,109.69 144.91,110.78 143.85,110.78 141.75,108.68 133.92,108.68 133.08,107.84 125.47,107.84 125.23,108.07 116.94,108.07 114.14,110.86 111.37,110.86 110.9,111.33 102.45,111.33 100.4,109.28 99.61,109.28 95.16,104.83 94.09,104.83 v1(93.67,104.41)
  BOTTOM w0.076: v1(148.12,100.07) UC1.F45
EDP_AUXP_C: length 4
  TOP w0.094: v1(91.19,106.5) 91.32,106.36 91.32,106.04 91.78,105.59 CV2.2
  BOTTOM w0.094: JEDP1.34 91.42,104.75 91.38,104.97 91.29,105.04 91.21,105.12 91.21,106.48 v1(91.19,106.5)
EDP_BIA_PWM: length 96.9
  TOP w0.102: v1(104.59,114.91) 104.59,114.18 104.18,113.76 103.79,113.76 103.48,113.45 v2(103.48,110.59) 102.99,110.1 101.15,110.1 98.86,107.82 97.86,107.82 DV1.3
  IN1 w0.102: v1(150.85,100.1) 150.24,100.71 150.24,107.98 147.02,111.2 147.02,112.25 145.32,113.95 145.32,114.55 144.12,115.76 144.12,116.36 142.2,118.28 140.59,118.28 139.86,117.55 138.6,117.55 138.05,118.1 133.5,118.1 133.2,117.8 128.06,117.8 127.88,117.98 123.78,117.98 123,117.2 122.26,117.2 119.22,114.15 109.66,114.15 108.84,114.97 104.66,114.97 v1(104.59,114.91)
  IN4 w0.076: 158.49,100 158.49,99.88 159.51,98.87 160.93,98.87 161.65,98.14 162.11,98.14 162.76,97.49 162.76,97.02 162.57,96.83 162.57,96.31 162.77,96.11 166.33,96.11 167.09,95.35 167.22,95.35 v1(167.79,94.77) ; 154.32,100.1 152.69,100.1 152.16,99.56 152.16,99.26 151.95,99.06 151.48,99.06 151.28,99.26 151.28,99.67 v1(150.85,100.1)
  IN4 w0.102: 154.32,100.1 154.99,100.1 156,101.11 157.77,101.11 158.49,100.39 158.49,100
  BOTTOM w0.076: v1(167.79,94.77) 168.09,95.08 UC1.R11
EDP_COMP: length 1.6
  TOP w0.508: RC2.2 143.86,100.66 v1(144.44,100.09)
  BOTTOM w0.254: UC1.E52 144.84,100.49 v1(144.44,100.09)
EDP_HPD: length 106.8
  TOP w0.102: v1(169.06,96.78) 169.06,95.87 RC1.2
  IN1 w0.102: v1(91.6,112.43) 92.37,113.19 97.67,113.19 99.87,115.39 104.22,115.39 104.36,115.53 105.58,115.53 105.7,115.41 109.02,115.41 109.84,114.59 119.04,114.59 122.08,117.64 122.82,117.64 123.6,118.42 126.21,118.42 127.2,119.41 133.79,119.41 134.9,118.3 138.17,118.3 138.72,117.75 139.77,117.75 140.5,118.48 142.28,118.48 144.38,116.38 144.38,115.82 145.53,114.67 145.53,114.03 147.21,112.35 147.21,111.29 150.45,108.05 150.45,104.59 v1(150.96,104.09)
  IN4 w0.076: v1(169.06,96.78) 169.06,96.78 168.68,97.16 166.79,97.16 166.57,96.95 165.43,96.95 164.42,97.95 162.8,97.95 162.33,98.42 161.64,98.42 161.01,99.06 159.7,99.06 158.76,100
  IN4 w0.102: 158.76,100 158.7,100.06 158.7,100.75 158.13,101.32 155.74,101.32 154.95,100.53 152.85,100.53 152.14,99.82 151.5,99.82 151.24,100.07 151.24,101.01 150.99,101.27 150.99,102.08 151.18,102.27 151.18,103.87 v1(150.96,104.09)
  BOTTOM w0.076: UC1.L10 v1(169.06,96.78)
  BOTTOM w0.102: JEDP1.26 93.06,108.49 91.22,110.33 91.22,112.05 v1(91.6,112.43)
EDP_TXN0: length 74.5
  TOP w0.094: v1(92.59,102.92) 92.39,103.13 92.1,103.13 91.89,103.34 CV4.1
  IN1 w0.084: v1(146.49,105.56) 146.22,105.84 145.99,105.84 145.82,106.01 145.82,109 144.83,109.99 143.88,109.99 142.01,108.12 134.15,108.12 133.31,107.28 125.24,107.28 125,107.52 116.71,107.52 113.92,110.31 111.04,110.31 110.57,110.78 102.68,110.78 100.29,108.39 99.74,108.39 97.13,105.79 97.13,105.67 97.5,105.31 97.5,105.05 97.22,104.78 96.97,104.78 96.6,105.14 96.49,105.14 96.31,104.96 96.31,104.84 96.97,104.18 96.97,103.87 96.75,103.65 96.44,103.65 95.78,104.31 95.66,104.31 95.48,104.13 95.48,104.02 96.07,103.42 96.07,103.11 95.85,102.89 95.54,102.89 94.95,103.49 94.83,103.49 94.48,103.13 92.8,103.13 v1(92.59,102.92)
  BOTTOM w0.076: UC1.C47 147.39,102.18 147.39,105.22 146.96,105.65 146.58,105.65 v1(146.49,105.56)
EDP_TXN0_C: length 3.5
  TOP w0.094: CV4.2 90.69,104.13 90.28,104.54 90.28,104.94 v1(90.18,105.05)
  BOTTOM w0.094: v1(90.18,105.05) 90.39,104.83 90.39,104.41 90.62,104.18 90.66,104.15 90.71,104.12 90.73,104.01 JEDP1.36
EDP_TXN1: length 76.5
  TOP w0.094: v1(91.52,101.42) 91.33,101.61 91.34,101.61 91.32,101.62 91.06,101.62 90.82,101.86 CV6.1
  IN1 w0.084: v1(148.92,106.34) 148.92,106.48 148.77,106.63 148.57,106.63 148.36,106.84 148.36,108.38 145.36,111.37 143.66,111.37 142.97,110.68 140.66,110.68 139.2,109.23 133.69,109.23 132.85,108.39 125.76,108.39 125.53,108.63 117.27,108.63 113.99,111.91 102.25,111.91 100.2,109.86 97.82,109.86 92.2,104.24 92.2,101.86 91.96,101.62 91.72,101.62 v1(91.52,101.42)
  BOTTOM w0.076: v1(148.92,106.34) 148.72,106.54 148.59,106.54 148.52,106.47 148.52,103.67 148.68,103.52 148.68,103.07 148.64,102.98 148.64,102.79 148.68,102.69 148.68,102.45 148.66,102.4 148.62,102.25 148.6,102.17 148.58,102.12 148.54,101.97 148.54,101.84 148.5,101.76 148.33,101.59 UC1.D46
EDP_TXN1_C: length 4.6
  TOP w0.094: CV6.2 89.61,102.73 89.12,103.21 v1(89.12,104.16)
  BOTTOM w0.094: v1(89.12,104.16) 89.21,104.07 89.21,103.61 89.48,103.35 90.08,103.35 90.14,103.31 90.16,103.19 JEDP1.38
EDP_TXP0: length 74.5
  TOP w0.094: CV3.1 91.98,103.51 92.18,103.31 92.39,103.31 v1(92.59,103.51)
  IN1 w0.084: v1(92.59,103.51) 92.8,103.3 94.41,103.3 94.76,103.65 95.02,103.65 95.61,103.06 95.78,103.06 95.91,103.18 95.91,103.36 95.32,103.95 95.32,104.2 95.59,104.48 95.85,104.48 96.51,103.82 96.68,103.82 96.8,103.94 96.8,104.11 96.14,104.78 96.14,105.03 96.42,105.31 96.67,105.31 97.04,104.94 97.15,104.94 97.33,105.12 97.33,105.24 96.97,105.6 96.97,105.86 99.67,108.56 100.23,108.56 102.61,110.94 110.64,110.94 111.11,110.47 113.98,110.47 116.77,107.68 125.07,107.68 125.31,107.45 133.24,107.45 134.08,108.29 141.95,108.29 143.81,110.16 144.9,110.16 145.99,109.06 145.99,106.08 146.06,106.01 146.29,106.01 v1(146.49,106.21)
  BOTTOM w0.076: v1(146.49,106.21) 146.49,106.13 146.81,105.81 147.03,105.81 147.55,105.29 147.55,102.37 UC1.C46
EDP_TXP0_C: length 3.4
  TOP w0.094: CV3.2 91.13,104.49 90.59,104.49 90.46,104.62 90.46,104.75 v1(90.76,105.05)
  BOTTOM w0.094: JEDP1.35 91.16,104.32 91.16,104.33 90.82,104.27 90.74,104.32 90.57,104.49 90.57,104.86 v1(90.76,105.05)
EDP_TXP1: length 76.5
  TOP w0.094: CV5.1 90.9,102.04 91.14,101.81 91.32,101.81 v1(91.52,102.01)
  IN1 w0.084: v1(91.52,102.01) 91.74,101.79 91.89,101.79 92.03,101.93 92.03,104.31 97.75,110.03 100.13,110.03 102.18,112.07 114.06,112.07 117.34,108.79 125.59,108.79 125.83,108.56 132.78,108.56 133.62,109.4 139.14,109.4 140.59,110.85 142.91,110.85 143.6,111.54 145.43,111.54 148.52,108.45 148.52,106.91 148.63,106.8 148.76,106.8 148.92,106.96 v1(148.92,107.1)
  BOTTOM w0.076: v1(148.92,107.1) 148.92,106.79 148.83,106.7 148.52,106.7 148.36,106.54 148.36,103.6 148.51,103.45 148.51,103.1 148.48,103.01 148.48,102.76 148.51,102.66 148.51,102.47 148.45,102.29 148.38,102.22 148.08,102.22 148.01,102.15 148.01,102.02 148.12,101.91 UC1.C45
EDP_TXP1_C: length 4.6
  TOP w0.094: v1(89.71,104.16) 89.31,103.76 89.31,103.29 89.52,103.07 90.1,103.07 CV5.2
  BOTTOM w0.094: v1(89.71,104.16) 89.4,103.85 89.4,103.69 89.55,103.53 90.14,103.53 90.24,103.46 90.24,103.46 90.56,103.52 JEDP1.37
EDRAM_OPIO_RCOMP: length 1.3
  TOP w0.381: v1(135.9,98.79) 135.8,98.69 RC90.1
  BOTTOM w0.254: UC1.H66 136.09,98.6 v1(135.9,98.79)
EMMC_RCOMP: length 2.6
  TOP w0.381: RC4.1 175.24,84.53 v1(175.23,84.52)
  BOTTOM w0.203: v1(175.23,84.52) 175.17,84.45 UC1.AT1
EN_1.0V_PRIM_COREP: length 5.5
  TOP w0.102: v2(246.3,95.6) 245.91,95.21 PR406.2
  TOP w0.254: PR406.2 PR407.1 PC411.1 243.49,94.71 243.18,94.4 242.7,94.4 242.45,94.14 PU402.13
EN_1.8VALW: length 1.2
  TOP w0.102: v2(284.87,6.42) 285.25,6.8 PR504.2
EN_1VS_VCCIO: length 4.6
  TOP w0.254: PC402.1 PR403.1 PR402.2 241.3,44.08 240.79,43.57 v2(240.48,43.57) 240.34,43.57 239.55,44.36 PU401.13
EN_+1VALWP: length 6.4
  TOP w0.254: PU301.1 228.1,84.46 228.32,84.68 228.32,86.15 v2(229.38,87.22) 229.72,87.55 PR312.1 230.58,88.16 PR302.1 PR301.1
EN_DK_PWRBAR: length 2.8
  TOP w0.254: PU901.17 92.17,70.64 92.56,71.03 PR934.1 PR901.1
EN_DOCK_PWR_BAR: length 168.3
  TOP w0.102: UE1.B37 v1(229.24,69.98)
  TOP w0.254: PR901.2 v1(94.9,71.92)
  IN2 w0.102: v1(229.24,69.98) 228.96,69.69 222.2,69.69 221.43,68.92 221.43,66.28 210.78,55.62 88.97,55.62 v1(88.36,56.23)
  IN4 w0.102: v1(94.9,71.92) 94.51,71.52 94.51,67.8 90.62,63.92 90.62,59.77 88.36,57.51 v1(88.36,56.23)
EN_I2S_NB_CODEC#: length 70.9
  TOP w0.102: v1(229.82,69.43) 229.82,69.99 229.33,70.48 UE1.B36 ; v2(285.37,74.42) 285.06,74.11 v1(285.06,74) 285.34,73.72 285.34,72.55 285.65,72.24 UA1.1
  IN3 w0.102: v1(276.69,67.26) 275.7,66.26 264.28,66.26 262.61,67.94 259.37,67.94 258.95,68.36 256.6,68.36 256.36,68.12 252.25,68.12 251.25,69.12 251.08,69.12 249.28,69.12 248.21,70.19 247.18,70.19 246.78,69.79 244.15,69.79 243.29,70.65 241.67,70.65 240.33,69.31 239.1,69.31 238.84,69.58 236.43,69.58 235.11,68.26 230.52,68.26 229.82,68.96 v1(229.82,69.43)
  BOTTOM w0.102: v1(276.69,67.26) 277.16,67.73 277.16,73.25 277.91,74 v1(285.06,74)
EN_INVPWR: length 289.2
  TOP w0.102: RE55.2 255.14,59.77 254.85,59.77 v1(254.38,60.25) 254.76,60.62 254.76,61.02 254.62,61.16 UE2.A25 ; v1(84.03,110.71) 84.41,111.09 v2(84.41,111.87) QV2.2
  IN1 w0.102: v1(68.17,48.36) 68.54,48.73 68.54,49.67 66.99,51.23 62.68,51.23 61.39,52.52 61.39,59.16 60.83,59.72 60.83,65.02 v1(61.66,65.85)
  IN2 w0.102: v1(68.17,48.36) 68.51,48.7 69.28,48.7 71.18,50.59 72.41,50.59 73.36,51.55 75.72,51.55 76.59,50.67 81.16,50.67 84.07,53.58 85.8,53.58 86.21,53.98 215.51,53.98 223.81,62.28 223.81,66.21 v1(224.41,66.81)
  IN4 w0.102: v1(61.66,65.85) 62.05,66.24 62.05,68.98 68.08,75.01 68.08,77.49 75.74,85.15 75.74,94.62 84.81,103.69 84.81,109.93 v1(84.03,110.71) ; v1(254.38,60.25) 253.07,61.56 250.93,61.56 250.48,61.11 250.48,60.51 248.85,58.88 246.36,58.88 245.48,59.76 237.74,59.76 237.11,59.14 236.7,59.14 236.23,59.61 232.78,59.61 232.45,59.94 232.45,60.42 231.8,61.07 227.79,61.07 223.83,65.02 223.83,66.24 v1(224.41,66.81)
EN_LCDPWR: length 6.7
  TOP w0.102: DV3.1 RV3.2 83.84,110.37 v2(84.01,110.21) 84.53,109.69 84.53,108.09 85,107.62 85,106.18 UV24.4
ENLDO_3V5V: length 16.7
  TOP w0.102: v1(206.99,84.9) v2(207.41,85.31)
  IN1 w0.254: v1(215.31,84.18) 214.96,84.18 214.41,84.73 207.16,84.73 v1(206.99,84.9)
  BOTTOM w0.254: v1(206.99,84.9) 206.99,85.42 207.12,85.54 PU102.11 ; PU100.11 215.48,85.2 215.35,85.07 215.35,84.22 v1(215.31,84.18) 214.34,83.21 214.34,82.18 214.17,82.01 214.17,80.73 PR103.1 214.34,79.7 PR102.1
ENVDD_PCH: length 220
  TOP w0.102: v1(196.97,91.17) 197.13,91.17 v2(197.41,91.45) ; v1(84.06,108.72) 83.68,108.34 DV3.3 ; v1(248.24,67.79) UE2.A7
  IN1 w0.076: 178.5,88.31 178.1,87.91 178.1,87.23 177.63,86.76 174.27,86.76 173.97,87.05 173.97,87.59 172.68,88.88 169.07,88.88 168.12,89.84 167.65,89.84 166.86,90.62 166.86,91.8 167.18,92.12 167.56,92.12 167.8,92.36 v1(167.8,92.66) 166.85,93.6 162.84,93.6 162.2,92.96 161.17,92.96 160.22,93.91 159.85,93.91 159.29,94.47 159.29,95.47 158.06,96.69 157.41,96.69 157.1,97.01 157.1,97.3 156.7,97.69 156.7,98.23 156.51,98.42 150.99,98.42 150.29,99.12 150.29,99.99 149.83,100.45 149.83,102.37
  IN1 w0.102: v1(196.97,91.17) 196.52,91.17 195.97,90.62 194.2,90.62 193.84,90.25 188.12,90.25 187.18,89.32 184.99,89.32 184.24,88.57 178.76,88.57 178.5,88.31 ; v1(84.06,108.72) 94.67,108.72 97.28,111.32 98.26,111.32 99.36,112.43 100.36,112.43 102.05,114.12 104.7,114.12 105.14,114.56 108.67,114.56 109.49,113.75 119.39,113.75 122.43,116.79 123.17,116.79 123.94,117.57 127.72,117.57 127.89,117.39 133.41,117.39 133.84,116.96 139.85,116.96 140.76,117.87 142.03,117.87 143.67,116.23 143.67,115.63 144.92,114.38 144.92,113.78 146.64,112.06 146.64,111 149.83,107.81 149.83,102.37
  IN3 w0.102: v1(196.97,91.17) 196.97,89.28 197.58,88.67 197.58,85.63 198.02,85.19 198.02,82.23 197.42,81.62 197.42,80.07 198.18,79.31 198.18,77.29 203.63,71.84 208.36,71.84 208.95,71.26 209.66,71.26 212.25,68.66 213.64,68.66 215.91,66.39 220.99,66.39 221.99,67.39 225.61,67.39 225.88,67.13 227.62,67.13 227.87,66.87 230.49,66.87 231.06,67.45 235.45,67.45 236.76,68.77 238.5,68.77 239.25,68.02 243.09,68.02 243.27,68.19 247.83,68.19 v1(248.24,67.79)
  BOTTOM w0.076: v1(167.8,92.66) 167.76,92.69 167.76,93.19 UC1.U13
EOPIO_RCOMP: length 2.6
  TOP w0.381: v1(136.92,98.79) 135.93,97.8 RC91.1
  BOTTOM w0.254: UC1.H65 137.11,98.6 v1(136.92,98.79)
ERC1: length 2.3
  TOP w0.254: PU901.3 87.69,65.21 87.22,64.74 PC908.1
ERC2: length 1.8
  TOP w0.254: PC901.1 93.34,68.64 PU901.13
ERC3: length 3.4
  TOP w0.102: v2(93.38,66.18) PC907.1
  TOP w0.254: PU901.12 92.71,68.14 PC907.1
FAN1_PWM: length 271.2
  TOP w0.102: UE2.A24 254.12,61.07 v1(254.38,60.82) 253.92,60.36 253.92,60.11 RE48.2 ; v1(69.05,48.1) 69.05,48.09 68.72,47.76 v2(68.72,46.6)
  IN1 w0.102: v1(69.05,48.1) 68.74,48.4 68.74,49.82 67.13,51.43 62.77,51.43 61.59,52.61 61.59,59.24 61.03,59.8 61.03,64.28 63.08,66.33 v1(64.81,66.33)
  IN2 w0.102: v1(69.05,48.1) 69.11,48.1 71.4,50.39 72.49,50.39 73.44,51.34 75.63,51.34 76.51,50.47 81.25,50.47 84.16,53.37 85.89,53.37 86.29,53.78 215.59,53.78 224.01,62.2 224.01,65.85 v1(224.42,66.25)
  IN4 w0.102: v1(224.42,66.25) 224.04,65.87 224.04,65.11 227.87,61.27 232.98,61.27 233.27,60.98 233.27,60.11 233.56,59.81 236.47,59.81 237.02,60.36 238.01,60.36 238.35,60.02 245.51,60.02 246.44,59.09 248.77,59.09 249.48,59.8 249.48,60.96 250.28,61.76 253.44,61.76 v1(254.38,60.82)
  BOTTOM w0.102: v1(64.81,66.33) 64.81,72.8 74.5,82.49 74.5,91.49 77,93.99 78.06,93.99 78.33,94.26 78.33,95.93 78.47,96.07 JFAN1.2
FAN1_TACH: length 270.5
  TOP w0.102: v1(251.53,59.47) 251.68,59.32 251.68,57.42 251.85,57.25 252.45,57.25 RE51.2 ; v1(251.87,63.66) 252.37,63.16 UE2.B22
  IN1 w0.102: v1(69.12,49.08) 69.12,49.72 67.21,51.63 62.85,51.63 61.8,52.69 61.8,59.33 61.24,59.89 61.24,64.2 62.92,65.88 v1(64.42,65.88)
  IN2 w0.102: v1(69.12,49.08) 69.12,49.34 71.54,51.75 75.8,51.75 76.68,50.87 81.08,50.87 83.99,53.78 85.63,53.78 86.04,54.19 215.43,54.19 223.61,62.37 223.61,66.61 v1(223.63,66.63)
  IN4 w0.102: v1(223.63,66.63) 223.63,64.94 228.24,60.32 229.28,60.32 230.2,59.41 236.13,59.41 236.62,58.91 237.17,58.91 237.82,59.56 245.4,59.56 246.28,58.68 247.79,58.68 248.09,58.38 249.54,58.38 250.73,59.57 251.43,59.57 v1(251.53,59.47)
  BOTTOM w0.102: JFAN1.3 78.78,94.85 78.53,94.61 78.53,94.18 78.14,93.79 77.08,93.79 74.7,91.4 74.7,82.4 65.2,72.9 65.2,66.15 64.93,65.88 v1(64.42,65.88) ; v1(251.53,59.47) 251.99,59.93 252.44,59.93 252.64,60.14 252.64,62.3 252.38,62.56 252.38,63.15 v1(251.87,63.66)
FB_1.8VALW: length 1.2
  TOP w0.102: PR506.1 295.3,6.69 v2(295.54,6.93)
FB_+1VALWP: length 4.6
  TOP w0.254: PU301.4 228.39,83.11 v2(228.79,83.52) 229.14,83.87 229.14,84.36 229.35,84.57 PR311.1 PR308.2 230.6,85.49 PR306.2
FB_IA: length 6.1
  TOP w0.102: v2(93.19,86.8) 93.09,86.9 v1(92.67,86.9)
  TOP w0.203: PU602.17 90.69,88.45 90.98,88.16 91.35,88.16 PR648.2 92.66,87.71 PR645.2 v1(92.67,86.9)
  BOTTOM w0.254: PR650.1 92.96,86.05 92.67,86.34 v1(92.67,86.9)
FB_VSA: length 5.4
  TOP w0.102: PR652.1 90.28,92.6 v2(90.52,92.85)
  TOP w0.203: PU602.25 87.32,90.87 87.35,90.9 87.35,91.39 87.3,91.44 87.3,91.75 87.79,92.25 87.79,92.6 PR649.1
  TOP w0.254: PR652.1 PR646.1 88.67,92.62 PR649.1
FCCM_GT: length 7.8
  TOP w0.203: 90.39,85.37 90.02,85.75 90.02,85.95 89.91,86.05 PU602.11
  TOP w0.254: v1(94.68,81.95) 94.68,82.32 v2(92.57,84.42) 91.62,85.37 90.39,85.37
  BOTTOM w0.254: PR671.2 v1(94.68,81.95)
FCCM_IA: length 31.1
  TOP w0.102: v1(109.18,105.43) v2(109.18,105.95)
  TOP w0.203: PU602.21 88.92,90.76 89.06,90.9 v1(89.32,90.9)
  IN2 w0.254: v1(89.32,90.9) 90.46,90.9 94.9,95.35 99.35,95.35 101.25,97.25 105.37,97.25 106.65,98.53 106.65,104.05 108.03,105.43 v1(109.18,105.43)
  BOTTOM w0.254: PR659.2 v1(109.18,105.43)
FCCM_VSA: length 61.9
  TOP w0.203: 85.64,91.05 85.72,90.97 PU602.29
  TOP w0.254: 85.64,91.05 85.43,91.25 85.43,91.51 84.88,92.06 84.29,92.06 82.67,93.67 82.67,94.25 83.51,95.09 93.24,95.09 v2(97,98.85) 98.88,100.73 98.88,106.94 101.2,109.25 105.89,109.25 111.11,114.47 119.11,114.47 119.63,114.99 122.16,114.99 122.74,115.58 125.72,115.58 PR679.2
FIVR_EN: length 3
  TOP w0.102: v2(124.43,131.52) RC217.1 RC219.2 123.15,130.81 RC218.2
FIVR_EN_R: length 11.7
  TOP w0.102: RC126.2 122.77,126.65 v2(123.73,127.62) 124.43,128.32 RC217.2 RC132.2 125.32,128.99 v1(125.89,128.42)
  BOTTOM w0.102: JXDP1.45 129.39,127.76 128.73,128.42 v1(125.89,128.42)
FWP#: length 24.5
  TOP w0.102: RE81.2 RE82.2 241.12,80.6 239.89,79.37 239.89,76.59 240.74,75.73 v2(240.74,75.43) 240.74,74.81 v1(240.66,74.74) ; UE2.B65 251.87,70.9 v1(252.37,70.4)
  IN3 w0.102: v1(240.66,74.74) 242.57,72.83 245.03,72.83 245.6,73.4 247.38,73.4 248.27,72.51 250.9,72.51 251.94,71.48 251.94,70.84 252.37,70.4 v1(252.37,70.4)
GPIO_PSID_SELECT: length 277.6
  TOP w0.102: v1(72.49,90.27) v2(72.98,90.27) ; UE1.A6 239.43,65.73 v1(239.93,66.23)
  TOP w0.254: PU1.6 v1(74.38,114.57)
  IN1 w0.102: v1(69.12,47.47) 68.68,47.91 66.46,47.91 66.18,48.19 66.18,48.8 65.94,49.04 63.14,49.04 59,53.19 59,58.16 57.43,59.74 57.43,60.47 57.88,60.93 57.88,61.57 v1(57.76,61.69)
  IN2 w0.102: v1(78.36,50.03) 78.84,49.55 81.05,49.55 83,51.51 83.47,51.51 83.61,51.37 83.61,50.82 83.82,50.62 86.39,50.62 88.94,53.17 215.85,53.17 225.08,62.4 225.08,64.83 225.94,65.69 v1(225.94,66.23)
  IN4 w0.102: v1(69.12,47.47) 70.41,46.19 73.75,46.19 76.95,49.39 77.89,49.39 78.36,49.86 v1(78.36,50.03) ; v1(74.38,114.57) 74.75,114.21 77.85,114.21 79.49,112.57 79.49,105.71 78.67,104.9 75.94,104.9 72.4,101.36 72.4,94.71 72.88,94.23 72.88,90.66 v1(72.49,90.27) ; v1(239.93,66.23) 239.44,65.74 239.13,65.74 238.77,65.38 235.91,65.38 235.43,65.86 228.84,65.86 228.47,66.23 v1(225.94,66.23)
  BOTTOM w0.102: v1(72.49,90.27) 73.73,89.02 73.73,82.8 57.76,66.83 v1(57.76,61.69)
GPIOD4: length 1.2
  TOP w0.102: v1(237.11,69.96) 237.12,69.98 UE1.B15
  BOTTOM w0.102: T97.1 236.92,69.77 v1(237.11,69.96)
GPIOD5: length 1.7
  TOP w0.102: UE1.A15 239.47,70.23 239.72,70.48 T99.1
GPIOE2: length 1.5
  TOP w0.102: UE1.A2 240.05,63.73 T98.1
GPP_B23: length 12.5
  BOTTOM w0.076: UC1.AM7 170.79,87.24 171.53,87.24 172.04,86.73 172.28,86.73 172.46,86.55 172.46,86.33 172.62,86.18 172.93,86.18 173.08,86.33 173.08,86.55 173.24,86.71 177.53,86.71 177.87,87.05 177.87,87.26 178.51,87.89
  BOTTOM w0.102: 178.51,87.89 178.51,87.9 QC3.3 178.51,88.96 RC326.1 RC327.2
GPP_B23_Q: length 5.2
  BOTTOM w0.102: QC3.1 180.41,89.1 RC327.1 181.3,89.23 181.3,88.9 v2(181.48,88.72) 181.8,88.4 183.07,88.4 RC317.1
GPP_C5: length 3.8
  TOP w0.102: v1(177.07,93.25) 176.96,93.14 RC25.1
  BOTTOM w0.076: UC1.W1 174.17,93.17 v2(176.53,93.17) 176.99,93.17 v1(177.07,93.25)
GPP_E23: length 1.1
  TOP w0.254: T120.1 166.82,96.17 v1(167.15,95.84)
  BOTTOM w0.254: UC1.N12 v1(167.15,95.84)
GPU_B+: length 0.9
  TOP w0.102: v1(97.32,89.51) 97.32,89.89 v3(96.94,90.27)
  vias: v1(90.41,78.2) v1(90.41,77.62) v1(90.41,77.03) v1(90.99,78.79) v1(90.99,78.2) v1(90.99,77.62) v1(90.99,77.03) v1(96.68,89.51) v1(96.68,88.87) v1(97.32,88.87) v1(97.95,89.51) v1(97.95,88.87) v1(98.59,88.87)
GPU_SMBCLK: length 15.4
  TOP w0.102: UE2.B49 258.25,70.04 v1(257.75,69.54) ; RPE3.4 246.59,70.58 246.72,70.46 247.05,70.46 247.16,70.58 247.16,70.73 v1(246.99,70.91)
  IN4 w0.084: v1(246.99,70.91) 247.18,70.72 247.18,70.49 247.39,70.28 249.22,70.28 250.06,71.12 250.56,71.12 250.8,70.88 250.8,70.31 251.35,69.76 257.52,69.76 v1(257.75,69.54)
GPU_SMBDAT: length 15.3
  TOP w0.102: RPE3.3 246.56,70.08 246.71,70.23 247.14,70.23 247.39,70.48 247.39,70.73 v1(247.57,70.91) ; UE2.B48 v1(258.33,69.54)
  IN4 w0.084: v1(258.33,69.54) 257.9,69.97 251.44,69.97 251.01,70.4 251.01,70.96 250.64,71.33 249.97,71.33 249.13,70.49 247.48,70.49 247.39,70.58 247.39,70.73 v1(247.57,70.91)
GT1N: length 6.7
  TOP w0.254: v1(104.58,80.44) v2(104.07,80.95) 102.38,80.95 102.21,80.77 100.98,80.77 PR673.1
  BOTTOM w0.254: PL604.2 v1(104.58,80.44)
GT1P: length 6.6
  TOP w0.254: v1(103.36,80.44) 103.31,80.39 v2(102.42,80.39) 100.02,80.39 PR674.2
  BOTTOM w0.254: PL604.3 v1(103.36,80.44)
GT_SNUB1: length 1.8
  TOP w0.102: PR676.2 v2(97.97,77.11)
GT_SW1:
  vias: v1(100.28,77.63) v1(100.86,77.63) v2(96.97,79.12)
H_CATERR#: length 7.9
  BOTTOM w0.076: UC1.D63 138.55,101.59 138.63,101.85 138.63,101.97 138.71,102.25 138.75,102.4 138.77,102.45 138.77,102.69 138.73,102.79 138.73,102.98 138.77,103.07 138.77,103.44 138.61,103.59 138.61,104.85 v2(138.45,105.01) 138.29,105.18 138.29,106.58 137.68,107.19 137.68,107.77 138.02,108.11 RC79.2
H_CPU_SVIDALRT#: length 12.7
  BOTTOM w0.076: UC1.B63 138.1,102.56 138.01,102.65 138.01,104.19 137.79,104.4 137.79,104.89 137.72,104.96 137.21,104.96 137.13,105.04 137.13,105.19 137.21,105.27 137.69,105.27 137.78,105.36 137.78,105.5 137.69,105.59 136.76,105.59 136.69,105.67 136.69,105.82 136.76,105.89 v2(137.27,105.89) 137.64,105.89 137.74,106 137.74,106.41 137.58,106.57 137.42,106.57 137.32,106.47 137.32,106.34 137.22,106.24 136.4,106.24 136.31,106.33 136.31,106.49 136.67,106.85 136.67,106.96 136.58,107.05 136.46,107.05 136.13,106.71 136,106.71 135.91,106.8 135.91,106.93 136.14,107.16 136.14,107.25 136.07,107.32 135.98,107.32 135.88,107.22 135.76,107.22 135.7,107.29 135.7,107.54 RC153.1
H_CPUPWRGD: length 15
  TOP w0.102: v3(129.44,102.65) 129.65,102.43 v1(129.93,102.43)
  BOTTOM w0.076: UC1.A68 135.1,103.21 134.54,103.77 131.27,103.77 v1(129.93,102.43) 129.6,102.1
  BOTTOM w0.102: 129.6,102.1 129.47,101.97 129.47,100.71 128.86,100.1 125.61,100.1 CC300.1 RC77.2
H_CPUPWRGD_R: length 0.9
  BOTTOM w0.102: RC77.1 T9.1
H_PROCHOT#: length 317.3
  TOP w0.102: PR818.1 v2(54.65,61.5) 54.65,61.74 56.58,63.67 63.45,63.67 v1(63.92,63.2) ; v1(79.18,86.39) 79.36,86.57 PC605.2 PR678.1 ; RE288.2 229.61,39.98 v1(229.37,40.22)
  IN1 w0.084: v1(140.08,39.2) 140.08,39.4 141.28,40.61 146.59,40.61 148.75,42.77 148.75,43.3 148.92,43.47 151.51,43.47 151.79,43.74 153.85,43.74 154.57,44.46 159.27,44.46 161.96,41.77 173.46,41.77 174.04,41.19 228.4,41.19 v1(229.37,40.22) ; v1(130.15,109.52) 129.88,109.26 117.57,109.26 114.29,112.54 101.98,112.54 99.98,110.54 97.6,110.54 90.98,103.91 90.98,101.3 v1(91.74,100.54) 91.74,99.64 88.53,96.42 82.18,96.42 78.34,92.58 78.34,86.8 78.74,86.39 v1(79.18,86.39) 79.18,85.84 69.81,76.46 69.81,74.18 65.58,69.95 65.58,66.49 66.24,65.82 66.24,64.31 65.53,63.6 64.3,63.6 63.92,63.22 v1(63.92,63.2)
  IN4 w0.084: v1(140.08,39.2) 117.09,39.2 116.35,39.94 116.35,74.75 117.09,75.48 117.09,76.64 115.1,78.64 115.1,86.92 114.09,87.92 109.51,87.92 107.03,90.4 107.03,93.29 104.38,95.94 99.99,95.94 95.39,100.54 v1(91.74,100.54)
  BOTTOM w0.102: RC84.1 RC83.2 128.2,108.85 CC310.1 128.85,109.52 v1(130.15,109.52)
H_PROCHOT#_R: length 11.4
  BOTTOM w0.076: UC1.C65 137.02,102.22 136.94,102.47 136.94,102.65 137,102.84 137,102.99 136.94,103.1 136.94,103.37 137.13,103.56 137.13,104.1 136.02,105.21 136.02,105.67 135.4,106.29 132.4,106.29 v2(131.8,106.89) 131.44,107.25 130.66,107.25 129.98,107.92
  BOTTOM w0.102: RC84.2 129.98,107.92
H_PROCHOT#_R1: length 65.4
  TOP w0.102: RE288.1 230.84,39.91 v1(230.84,40.21) ; v1(264.07,69.63) v2(263.32,69.63) 261.48,69.63 261.32,69.79 UE2.A46
  IN1 w0.084: v1(230.84,40.21) 231.29,40.66 232.41,40.66 234.28,42.53 239.38,42.53 239.64,42.27 243.92,42.27 243.92,42.26 254.96,42.26 258.1,45.41 260.64,45.41 261.48,46.25 261.48,47.95 262.3,48.78 263.03,48.78 264.7,50.45 264.7,50.47 v1(264.69,50.48)
  IN2 w0.122: v1(264.07,69.63) 264.54,69.16 264.54,67.47 264.15,67.08 264.15,65.61 263.38,64.84 263.38,62.23 264.44,61.17 264.44,60.51 264.8,60.15 264.8,57.45 265.29,56.96 265.29,56.06 264.99,55.76 264.99,55.17 264.57,54.74 264.57,53.47 264.72,53.32 264.72,50.62 264.69,50.59 v1(264.69,50.48)
H_THERMTRIP#: length 264.1
  TOP w0.102: QE4.3 259.99,57.07 v1(260.35,56.71) ; RD4.2 195.7,39 v2(195.02,39) v1(194.36,39) ; v1(118.05,40.1) 117.82,39.87 117.14,39.87 116.76,40.25 RD61.2
  IN1 w0.076: 134,97.77 134,97.53 131.79,95.33 129.57,95.33
  IN1 w0.084: v1(265.85,45.57) 265.85,44.88 259.59,38.62 240.38,38.62 238.49,40.51 235.43,40.51 233.48,38.56 194.79,38.56 v1(194.36,39) 194.28,39.07 166.61,39.07 165.66,40.03 161.26,40.03 158.57,42.72 155.27,42.72 153.78,41.23 v1(151.64,41.23) ; v1(115.5,82.38) 124.8,91.68 124.8,93.45 126.68,95.33 129.57,95.33 ; 134,97.77 134,98.71 135.48,100.2 135.48,101.44 137.41,103.37 137.41,106.96 v1(137.04,107.32)
  IN4 w0.084: v1(151.64,41.23) 151.05,40.64 136.87,40.64 136.1,39.87 118.28,39.87 v1(118.05,40.1) 118.05,40.52 117.48,41.09 117.48,76.8 115.5,78.78 v1(115.5,82.38)
  BOTTOM w0.076: UC1.C63 138.52,102.22 138.6,102.47 138.6,102.65 138.54,102.84 138.54,102.99 138.6,103.1 138.6,103.37 138.38,103.59 138.38,104.64 138.12,104.9 138.12,106.51 137.31,107.32 v1(137.04,107.32) 137.04,107.64 137.07,107.67 CC312.1 RC80.2
  BOTTOM w0.102: v1(265.85,45.57) 265.68,45.75 265.68,48.53 264.11,50.09 264.11,50.51 262.6,52.03 262.6,55.5 261.38,56.71 v1(260.35,56.71)
H_VCCST_PWRGD: length 349.9
  TOP w0.102: RE308.1 v1(261.8,68.59) ; UE4.4 247.74,82.02 247.83,82.12 247.83,82.26 v1(247.51,82.58)
  IN1 w0.084: v1(247.51,82.58) 248.38,81.71 249.13,81.71 249.97,82.55 252.83,82.55 256.15,79.23 256.15,78.56 257,77.71 257,76.77 258.06,75.71 259.14,75.71 260.04,74.8 260.04,73.82 v1(260.33,73.53) ; v1(132.56,109.77) 131.91,109.12 131.1,109.12 130.3,109.93 129.99,109.93 129.71,109.64 117.73,109.64 114.45,112.93 v1(110.86,112.93) 101.82,112.93 99.82,110.93 97.44,110.93 90.59,104.08 90.59,101.12 v1(91.17,100.54) ; v1(259.27,40.25) 259.27,39.66 258.94,39.33 253.63,39.33 252.93,40.03 247.47,40.03 246.57,40.93 243.59,40.93 242.84,40.17 239.37,40.17 238.65,40.9 235.27,40.9 233.32,38.95 195.04,38.95 194.53,39.46 166.77,39.46 165.82,40.42 161.42,40.42 158.72,43.12 155.12,43.12 154.05,42.05 v1(152.07,42.05)
  IN2 w0.122: v1(261.8,68.59) 261.8,68.48 261.43,68.12 261.16,68.12 260.19,67.15 260.19,65.1 262.15,63.14 262.15,61.82 262.7,61.27 262.7,59.59 263.37,58.92 263.37,55.24 263.46,55.14 263.46,52.34 261.69,50.57 261.69,41.7 260.25,40.25 v1(259.27,40.25)
  IN4 w0.084: v1(152.07,42.05) 151.64,41.61 151.43,41.61 150.85,41.03 122.7,41.03 121.18,42.56 121.18,49.58 118.93,51.82 118.93,75.9 115.89,78.94 115.89,86.91 114.49,88.31 109.67,88.31 107.42,90.56 107.42,93.45 104.54,96.33 100.15,96.33 95.55,100.93 91.56,100.93 v1(91.17,100.54) ; v1(113.08,123.48) 113.08,122.96 110.86,120.73 v1(110.86,112.93) ; v1(260.33,73.53) 261.55,72.31 261.55,70.85 262.32,70.08 262.32,69.37 261.8,68.84 v1(261.8,68.59)
  BOTTOM w0.076: 131.93,109.14 131.75,108.96 RC78.1 131.75,108.82 RC71.2
  BOTTOM w0.102: 131.93,109.14 v1(132.56,109.77) 133.26,110.47 CC301.1 ; RC123.1 v1(113.08,123.48)
H_VCCST_PWRGD_XDP: length 21.6
  BOTTOM w0.102: CC307.1 RC124.2 RC123.2 112.06,122.94 v2(113.46,122.94) 114.78,122.94 115.55,122.18 124.93,122.18 127.89,125.13 JXDP1.39
HDA_BIT_CLK: length 12.9
  TOP w0.102: RC93.2 164.82,70.84 164.82,71.61 v1(164.29,72.14)
  BOTTOM w0.076: UC1.AY22 161.91,81.73 161.8,81.62 161.71,81.5 161.64,81.3 161.64,81.18 161.7,80.95 161.7,80.81 161.64,80.69 161.64,80.17 161.98,79.83 161.98,78.78 v2(162.28,78.48) 162.28,77.45 162.79,76.94 162.79,76.79
  BOTTOM w0.102: 162.79,76.79 162.79,75.2 163.52,74.47 163.52,72.9 v1(164.29,72.14)
HDA_BIT_CLK_R: length 142.4
  TOP w0.102: RC93.1 CC27.1 165.83,69.14 v2(165.83,67.86) 165.83,66.9 167.13,65.6 174.25,65.6 v1(174.65,65.21) ; UA1.6 284.99,70.24 284.9,70.33 RA17.1 283.13,69.88 282.52,69.88 v1(282.32,69.68)
  IN1 w0.084: v1(174.65,65.21) 175.08,65.64 175.67,65.64 176.02,65.29 176.99,65.29 177.98,64.31 177.98,63.03 185.6,55.4 186.83,55.4 188.36,53.88 232.92,53.88 233.06,53.74 242.84,53.74 243.23,53.35 245.21,53.35 245.92,52.65 255.66,52.65 256.07,53.05 267.22,53.05 270.14,55.96 273.3,55.96 v1(273.36,55.9)
  IN4 w0.084: v1(273.36,55.9) 274.1,56.64 274.1,58.1 274.66,58.66 274.66,63.64 281.07,70.05 281.95,70.05 v1(282.32,69.68)
HDA_RST#: length 15.3
  TOP w0.102: RC95.2 163.3,69.5 163.3,70.14 v2(163.5,70.33) 163.5,70.49 164.29,71.27 v1(164.29,71.49)
  BOTTOM w0.076: UC1.AW22 161.91,82.43 161.73,82.26 161.73,82.26 161.52,81.56 161.52,81.47 161.46,81.32 161.46,81.17 161.53,80.95 161.53,80.84 161.49,80.76 161.48,80.73 161.48,80.1 161.79,79.79 161.79,79.34
  BOTTOM w0.102: 161.79,79.34 161.79,77.37 162.41,76.75 162.41,74.89 163.07,74.23 163.07,72.71 v1(164.29,71.49)
HDA_RST#_R: length 143.1
  TOP w0.102: RC95.1 166.09,64.96 v2(166.52,64.96) 173.24,64.96 v1(173.48,65.2) ; v1(285.34,66.7) 285.4,66.76 285.4,68.04 285.6,68.24 UA1.11
  IN1 w0.084: v1(275.35,55.92) 275.05,55.62 274.28,55.62 273.8,55.14 273.8,54.66 273.5,54.36 272.88,54.36 272.01,55.24 270.37,55.24 267.5,52.38 256.35,52.38 255.94,51.97 245.64,51.97 244.93,52.68 242.95,52.68 242.56,53.06 232.78,53.06 232.64,53.2 188.08,53.2 186.55,54.73 185.32,54.73 177.3,62.75 177.3,64.03 176.74,64.59 174.09,64.59 v1(173.48,65.2)
  IN4 w0.084: v1(275.35,55.92) 275.35,58.09 276.72,59.46 276.72,63.87 278.01,65.16 283.38,65.16 284.91,66.7 v1(285.34,66.7)
HDA_SDIN0: length 150.8
  TOP w0.102: v1(281.95,68.74) 283.04,68.74 RA9.1
  IN1 w0.084: v1(164.33,76.63) 164.93,76.63 166.28,75.28 166.28,74.05 168.25,72.09 168.25,69.46 171.56,66.15 175.82,66.15 176.21,65.76 177.18,65.76 178.46,64.48 178.46,63.2 185.8,55.87 187.03,55.87 188.55,54.34 229.27,54.34 229.92,54.99 239.43,54.99 240.22,54.2 243.04,54.2 243.31,53.93 246.96,53.93 247.78,53.11 255.47,53.11 255.87,53.52 257.48,53.52 258.14,54.17 261.5,54.17 261.96,54.64 263.31,54.64 264.4,53.54 267.05,53.54 269.95,56.43 274.14,56.43 v1(274.57,56)
  IN4 w0.084: v1(274.57,56) 274.57,57.91 276.3,59.64 276.3,64.62 281.27,69.58 281.58,69.58 281.95,69.22 v1(281.95,68.74)
  BOTTOM w0.076: 163.19,78.67 163.19,79 162.85,79.34 162.85,80.01 162.51,80.35 162.51,81.53 UC1.BA21
  BOTTOM w0.102: 163.19,78.67 163.71,78.15 163.71,77.24 v1(164.33,76.63)
HDA_SDIN0_R: length 2
  TOP w0.102: RA9.2 284.65,69.44 UA1.8
HDA_SDOUT: length 15.7
  TOP w0.102: RC187.2 161.09,69.09 RC94.2 RC223.2 162.13,69.08 162.69,69.64 162.69,70.19 162.7,70.19 162.7,70.57 163.52,71.39 v2(163.52,71.81) 163.52,72.74 CC311.1 163.57,72.79 v1(164.29,72.79)
  BOTTOM w0.076: 163.19,76.79 163.19,76.88 163.19,77.07 162.6,77.67 162.6,78.9 162.34,79.15 162.34,79.94 161.91,80.37 UC1.BB22
  BOTTOM w0.102: 163.19,76.79 163.19,75.42 163.91,74.7 163.91,73.17 v1(164.29,72.79)
HDA_SDOUT_R: length 147.4
  TOP w0.102: RC94.1 v2(163.68,65.59) 165.4,63.88 172.72,63.88 v1(174.05,65.21) ; UA1.5 285.3,70.64 283.7,72.23 283.06,72.23 v1(282.91,72.09)
  IN1 w0.084: v1(273.36,55.32) 273.19,55.32 273.01,55.49 270.32,55.49 267.42,52.59 256.26,52.59 255.85,52.18 245.73,52.18 245.02,52.89 243.04,52.89 242.65,53.27 232.87,53.27 232.73,53.41 188.17,53.41 186.64,54.94 185.41,54.94 177.51,62.84 177.51,64.11 176.8,64.83 174.27,64.83 174.05,65.05 v1(174.05,65.21)
  IN4 w0.084: v1(273.36,55.32) 272.99,55.69 272.99,56.19 273.62,56.81 273.62,58.27 274.19,58.85 274.19,63.83 281.66,71.29 282.12,71.29 v1(282.91,72.09)
HDA_SYNC: length 12.5
  TOP w0.102: v1(164.29,74.09) 164.69,73.69 164.69,72.89 165.81,71.78 165.81,71.24 166.27,70.79 RC92.2
  BOTTOM w0.076: UC1.BA22 161.91,81.03 162.18,80.76 162.18,80.34 162.51,80.01 162.51,79.22 162.77,78.95 162.77,77.9 v2(163.21,77.47) 163.42,77.26 163.42,76.79
  BOTTOM w0.102: 163.42,76.79 163.42,75.65 164.29,74.78 v1(164.29,74.09)
HDA_SYNC_R: length 141.8
  TOP w0.102: UA1.10 285.68,68.64 285.02,67.98 v1(285.02,67.22) ; RC92.1 166.31,69.54 166.31,67.15 v2(166.71,66.75) 167.37,66.09 174.5,66.09 175.04,65.54 175.04,64.74 175.63,64.16 v1(176.64,64.16)
  IN1 w0.084: v1(274.56,55.23) 274.06,54.73 274.06,54.63 273.56,54.12 272.83,54.12 271.92,55.03 270.46,55.03 267.59,52.17 256.43,52.17 256.03,51.76 245.55,51.76 244.85,52.47 242.86,52.47 242.48,52.85 232.69,52.85 232.55,52.99 187.91,52.99 186.39,54.52 185.24,54.52 176.64,63.11 v1(176.64,64.16)
  IN4 w0.084: v1(274.56,55.23) 274.97,55.64 274.97,58.01 276.51,59.55 276.51,63.96 277.92,65.37 283.18,65.37 v1(285.02,67.22)
HDMI_CEC: length 20.5
  TOP w0.102: v1(253.32,132.25) 252.98,132.6 249.38,132.6 246.42,129.64 v2(245.65,129.64) 243.37,129.64 240.38,132.62 238.55,132.62 JHDMI1.13
  BOTTOM w0.102: v1(253.32,132.25) 252.35,131.28 RV8.1
HDMI_CLKN: length 2.9
  TOP w0.094: RV658.1 236.75,127.7 LV12.2 236.75,127.37 236.57,127.19 236.57,127.02 v1(236.78,126.81)
  BOTTOM w0.094: RV17.1 236.6,127.12 236.6,126.98 v1(236.78,126.81) 237.08,126.5 CV14.1
HDMI_CLKP: length 2.8
  TOP w0.094: v1(236.19,126.81) 236.38,127 236.38,127.19 236.2,127.37 LV12.1 236.03,127.85 RV656.1
  BOTTOM w0.094: RV16.1 236.42,127.19 236.42,127.03 v1(236.19,126.81) CV13.1
HDMI_CTRL_CLK: length 13.5
  IN1 w0.084: JHDMI1.15 239.4,132.77 240.63,132.77 241.08,132.33 241.08,128.24 239.63,126.8 239.1,126.8 238.89,127.01 238.89,127.42 v1(238.81,127.5)
  BOTTOM w0.102: QV3.6 238.93,126.8 239.35,126.37 239.49,126.37 239.62,126.5 239.62,126.69 v1(238.81,127.5) 238.81,127.9 RV21.1
HDMI_CTRL_DATA: length 14.6
  IN1 w0.084: JHDMI1.16 238.72,132.45 238.72,132.61 238.91,132.8 239.07,132.8 239.31,132.56 240.55,132.56 240.87,132.24 240.87,128.33 239.54,127.01 239.19,127.01 239.1,127.09 239.1,127.23 v1(239.37,127.49)
  BOTTOM w0.102: RV18.1 239.49,127.62 v1(239.37,127.49) 239.37,127.27 239.85,126.79 239.85,125.73 240.08,125.5 QV3.3 v2(240.44,124.38)
HDMI_HPD: length 11.8
  BOTTOM w0.102: JHDMI1.19 240.8,132.46 242.82,130.44 244.36,130.44 246.47,132.55 v2(246.72,132.55) 247.36,132.55 247.56,132.34 QV5.1 247.56,130.74 247.42,130.6 RV20.1
HDMI_L_CLKN: length 3.9
  TOP w0.094: JHDMI1.12 236.89,131.46 236.89,130.93 236.53,130.57 236.53,130.3 RV657.1 236.55,129.58 236.55,129.42 236.75,129.22 LV12.3 236.75,128.91 RV658.2
HDMI_L_CLKP: length 3.9
  TOP w0.094: RV656.2 236.03,128.76 LV12.4 236.2,129.27 236.37,129.45 236.37,129.55 RV657.2 236.35,130.29 236.35,130.65 236.71,131 236.71,131.46 JHDMI1.10
HDMI_L_TX_N0: length 9.2
  TOP w0.094: RV655.2 231.35,128.9 LV9.3 231.35,129.16 231.13,129.38 231.13,129.57 RV654.1 231.01,130.38 231.01,131.04 v1(231.19,131.21)
  IN4 w0.084: v1(231.19,131.21) 230.99,131.42 230.99,131.66 231.8,132.47 235.18,132.47 235.4,132.69 235.4,132.97 JHDMI1.9
HDMI_L_TX_N1: length 4.2
  TOP w0.094: RV652.2 234.94,128.9 LV6.3 234.94,129.2 234.7,129.44 234.7,129.54 RV651.1 234.72,130.3 234.72,130.65 234.36,131.01 234.11,131.01 233.89,131.23 233.89,131.46 JHDMI1.6
HDMI_L_TX_N2: length 6.3
  TOP w0.094: RV649.2 233.14,128.9 LV3.3 233.14,129.22 232.92,129.43 232.92,129.54 RV648.1 232.92,130.31 232.92,130.82 232.6,131.14 232.14,131.14 231.72,131.56 231.72,132.1 232.39,132.77 232.39,132.96 JHDMI1.3
HDMI_L_TX_P0: length 9.2
  TOP w0.094: v1(230.6,131.21) 230.83,130.99 230.83,130.18 RV654.2 230.95,129.53 230.95,129.38 230.81,129.24 230.81,128.92 LV9.4 230.64,128.76 RV653.2
  IN4 w0.084: v1(230.6,131.21) 230.61,131.21 230.82,131.42 230.82,131.73 231.73,132.63 235.11,132.63 235.24,132.76 235.24,132.93 JHDMI1.7
HDMI_L_TX_P1: length 4.2
  TOP w0.094: RV650.2 234.22,128.76 LV6.4 234.39,129.27 234.52,129.4 234.52,129.59 RV651.2 234.54,130.28 234.54,130.58 234.29,130.83 234.03,130.83 233.71,131.15 233.71,131.46 JHDMI1.4
HDMI_L_TX_P2: length 6.3
  TOP w0.094: RV647.2 232.42,128.76 LV3.4 232.59,129.29 232.74,129.43 232.74,129.58 RV648.2 232.74,130.28 232.74,130.74 232.52,130.96 232.06,130.96 231.54,131.48 231.54,132.18 232.21,132.85 232.21,132.96 JHDMI1.1
HDMI_OB: length 9.4
  TOP w0.102: v2(237.45,126.73) 237.64,126.92 v1(237.64,127.48) 237.64,127.88 237.93,128.18 QV4.1
  BOTTOM w0.102: RV14.2 RV15.2 RV10.2 RV11.2 RV12.2 RV13.2 RV16.2 RV17.2 237.64,127.77 v1(237.64,127.48)
HDMI_TX_N0: length 2.9
  TOP w0.094: v1(231.47,126.81) 231.2,127.07 231.2,127.16 231.35,127.31 LV9.2 231.35,127.7 RV655.1
  BOTTOM w0.094: RV15.1 231.27,127.12 231.27,127 v1(231.47,126.81) 231.75,126.53 CV29.1
HDMI_TX_N1: length 2.9
  TOP w0.094: RV652.1 234.94,127.72 LV6.2 234.94,127.32 234.81,127.19 234.81,127.02 v1(235.02,126.81)
  BOTTOM w0.094: RV13.1 234.84,127.13 234.84,126.99 v1(235.02,126.81) 235.3,126.53 CV22.1
HDMI_TX_N2: length 2.9
  TOP w0.094: v1(233.23,126.81) 233.01,127.03 233.01,127.22 233.14,127.35 LV3.2 233.14,127.7 RV649.1
  BOTTOM w0.094: RV11.1 233.05,127.12 233.05,126.99 v1(233.23,126.81) 233.53,126.51 CV18.1
HDMI_TX_P0: length 2.8
  TOP w0.094: v1(230.86,126.81) 231.02,126.97 231.02,127.12 230.93,127.21 230.88,127.21 230.78,127.3 230.78,127.65 LV9.1 230.62,127.84 RV653.1
  BOTTOM w0.094: CV28.1 v1(230.86,126.81) 231.09,127.03 231.09,127.19 RV14.1
HDMI_TX_P1: length 2.9
  TOP w0.094: v1(234.41,126.81) 234.62,127.02 234.62,127.14 234.55,127.22 234.48,127.22 234.39,127.31 LV6.1 234.23,127.84 RV650.1
  BOTTOM w0.094: RV12.1 234.66,127.17 234.66,127.05 v1(234.41,126.81) CV21.1
HDMI_TX_P2: length 2.8
  TOP w0.094: RV647.1 232.43,127.84 LV3.1 232.59,127.36 232.83,127.12 232.83,127 v1(232.64,126.81)
  BOTTOM w0.094: RV10.1 232.86,127.19 232.86,127.03 v1(232.64,126.81) CV17.1
HOST_DEBUG_TX: length 89.2
  TOP w0.102: JDEG1.8 279.58,8.37 RE73.2 280.17,8.96 281.06,8.96 283.18,6.84 v1(283.18,6.73) ; v1(268.85,56.1) 268.85,55.25 v2(268.97,55.13) ; UE2.B44 258.39,67.54 v1(258.27,67.67)
  IN1 w0.102: v1(283.18,6.73) 285.02,8.57 285.02,9.72 284.87,9.87 284.87,11.71 286.94,13.78 286.94,15.57 286.09,16.42 286.09,17.59 277.58,26.1 277.58,26.27 v1(276.92,26.93)
  BOTTOM w0.102: v1(258.27,67.67) 257.76,67.16 257.6,67.16 257.31,66.86 257.31,65.27 257.53,65.05 258.5,65.05 259.82,63.72 261.48,63.72 263.55,61.66 263.55,60.68 264.91,59.32 266.6,59.32 268.85,57.06 v1(268.85,56.1) 269.82,56.1 270.96,54.96 271.32,54.6 271.32,53.59 272.01,52.9 275.65,52.9 276.5,52.05 276.5,27.36 v1(276.92,26.93)
HOST_SD_WP#: length 133.9
  IN2 w0.102: v1(177.65,91.78) 177.49,91.63 177.49,90.34 178.61,89.23 183.65,89.23 183.97,89.54 184.77,89.54 185.09,89.23 185.84,89.23 187.02,88.05 187.02,85.1 188.63,83.49 188.63,81.04 190.03,79.64 191.64,79.64 193.88,77.4 193.88,76.06 192.1,74.28 190.17,74.28 189.63,73.74 189.63,71.44 190.82,70.25 205.65,70.25 206.43,69.48 v1(208.03,69.48)
  IN3 w0.102: v1(268.01,60.94) 267.71,60.65 264.65,60.65 264.29,61.01 263.07,61.01 262.27,60.21 262.27,57.29 261.66,56.68 260.92,56.68 260.3,56.05 258.65,56.05 258.35,56.35 256.49,56.35 255.55,55.41 251.64,55.41 250.94,56.1 249.65,56.1 248.32,57.44 246.11,57.44 245.71,57.03 242.56,57.03 242.27,57.32 240.63,57.32 238.88,59.07 237.89,59.07 237.75,58.92 236.64,58.92 236.03,59.54 232.09,59.54 231.43,60.2 231.43,61.1 230.64,61.9 224.62,61.9 221.83,64.68 217.91,64.68 217.23,65.36 215.5,65.36 213.87,67 209.59,67 208.03,68.56 v1(208.03,69.48)
  BOTTOM w0.076: UC1.AB3 173.07,92.05 174.42,92.05 174.77,91.69 177.56,91.69 v1(177.65,91.78) 177.92,92.06 177.92,92.2 RC292.2
  BOTTOM w0.102: v1(268.01,60.94) 268.22,60.73 QR1.2
HUB_DP0_AUXN: length 27.3
  TOP w0.089: UV8.A11 213.36,119.15 213.27,119.24 212.88,119.24 212.87,119.23 ; v1(211.3,118.78) 211.04,119.03 211,119.03
  TOP w0.094: 211,119.03 210.67,119.03 210.38,119.31 210.38,121.14 RV85.1 ; 211.48,118.96 v1(211.3,118.78)
  TOP w0.102: 211.48,118.96 212.43,118.96 212.58,119.11 212.75,119.11 212.87,119.23
  IN1 w0.084: v1(194.99,117.83) 194.62,117.46 194.62,116.9 194.9,116.62 198.01,116.62 199.02,115.6 208.79,115.6 211.72,118.54 211.72,118.85 211.63,118.94 211.46,118.94 v1(211.3,118.78)
  BOTTOM w0.094: v1(194.99,117.83) 195.18,118.02 CV123.2
HUB_DP0_AUXN_C: length 1.7
  BOTTOM w0.094: UV12.5 196.53,118.03 CV123.1
HUB_DP0_AUXP: length 27
  TOP w0.089: UV8.B11 213.64,119.42 212.81,119.42 212.8,119.42 212.76,119.38 212.75,119.38 212.74,119.37 ; 211,119.22 211.15,119.22 v1(211.3,119.36)
  TOP w0.094: RV74.1 210.57,121.14 210.57,119.39 210.74,119.22 211,119.22 ; 211.5,119.15 v1(211.3,119.36)
  TOP w0.102: 212.74,119.37 212.67,119.3 212.5,119.3 212.35,119.15 211.5,119.15
  IN1 w0.084: v1(194.93,116.11) 194.93,116.32 195.07,116.45 197.94,116.45 198.96,115.44 208.85,115.44 211.88,118.47 211.88,118.92 211.69,119.11 211.55,119.11 v1(211.3,119.36)
  BOTTOM w0.094: CV122.2 v1(194.93,116.11)
HUB_DP0_AUXP_C: length 1.7
  BOTTOM w0.094: UV12.2 196.55,116.08 CV122.1
HUB_DP0_CADET: length 98.7
  TOP w0.089: UV8.A14 213.36,121.17 v1(212.84,121.7)
  TOP w0.102: v1(205.42,118.68) v2(205.42,119.22)
  IN1 w0.102: v1(199.63,117.75) 199.32,117.45 199.32,116.34 v1(199.6,116.06) 199.62,116.08 204.4,116.08 205.42,117.1 v1(205.42,118.68)
  BOTTOM w0.102: v1(199.6,116.06) 199.6,115.77 199.27,115.43 UV12.1 196.73,115.43 RV509.2 196.07,114.77 193.11,114.77 191.65,116.23 178.74,116.23 173.09,121.88 172.32,121.88 170.65,123.55 162.95,123.55 161.48,125.03 157.96,125.03 157.56,124.62 145.14,124.62 143.78,123.26 140.01,123.26 139.89,123.14 136.99,123.14 135,125.13 JDOCK1.5 ; v1(205.42,118.68) 205.7,118.68 205.82,118.8 QV10.2 206.28,119.35 206.88,119.95 209.65,119.95 211.8,122.09 212.44,122.09 v1(212.84,121.7) ; UV12.4 199.26,117.38 v1(199.63,117.75)
HUB_DP0_CADETN: length 8.1
  BOTTOM w0.102: QV10.1 206.47,117.18 RV91.2 205.38,116.08 UV12.13 ; QV10.1 205.89,118.03 UV12.10 ; QV10.1 207.49,118.46 v2(208.37,118.46)
HUB_DP0_HPD: length 86.2
  TOP w0.089: 211,114.88 212.57,114.88 213.36,115.67 UV8.A6
  TOP w0.102: 211,114.88 208.54,114.88 v2(208.22,114.56) 207.91,114.25 v1(207.91,113.72)
  IN1 w0.102: v1(207.91,113.72) 207.27,113.09 204.96,113.09 204.25,113.81 192.31,113.81 185.75,120.37 185.75,123.54 184.76,124.52 171.53,124.52 168.81,127.24 v1(168.78,127.24)
  BOTTOM w0.102: v1(168.78,127.24) 168.78,125.75 166.78,123.76 163.04,123.76 161.56,125.23 157.88,125.23 157.47,124.82 147.29,124.82 C310.1 R268.1 143.5,127.73 JDOCK1.39
HUB_DP0_N0: length 91.4
  TOP w0.094: UV8.A7 213.27,116.35 213.26,116.35 212.81,115.9 212.72,115.81 212.47,115.56 197.83,115.56 196.66,116.73 191.26,116.73 187.04,120.95 187.04,121.71 184.46,124.29 182.19,124.29 182,124.48 179.88,124.48 179.13,125.23 179.13,126.74 v1(179.34,126.95)
  IN4 w0.084: v1(137.75,123.6) 137.71,123.6 137.34,123.97 137.34,124.32 139.26,126.24 144.13,126.24 150.04,132.15 171.14,132.15 176.97,126.32 178.89,126.32 179.11,126.53 179.11,126.71 v1(179.34,126.95)
  BOTTOM w0.094: C295.2 137.68,124.63 137.54,124.63 137.44,124.53 137.44,123.92 v1(137.75,123.6)
HUB_DP0_N0_C: length 0.9
  BOTTOM w0.094: R252.1 C295.1
HUB_DP0_N0_R: length 4.1
  BOTTOM w0.094: R252.2 137.54,127.46 137.54,128.01 v5(137.08,128.47) 136.34,129.21 136.34,129.37 136.5,129.53 JDOCK1.11
HUB_DP0_N1: length 89.6
  TOP w0.094: v1(180.5,126.95) 180.29,126.74 180.29,125.94 180.91,125.32 181.98,125.32 182.35,124.96 185.37,124.96 189.43,120.9 189.43,119.53 191.56,117.41 196.91,117.41 197.59,116.73 200.29,116.73 200.79,116.23 208.16,116.23 208.44,116.5 212.49,116.5 212.94,116.95 213.22,116.95 UV8.A8
  IN4 w0.084: v1(180.5,126.95) 180.49,126.95 180.29,126.74 180.29,126.17 179.88,125.76 176.74,125.76 170.91,131.59 150.86,131.59 144.95,125.69 140.42,125.69 139.13,124.4 139.13,123.97 139.5,123.6 v1(139.55,123.6)
  BOTTOM w0.094: C299.2 139.43,124.66 139.33,124.66 139.21,124.54 139.21,123.93 v1(139.55,123.6)
HUB_DP0_N1_C: length 0.9
  BOTTOM w0.094: R255.1 C299.1
HUB_DP0_N1_R: length 4.2
  BOTTOM w0.094: JDOCK1.17 138,129.61 137.93,129.54 137.93,129.47 138.09,129.31 138.09,129.14 v5(138.61,128.62) 139.32,127.91 139.32,127.46 R255.2
HUB_DP0_N2: length 86.4
  TOP w0.094: v1(181.64,126.95) 181.44,126.75 181.44,126.16 181.7,125.91 182.23,125.91 182.44,125.69 185.66,125.69 188.21,123.14 188.62,123.14 190.35,121.4 190.9,121.4 192.68,119.62 196.28,119.62 198.55,117.34 208.18,117.34 208.42,117.59 213.21,117.59 UV8.A9
  IN4 w0.084: v1(141.31,123.76) 141.26,123.76 140.89,124.13 140.89,124.46 141.57,125.14 145.45,125.14 148.18,127.87 153.22,127.87 154.75,129.4 156.7,129.4 157.43,128.67 159.13,128.67 161.02,130.57 171.15,130.57 176.52,125.21 180.71,125.21 181.43,125.93 181.43,126.74 v1(181.64,126.95)
  BOTTOM w0.094: C306.2 141.2,124.67 141.07,124.67 140.99,124.6 140.99,124.07 v1(141.31,123.76)
HUB_DP0_N2_C: length 0.9
  BOTTOM w0.094: R263.1 C306.1
HUB_DP0_N2_R: length 4.7
  BOTTOM w0.094: JDOCK1.23 139.5,129.53 139.34,129.37 139.34,129.02 139.75,128.61 v5(140.04,128.61) 140.33,128.61 141.1,127.84 141.1,127.46 R263.2
HUB_DP0_N3: length 84.2
  TOP w0.094: UV8.A10 213.31,118.35 208.2,118.35 207.92,118.07 200.75,118.07 200.17,118.66 v5(199.46,118.66) 198.75,118.66 197.16,120.25 193.14,120.25 191.75,121.64 191.75,123.14 188.57,126.32 182.81,126.32 182.63,126.5 182.63,126.77 v1(182.81,126.95)
  IN4 w0.084: v1(182.81,126.95) 182.48,126.62 182.48,125.97 181.16,124.65 176.29,124.65 170.95,129.99 161.26,129.99 158.56,127.3 148.39,127.3 145.68,124.58 142.84,124.58 142.67,124.41 142.67,124.13 143.04,123.76 v1(143.09,123.76)
  BOTTOM w0.094: C301.2 142.97,124.67 142.85,124.67 142.77,124.6 142.77,124.07 v1(143.09,123.76)
HUB_DP0_N3_C: length 0.9
  BOTTOM w0.094: R266.1 C301.1
HUB_DP0_N3_R: length 5.1
  BOTTOM w0.094: JDOCK1.29 141,129.56 140.84,129.4 140.84,129.03 141.47,128.4 141.68,128.4 141.72,128.43 142.3,128.43 142.34,128.4 142.51,128.4 142.89,128.02 142.89,127.45 R266.2
HUB_DP0_P0: length 91.5
  TOP w0.094: v1(178.76,126.95) 178.95,126.75 178.95,125.15 179.8,124.3 181.93,124.3 182.12,124.11 184.38,124.11 186.86,121.63 186.86,120.88 191.18,116.55 196.58,116.55 197.75,115.38 212.55,115.38 212.94,115.77 213.33,116.17 213.48,116.17 213.76,116.44 UV8.B7
  IN4 w0.084: v1(137.17,123.6) 137.17,124.39 139.19,126.41 144.07,126.41 149.97,132.31 171.21,132.31 177.03,126.49 178.83,126.49 178.94,126.6 178.94,126.76 v1(178.76,126.95)
  BOTTOM w0.094: C302.2 137.25,124.17 137.25,123.68 v1(137.17,123.6)
HUB_DP0_P0_C: length 0.9
  BOTTOM w0.094: R259.1 C302.1
HUB_DP0_P0_R: length 4.2
  BOTTOM w0.094: JDOCK1.9 136,129.53 136.16,129.37 136.16,129.13 136.72,128.57 136.72,128.52 137.14,128.1 137.19,128.1 137.32,127.97 137.36,127.93 137.36,127.46 R259.2
HUB_DP0_P1: length 89.7
  TOP w0.094: UV8.B8 213.68,116.76 213.01,116.76 212.57,116.32 208.51,116.32 208.24,116.04 200.72,116.04 200.22,116.54 197.52,116.54 196.84,117.22 191.48,117.22 189.25,119.46 189.25,120.82 185.3,124.77 182.28,124.77 181.91,125.14 180.83,125.14 180.1,125.87 180.1,126.75 v1(179.91,126.95)
  IN4 w0.084: v1(179.91,126.95) 179.92,126.95 180.12,126.74 180.12,126.24 179.81,125.93 176.81,125.93 170.98,131.76 150.79,131.76 144.88,125.86 140.35,125.86 138.96,124.47 v1(138.96,123.6)
  BOTTOM w0.094: C297.2 139.03,124.17 139.03,123.67 v1(138.96,123.6)
HUB_DP0_P1_C: length 0.9
  BOTTOM w0.094: R253.1 C297.1
HUB_DP0_P1_R: length 4.3
  BOTTOM w0.094: JDOCK1.15 137.5,129.64 137.91,129.23 137.91,129.07 138.25,128.72 138.25,128.67 138.67,128.26 138.72,128.26 139.14,127.84 139.14,127.46 R253.2
HUB_DP0_P2: length 86.4
  TOP w0.094: UV8.B9 213.68,117.41 208.5,117.41 208.25,117.16 198.48,117.16 196.2,119.43 192.61,119.43 190.82,121.22 190.28,121.22 188.54,122.96 188.14,122.96 185.58,125.51 182.36,125.51 182.15,125.72 181.62,125.72 181.26,126.09 181.26,126.74 v1(181.06,126.95)
  IN4 w0.084: v1(181.06,126.95) 181.26,126.74 181.26,126 180.64,125.37 176.58,125.37 171.22,130.73 160.95,130.73 159.06,128.84 157.5,128.84 156.77,129.56 154.68,129.56 153.15,128.04 148.12,128.04 145.38,125.3 141.5,125.3 140.73,124.53 v1(140.73,123.76)
  BOTTOM w0.094: C304.2 140.81,124.17 140.81,123.84 v1(140.73,123.76)
HUB_DP0_P2_C: length 0.9
  BOTTOM w0.094: R257.1 C304.1
HUB_DP0_P2_R: length 4.7
  BOTTOM w0.094: R257.2 140.91,127.46 140.91,127.77 140.29,128.39 139.71,128.39 139.16,128.94 139.16,129.37 139,129.53 JDOCK1.21
HUB_DP0_P3: length 84.2
  TOP w0.094: v1(182.22,126.95) 182.45,126.72 182.45,126.42 182.73,126.14 188.49,126.14 191.56,123.07 191.56,121.57 193.06,120.07 197.08,120.07 198.68,118.47 199.13,118.47 199.17,118.44 199.76,118.44 199.79,118.47 200.09,118.47 200.68,117.89 208,117.89 208.27,118.16 212.98,118.16 213.05,118.09 213.71,118.09 UV8.B10
  IN4 w0.084: v1(182.22,126.95) 182.32,126.85 182.32,126.04 181.09,124.81 176.36,124.81 171.01,130.16 161.19,130.16 158.5,127.46 148.32,127.46 145.61,124.75 142.77,124.75 142.5,124.48 v1(142.5,123.76)
  BOTTOM w0.094: v1(142.5,123.76) 142.59,123.84 142.59,124.17 C300.2
HUB_DP0_P3_C: length 0.9
  BOTTOM w0.094: R265.1 C300.1
HUB_DP0_P3_R: length 5.1
  BOTTOM w0.094: JDOCK1.27 140.5,129.56 140.66,129.4 140.66,128.95 141.39,128.22 v5(142.01,128.22) 142.44,128.22 142.7,127.95 142.7,127.47 R265.2
HUB_DP0_SCL: length 31.9
  TOP w0.089: v1(212.26,121.08) 212.57,121.08 213.03,120.61 213.03,120.28 213.31,120.01 213.7,120.01 UV8.B12
  IN1 w0.084: v1(212.7,110.24) 212.89,110.44 213.12,110.44 213.34,110.66 213.34,111.39 212.33,112.4 212.33,115.1 211.62,115.81 211.62,117.08 212.63,118.09 212.63,120.5 212.26,120.87 v1(212.26,121.08) 212.12,120.94 203.45,120.94 201.56,119.06 201.56,117.59 201.97,117.18 202.47,117.18 202.75,116.9 v1(202.75,116.73)
  BOTTOM w0.102: UV12.12 v1(202.75,116.73) ; RPV2.3 212.62,110.17 v1(212.7,110.24)
HUB_DP0_SDA: length 31.7
  TOP w0.089: v1(212.06,120.54) 212.06,120.33 212.19,120.21 212.36,120.21 212.48,120.33 212.48,120.59 212.56,120.66 212.73,120.66 212.86,120.54 212.86,120.21 213.36,119.7 UV8.A12
  IN1 w0.084: v1(212.73,110.82) 212.9,110.65 213.03,110.65 213.13,110.75 213.13,111.31 212.12,112.32 212.12,115.01 211.41,115.72 211.41,117.17 212.42,118.18 212.42,120.41 212.29,120.54 v1(212.06,120.54) 211.87,120.73 203.54,120.73 201.78,118.97 201.78,117.67 202.05,117.39 202.51,117.39 202.76,117.64 v1(202.76,118.68)
  BOTTOM w0.102: UV12.9 v1(202.76,118.68) ; RPV2.4 213.12,110.43 v1(212.73,110.82)
HUB_DP1_AUXN: length 40.4
  TOP w0.094: UV8.J14 218.56,120.84 218.69,120.72 218.76,120.72 218.92,120.88 218.92,121.13 218.66,121.39 218.66,121.83 218.41,122.07 218.41,123.01 RV82.1 218.41,123.67 218.41,124.9 217.79,125.52 215.97,125.52 213.8,127.69 201.76,127.69 200.21,126.13 193.01,126.13 192.83,126.32 192.83,126.6 v1(193.03,126.81)
  BOTTOM w0.094: v1(193.03,126.81) 192.83,126.6 192.83,123.68 193.71,122.81 195.51,122.81 195.6,122.9 CV120.2

# Allegro board LAC451PR10-0923B.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
SIO_EXT_SMI#: length 127.7
  TOP w0.102: UE2.A6 248.15,68.29 v1(247.65,67.79) ; RC346.2 179.97,113.46 179.97,111.17 179.54,110.75 v1(179.54,109.99) 179.54,109.53 175.08,105.06 v2(172.7,105.06) 171.94,105.06 v1(171.1,104.22)
  IN2 w0.102: v1(239.9,67.58) 238.95,68.53 238.95,71.41 239.42,71.88 239.42,74.32 238.9,74.84 238.9,78.08 239.42,78.6 239.42,83.88 238.62,84.68 236.56,84.68 234.75,86.49 234.75,93.51 237.71,96.47 237.71,99.12 234.04,102.79 230.5,102.79 230.12,102.41 216.01,102.41 215.15,103.27 200.04,103.27 198.4,101.62 v1(198.4,101.56)
  IN4 w0.102: v1(247.65,67.79) 246.3,67.79 245.82,67.31 243.51,67.31 243.02,67.79 240.11,67.79 v1(239.9,67.58)
  BOTTOM w0.076: v1(171.1,104.22) 171.22,104.11 UC1.A6
  BOTTOM w0.102: v1(179.54,109.99) 183.74,109.99 190.18,103.55 194.93,103.55 196.18,102.3 197.97,102.3 198.4,101.88 v1(198.4,101.56)
SIO_EXT_WAKE#: length 107.4
  TOP w0.102: v1(192.94,86.74) 192.81,86.88 RC283.2 194.69,87.92 194.89,87.71 198.55,87.71 v1(198.79,87.47) ; v1(251,69.54) 251,69.37 250.68,69.04 UE2.B5
  IN3 w0.102: v1(251,69.54) 251,70.15 250.76,70.39 250.76,70.96 249.62,72.11 248.1,72.11 247.21,73 246.33,73 244.54,71.2 242.21,71.2 241.45,71.97 230.04,71.97 229.24,72.77 228.33,72.77 226.4,70.84 225.52,70.84 224.66,69.97 223.41,69.97 220.07,73.31 219.5,73.31 218.08,74.74 209.37,74.74 209.24,74.86 205.81,74.86 205.11,75.56 201.63,75.56 199.73,77.46 199.73,79.04 200.35,79.65 200.35,80.83 199.04,82.14 199.04,86.16 199.22,86.33 199.22,87.04 v1(198.79,87.47) ; v1(192.94,86.74) 193.5,87.31 193.88,87.31 195.03,88.46 195.03,90.09 193.71,91.41 186.15,91.41 184.8,90.05 183.09,90.05 182.74,89.7 178.95,89.7 178.41,90.24 176.17,90.24 v1(176.03,90.1)
  BOTTOM w0.076: v1(176.03,90.1) 173.29,90.1 172.97,90.42 UC1.AD3
SIO_PWRBTN#: length 369.4
  TOP w0.102: UE2.B58 v1(255.37,70.98)
  IN1 w0.084: v1(258.06,55.09) 257.77,54.8 253.79,54.8 252.79,55.8 247.78,55.8 247.66,55.69 245.13,55.69 244.98,55.84 241.59,55.84 240.6,56.83 238.33,56.83 237.81,56.31 188.61,56.31 187.73,57.19 186.34,57.19 180.96,62.57 180.96,66.04 179.85,67.15 176.68,67.15 176.18,67.66 172.85,67.66 171.19,69.32 171.19,69.9 169.68,71.41 169.68,74.05 v1(169.2,74.53)
  IN2 w0.122: v1(65.73,58.02) 66.01,58.02 66.54,58.55 71.1,58.55 71.46,58.19 71.85,58.19 72.58,57.46 74.36,57.46 74.88,57.98 77.02,57.98 77.23,57.77 79.49,57.77 85.21,63.5 91.49,63.5 92.49,64.5 99.54,64.5 100.03,64.01 164.79,64.01 168.92,68.13 168.92,74.24 v1(169.2,74.53) ; v1(258.06,55.09) 258.39,55.09 258.66,55.36 258.66,56.08 257.95,56.79 257.95,58.21 256.23,59.93 256.23,61.79 255.88,62.14 255.88,64.12 255.79,64.22 255.79,70.69 255.5,70.98 v1(255.37,70.98)
  IN4 w0.084: v1(65.73,58.02) 65.69,57.98 63.83,57.98 63.52,58.29 63.52,59.17 63.26,59.42 62.63,59.42 62.23,59.82 62.23,61.05 60.93,62.35 60.93,68.79 67.19,75.05 67.19,77.43 75.16,85.39 75.16,94.94 81.76,101.55 81.76,118.94 83.14,120.32 88.38,120.32 90.07,122.01 107.08,122.01 107.88,122.82 110.42,122.82 v1(110.82,122.42)
  BOTTOM w0.076: UC1.BA15 165.26,80.97 165.26,79.25 166.08,78.44 166.08,77.87 166.48,77.47 166.69,77.47 168.66,75.5 168.66,75.07 v1(169.2,74.53)
  BOTTOM w0.102: JXDP1.41 128.39,124.19 125.97,121.77 115.55,121.77 115.54,121.76 112.1,121.76 RC241.2 111.44,122.42 v1(110.82,122.42) 110.73,122.34 CC269.1
SIO_RCIN#: length 121.4
  TOP w0.102: RC13.2 172.7,68.54 v2(172.32,68.93) v1(171.75,69.49) ; UE2.A27 v1(255.62,60.88)
  IN1 w0.084: v1(171.75,69.49) 171.75,69.3 173.21,67.84 176.25,67.84 176.76,67.34 179.93,67.34 181.15,66.11 181.15,62.64 186.42,57.37 187.8,57.37 188.68,56.49 237.72,56.49 238.25,57.02 240.68,57.02 241.64,56.05 242.91,56.05 243.5,56.64 244.55,56.64 245.31,55.88 247.59,55.88 247.7,55.99 252.86,55.99 253.87,54.99 257.39,54.99 258.05,55.65 v1(258.18,55.65)
  IN2 w0.122: v1(258.18,55.65) 258.18,56.25 257.71,56.72 257.71,58.14 256.01,59.83 256.01,60.64 255.77,60.88 v1(255.62,60.88)
  BOTTOM w0.076: UC1.AW13 166.75,82.43 166.58,82.26 166.58,82.26 166.36,81.56 166.36,81.47 166.3,81.32 166.3,81.17 166.37,80.95 166.37,80.84 166.33,80.75 166.32,80.72 166.32,80.34 166.44,80.22 166.44,78.77 166.57,78.64 166.57,78.14 166.74,77.97 166.9,77.97 167.21,77.66
  BOTTOM w0.102: v1(171.75,69.49) 171.75,69.54 170.49,70.8 170.49,71.81 169.8,72.5 169.8,75.61 169.36,76.04 168.83,76.04 167.21,77.66
SIO_SLP_A#: length 139.9
  TOP w0.102: v1(171.07,73.25) 171.07,75.21 170.44,75.83 v2(170.44,76.56) 170.44,78.76 169.61,79.6 169.61,80.68 169.23,81.06 169.22,81.07 167.33,82.95 166.18,82.95 165.99,83.14 165.99,85.02 165.56,85.45 165.01,85.45 v1(164.55,85.91) ; v1(255.42,63.08) 255.37,63.02 UE2.B28 ; v1(186.12,64.13) 186.12,63.67 186.06,63.61 JAPS1.6
  IN1 w0.084: v1(186.12,64.13) 185.47,63.48 182.42,63.48 181.93,63.97 181.93,66.44 179.4,68.96 174.83,68.96 173,70.8 171.52,70.8 170.52,71.8 170.52,72.71 v1(171.07,73.25) ; v1(176.44,84.96) 176.26,85.14 172.49,85.14 171.15,86.47 170.73,86.47 170.36,86.1 169.82,86.1 169.54,86.38 168.93,86.38 168.26,87.05 167.07,87.05 166.56,87.56 165.3,87.56 165,87.26 165,86.35 v1(164.55,85.91)
  IN2 w0.122: v1(219.17,69.96) 218.72,69.5 218.72,67.36 217.64,66.28 214.43,66.28 213.91,65.76 188.21,65.76 186.57,64.13 v1(186.12,64.13)
  IN4 w0.084: v1(219.17,69.96) 219.54,69.96 222.36,67.14 223.22,67.14 223.56,67.48 225.7,67.48 226.03,67.15 227.75,67.15 227.98,66.91 229.96,66.91 230.46,66.4 238.66,66.4 238.87,66.62 242.01,66.62 242.41,66.22 245.78,66.22 246.74,67.18 248.79,67.18 249.94,66.02 251.15,66.02 252.5,64.68 254.98,64.68 255.81,63.84 255.81,63.46 v1(255.42,63.08)
  BOTTOM w0.076: v1(176.44,84.96) 177.04,85.56 178,85.56 178.19,85.75 178.51,85.75 ; UC1.AN16 v1(164.55,85.91)
  BOTTOM w0.102: 178.51,85.75 180.34,85.75 RC339.2
SIO_SLP_LAN#: length 205.9
  TOP w0.102: v1(177.64,67.95) 177.64,67.62 178.29,66.98 v2(178.58,66.98) 178.68,66.88 RC68.1 179.89,66.89 RC344.1 ; UE2.B37 258.53,64.04 v1(258.33,63.84) ; v1(287.61,111.18) 287.35,110.92 UZ2.5
  IN1 w0.102: v1(242.04,56.73) 241.37,57.4 238.09,57.4 237.57,56.87 188.84,56.87 187.96,57.75 186.58,57.75 181.53,62.8 181.53,66.27 179.41,68.39 178.08,68.39 v1(177.64,67.95) 177.23,68.37 173.77,68.37 171.99,70.16 171.53,70.16 170.09,71.6 170.09,74.76 v1(169.2,75.64)
  IN3 w0.102: v1(242.04,56.73) 242.14,56.63 245.88,56.63 246.28,57.03 247.06,57.03 248.43,55.66 250.81,55.66 251.47,55 257.58,55 257.88,54.69 261.39,54.69 262.72,56.03 262.72,59.71 v1(263.34,60.33) 264.39,60.33 265.14,59.58 268.7,59.58 269.18,59.1 275.86,59.1 278.75,61.98 278.75,65.38 280.9,67.53 280.9,71.77 283.72,74.59 283.72,79.31 281.34,81.68 281.34,85.52 281.79,85.96 281.79,88.77 286.78,93.76 286.78,101.81 288.66,103.69 288.66,110.14 v1(287.61,111.18)
  BOTTOM w0.076: v1(169.2,75.64) 168.98,75.64 166.82,77.81 166.65,77.81 166.41,78.05 166.41,78.57 165.63,79.35 165.63,80.27 165.79,80.43 165.79,81.9 165.63,82.23 165.63,82.23 165.48,82.39 UC1.AW15
  BOTTOM w0.102: v1(258.33,63.84) 259.13,63.84 260.52,62.45 261.53,62.45 263.34,60.64 v1(263.34,60.33)
SIO_SLP_S0#: length 275.3
  TOP w0.102: v1(193.69,72.16) v2(193.69,69.77) 190.56,66.64 JAPS1.15 ; v1(216.9,64.6) 216.93,64.63 RZ112.1
  TOP w0.254: PR426.1 v1(241.72,96.85) ; v1(240.68,45.42) 241.12,45.42 PR425.1
  IN1 w0.076: 175.25,76.94 175.21,76.94 171.66,80.5 171.02,80.5 169.57,81.94 168.15,81.94 167.68,82.4 167.68,83.63 v1(167.31,84)
  IN1 w0.102: v1(193.69,72.16) 193.25,72.16 192.03,70.94 182.48,70.94 181.95,71.47 181.95,72.2 180.96,73.19 178.21,73.19 175.36,76.04 175.36,76.83 175.25,76.94 ; v1(216.9,64.6) 216.44,65.06 214.82,65.06 214.36,64.6 209.5,64.6 199.26,74.84 v1(199.26,74.95)
  IN1 w0.254: v1(238.77,82.09) 236.01,84.84 236.01,93.9 238.96,96.85 v1(241.72,96.85)
  IN2 w0.102: v1(163.62,121.08) 164.16,121.61 164.68,121.61 165.96,120.33 185.48,120.33 186.6,121.45 188.02,121.45 189.04,120.43 192.33,120.43 193.94,118.82 193.94,114.8 193.08,113.94 193.08,109.9 193.6,109.37 193.6,105.17 193.09,104.66 193.09,97.14 193.49,96.73 196.72,96.73 198.3,95.16 198.3,94.23 204.45,88.07 204.45,79.76 204.15,79.46 204.15,78.08 201.03,74.95 v1(199.26,74.95) 199.12,74.95 198.14,73.98 198.14,72.78 197.05,71.69 194.16,71.69 v1(193.69,72.16)
  IN2 w0.254: v1(238.77,82.09) 238.77,79.59 236.32,77.14 236.32,75.08 235.67,74.42 235.67,74.14 236.22,73.59 236.22,68.93 235.52,68.23 235.52,65.01 236.07,64.46 236.07,63.12 238.14,61.04 238.14,59.46 235.8,57.11 235.8,54.22 236.61,53.41 239.52,53.41 241.74,51.19 241.74,46.48 v1(240.68,45.42)
  BOTTOM w0.076: v1(167.31,84) 167.66,84.35 UC1.AT11
  BOTTOM w0.102: v1(238.77,82.09) 238.77,79.97 236.55,77.75 234.87,77.75 233.06,75.93 220.25,75.93 220.03,75.71 218.95,75.71 218.39,75.15 204.43,75.15 204.24,75.35 199.65,75.35 v1(199.26,74.95) ; UC13.1 v1(163.62,121.08)
SIO_SLP_S3#: length 448.6
  TOP w0.102: UE3.2 253.11,83.4 253.5,83.79 256.47,83.79 v1(257.11,83.16) ; v1(183.87,64.13) 183.87,63.69 184.06,63.51 JAPS1.2 ; QE11.2 267.77,51.07 266.18,49.48 v1(266.04,49.48) 265.36,48.8 v2(264.46,48.8) 262.09,48.8 261.89,49.01 259.02,49.01 258.82,48.8 255.93,48.8 254.94,49.8 254.94,53.32 255.15,53.53 255.15,54.02 254.98,54.2 UE5.1 254.18,54.2 253.38,55 253.38,55.68 253.09,55.96 251.64,55.96 RE280.1 ; v1(107.76,74.37) 107.77,74.38 RZ120.1 ; UE2.A35 260.84,64.29 261.71,63.42 v1(261.71,62.96)
  TOP w0.254: PR511.1 289.96,12.58 v1(290.37,12.18)
  IN1 w0.102: v1(261.71,62.96) 263.27,62.96 263.93,62.3 265.97,62.3 265.97,62.3 266.75,62.3 267.28,62.84 v1(268.04,62.84) ; v1(241.4,59.11) 241.42,59.11 240.99,58.68 240.41,58.68 240.17,58.91 238.45,58.91 237.38,57.84 235.38,57.84 234.84,58.37 232.88,58.37 232.32,57.81 228.98,57.81 228.37,58.42 224.79,58.42 223.86,57.49 205.53,57.49 198.26,64.75 184.49,64.75 v1(183.87,64.13)
  IN2 w0.102: v1(166.39,85.22) 165.5,85.22 165.08,84.81 165.08,83.14 165.3,82.93 165.3,70.94 163.09,68.73 110.12,68.73 107.76,71.09 v1(107.76,74.37) ; v1(163.61,120.48) 164.3,119.8 192.03,119.8 192.72,119.1 192.72,117.26 191.41,115.96 191.41,110.05 192.35,109.11 192.35,96.82 194.51,94.66 194.99,94.66 196.6,93.05 197.45,93.05 199.64,90.86 199.64,89.7 203.5,85.84 v1(203.5,84.45) ; v1(266.04,49.48) 266.49,49.93 266.49,54.34 267.59,55.43 267.59,56.37 268.26,57.04 268.26,59.93 267.52,60.66 267.52,62.32 v1(268.04,62.84) ; v1(183.87,64.13) 183.87,65.08 184.72,65.94 184.72,74.16 183.98,74.9 183.98,75.81 183.63,76.17 v1(183.63,77.46)
  IN3 w0.102: v1(261.71,62.96) 261.16,63.51 259.74,63.51 258.27,62.04 254.46,62.04 253.68,61.27 253.68,59.6 252.94,58.86 251.24,58.86 249.39,60.71 247.58,60.71 247.17,60.3 244.54,60.3 242.78,58.54 241.97,58.54 241.42,59.09 241.42,59.1 241.41,59.11 v1(241.4,59.11)
  IN4 w0.076: v1(166.39,85.22) 166.39,84.79 166.92,84.27 166.92,82.89 169.14,80.67 176.19,80.67
  IN4 w0.102: v1(183.63,77.46) 183.63,77.89 182.56,78.95 181.81,78.95 180.1,80.67 176.19,80.67 ; v1(290.37,12.18) 289.15,13.39 289.15,21.32 288,22.47 286.24,22.47 285.56,23.16 280.95,23.16 279.65,24.46 279.65,26.34 278.93,27.06 278.93,28.98 277.86,30.04 277.86,38.68 273.43,43.11 273.01,43.11 266.65,49.48 v1(266.04,49.48) ; v1(261.71,62.96) 262.46,62.96 263.62,64.12 263.62,67.22 263.5,67.35 263.5,68.16 263.76,68.43 263.76,68.93 264.07,69.24 264.22,69.24 264.45,69.46 264.45,70.37 263.76,71.05 263.76,73.84 262.22,75.38 257.81,75.38 v1(257.29,75.9)
  BOTTOM w0.076: v1(166.39,85.22) 165.96,85.65 UC1.AP15
  BOTTOM w0.102: v1(257.29,75.9) 257.29,80.29 256.74,80.83 256.74,81.31 257.11,81.68 v1(257.11,83.16) ; v1(183.63,77.46) 183.63,76.84 185.29,75.18 188.26,75.18 188.84,75.76 191.27,75.76 191.67,75.36 193.1,75.36 193.46,75.71 194.74,75.71 195.34,76.31 201.38,76.31 203.15,78.08 203.15,80.26 203.61,80.72 203.61,82 204.08,82.47 204.08,83.88 v1(203.5,84.45) ; v1(163.61,120.48) 163.56,120.43 UC13.2 159.37,120.43 RC320.1
SIO_SLP_S4#: length 402.2
  TOP w0.102: v1(131.8,128.08) 131.8,127.11 131.1,126.41 127.07,126.41 126.41,125.75 116.33,125.75 v1(116.01,125.43) 115.48,125.43 115.3,125.61 115.3,126.01 115.48,126.19 UZ21.4 ; v1(83.84,105.3) 82.66,105.3 81.82,104.47 v2(81.82,103.09) 82.19,102.73 82.19,96.25 81.38,95.44 78.02,95.44 77.34,94.76 77.34,93.18 77.78,92.73 77.78,81.91 v1(77.06,81.19) ; JAPS1.5 185.56,66.32 186.34,67.11 v1(186.34,67.91) ; UE2.B36 258.68,63.54 258.3,63.16 v1(258.3,63.07) ; PR1500.1 251.27,43.56 v1(251.08,43.75) ; UC14.2 89.85,118.91 v1(90.92,119.97)
  IN1 w0.102: v1(241.96,59.13) 241.97,59.13 241.98,59.14 241.98,59.15 241.63,59.51 238.47,59.51 237.21,58.25 235.54,58.25 235.01,58.78 232.71,58.78 232.15,58.22 229.15,58.22 228.21,59.15 205.3,59.15 198.15,66.3 187.64,66.3 186.34,67.6 v1(186.34,67.91)
  IN2 w0.102: v1(203.49,82.71) 204.25,83.47 204.25,87.98 198.09,94.14 198.09,95.07 196.64,96.53 193.41,96.53 192.89,97.05 192.89,104.74 193.4,105.26 193.4,109.29 192.87,109.81 192.87,114.02 193.74,114.89 193.74,118.66 192.2,120.2 188.98,120.2 187.94,121.24 186.68,121.24 185.57,120.13 165.16,120.13 v1(164.21,121.08) ; v1(185.42,75.93) 186.28,75.07 186.28,73.07 185.93,72.71 185.93,69.19 186.38,68.73 186.38,67.94 v1(186.34,67.91)
  IN3 w0.102: v1(258.3,63.07) 257.54,62.3 254.43,62.3 253.48,61.35 253.48,59.69 252.85,59.06 251.33,59.06 249.48,60.92 247.5,60.92 247.08,60.5 244.42,60.5 242.66,58.75 242.36,58.75 241.98,59.13 v1(241.96,59.13)
  IN4 w0.102: v1(83.84,105.3) 84.25,105.71 84.25,107.78 82.34,109.69 82.34,114.58 83.04,115.27 83.04,118.93 83.69,119.58 90.52,119.58 v1(90.92,119.97) 92.44,121.5 110.6,121.5 112.13,123.02 112.13,123.66 114.54,126.07 115.38,126.07 v1(116.01,125.43) ; v1(137.83,122.35) 137.83,122.49 137.37,122.94 136.9,122.94 136.29,123.56 136.29,125.86 134.64,127.51 132.36,127.51 v1(131.8,128.08)
  BOTTOM w0.076: UC1.BA16 164.93,81.53 164.93,79.09 165.75,78.27 165.75,77.74 166.37,77.11 166.52,77.11
  BOTTOM w0.102: v1(203.49,82.71) 203.2,82.42 203.2,80.89 202.74,80.43 202.74,79.3 200.51,77.07 197.29,77.07 196.9,76.68 195.31,76.68 195.04,76.41 191.65,76.41 191.44,76.62 187.53,76.62 186.46,75.55 185.8,75.55 v1(185.42,75.93) ; v1(164.21,121.08) 163.23,122.06 162.61,122.06 161.78,122.88 160.17,122.88 159.98,123.07 159.98,124.18 159.74,124.42 158.21,124.42 157.81,124.01 145.39,124.01 144.03,122.65 140.31,122.65 140,122.35 v1(137.83,122.35) ; 166.52,77.11 168.25,75.39 168.25,72.54 168.6,72.18 168.93,71.86 168.93,69.19 169.56,68.56 177.28,68.56 177.51,68.79 185.47,68.79 186.31,67.95 186.31,67.94 v1(186.34,67.91) ; v1(251.08,43.75) 251.08,41.72 250.66,41.3 250.66,40.71 250.12,40.18 246.64,40.18 245.72,41.11 243.86,41.11 241.31,43.66 241.31,48.51 241.78,48.98 241.78,53.2 242.81,54.22 242.81,57.03 241.96,57.88 v1(241.96,59.13)
  BOTTOM w0.254: PR208.1 v1(77.06,81.19)
SIO_SLP_S5#: length 111
  TOP w0.102: v1(185.75,67.91) 185.75,67.12 v2(185.29,66.66) 185.06,66.43 JAPS1.4 ; UE2.A18 251.12,61.1 v1(250.9,60.87)
  IN1 w0.102: v1(185.75,67.91) 187.55,66.1 198.07,66.1 205.22,58.95 228.13,58.95 229.07,58.01 232.23,58.01 232.8,58.58 234.93,58.58 235.46,58.04 237.3,58.04 238.37,59.11 v1(240.81,59.11)
  IN3 w0.102: v1(240.81,59.11) 240.84,59.11 241.32,59.6 242.72,59.6 245.34,62.21 249.55,62.21 v1(250.9,60.87)
  BOTTOM w0.076: UC1.AY16 164.9,82.02 164.6,81.71 164.6,81.29 164.76,81.12 164.76,78.98 165.58,78.16 165.58,77.67 166.31,76.93 166.43,76.93
  BOTTOM w0.102: 166.43,76.93 168.06,75.31 168.06,72.44 168.72,71.77 168.72,68.93 169.3,68.36 177.37,68.36 177.6,68.59 185.07,68.59 v1(185.75,67.91)
SIO_SLP_SUS#: length 430.7
  TOP w0.102: v1(285.28,7.32) 285.67,7.72 PR504.1 ; RC76.2 260.17,82.67 260.45,82.95 v1(260.45,83.28) ; UC14.1 89.33,118.26 89.89,117.7 91.31,117.7 94.84,114.17 94.84,112.9 v1(95.17,112.57) ; v1(197.46,76.69) 197.2,76.44 196,76.44 RZ64.1
  TOP w0.254: v1(228.75,88.83) 229.47,88.83 PR312.2 ; PR406.1 v1(245.27,96.81)
  IN1 w0.102: v1(228.75,88.83) 229.36,88.22 229.36,85.42 231.42,83.36 231.42,78.76 230.15,77.49 214.26,77.49 213.83,77.93 206.45,77.93 204.3,80.08 204.3,83.07 v1(203.49,83.88) 203.34,83.88 201.78,85.44 201.78,87.24 198.59,90.42 197.99,90.42 197.57,90.84 197.16,90.84 196.74,90.41 194.29,90.41 193.92,90.05 191.81,90.05 v1(191.42,89.67) 190.73,88.97 185.29,88.97 v1(184.82,88.5)
  IN2 w0.102: v1(165.4,85.97) 165.59,85.97 165.91,86.29 165.91,87.65 166.13,87.87 168.74,87.87 169.23,87.37 171.41,87.37 172.81,85.97 177.71,85.97 v1(178.37,85.31) 179.74,85.31 182.14,87.71 184.03,87.71 v1(184.82,88.5) ; v1(173.26,117.7) 174.22,116.75 183.93,116.75 189.29,111.39 189.29,101.55 190.89,99.94 190.89,95.59 192.05,94.43 192.05,93.37 193.85,91.56 193.85,90.5 193.46,90.1 191.86,90.1 v1(191.42,89.67) ; v1(269.35,71.97) 269.35,70.71 268.55,69.91 268.55,68.56 269.06,68.06 270,68.06 270.46,67.6 270.46,66.62 271,66.07 271,64.17 270.42,63.58 270.42,62.85 269.81,62.24 269.81,57.58 269.84,57.54 269.84,54.65 269.72,54.53 269.72,53.44 268.34,52.06 268.34,44.01 274.89,37.46 274.89,16.19 278.82,12.27 278.82,11.21 281.74,8.29 284.31,8.29 v1(285.28,7.32)
  IN3 w0.102: v1(235.08,75.73) 235.45,76.11 246.58,76.11 247.83,77.35 249.76,77.35 251.64,75.47 259.41,75.47 v1(260.55,74.33) 263.89,74.33 264.53,73.69 268.69,73.69 269.35,73.03 v1(269.35,71.97) ; v1(173.26,117.7) 170.74,117.7 165.8,122.64 161.11,122.64 159.88,121.42 158.96,121.42 155.63,124.75 136.8,124.75 134.98,122.93 133.74,122.93 131.78,120.98 121.91,120.98 116.9,115.96 113.55,115.96 112.96,115.36 107.41,115.36 106.37,114.32 102.52,114.32 101.47,115.38 100.31,115.38 97.7,112.77 95.63,112.77 95.43,112.57 v1(95.17,112.57)
  IN4 w0.102: v1(228.75,88.83) 229.69,89.77 231.7,89.77 239.37,97.44 244.64,97.44 v1(245.27,96.81)
  BOTTOM w0.076: UC1.AN15 165.79,86.3 v1(165.4,85.97) ; 178.51,85.31 v1(178.37,85.31)
  BOTTOM w0.102: v1(260.45,83.28) 260.06,82.89 260.06,79.32 261.49,77.89 261.49,76.75 260.55,75.81 v1(260.55,74.33) ; RZ82.2 172.95,118.53 173.26,118.21 v1(173.26,117.7) ; 178.51,85.31 180.78,85.31 RC340.2 ; v1(197.46,76.69) 200.42,76.69 202.94,79.21 202.94,80.34 203.41,80.81 203.41,82.09 203.87,82.55 203.87,83.5 v1(203.49,83.88) ; v1(235.08,75.73) 238.97,79.63 238.97,81.55 239.19,81.77 239.19,82.6 240.43,83.84 242.22,83.84 243.87,85.49 244.64,85.49 245.91,86.76 246.38,86.76 246.84,87.22 246.84,95.24 v1(245.27,96.81)
SIO_SLP_SUS#_R: length 17.5
  TOP w0.102: RC76.1 260.22,81.76 260.69,82.23 260.69,82.89 v1(261.08,83.28) ; UE2.B52 258.37,72.11 v1(258.63,72.37)
  BOTTOM w0.102: v1(261.08,83.28) 260.26,82.46 260.26,79.41 261.69,77.97 261.69,76.66 261.21,76.18 261.21,73.31 260.27,72.37 v1(258.63,72.37)
SIO_SLP_WLAN#: length 127
  TOP w0.102: v1(240.84,55.8) 240.52,55.48 240.52,54.73 v2(240.52,54.73) 240.52,54.72 240.52,54.35 241.05,53.82 241.05,51.94 241.74,51.25 241.74,49.46 v1(242.52,48.69) ; UE1.A14 v1(239.36,69.73)
  IN1 w0.102: v1(240.84,55.8) 240.02,56.62 238.39,56.62 237.89,56.11 188.52,56.11 187.65,56.99 186.26,56.99 180.77,62.49 180.77,65.96 179.77,66.96 176.6,66.96 176.1,67.46 172.74,67.46 170.87,69.33 170.87,69.88 169.49,71.26 169.49,73 167.38,75.11 v1(167.13,75.11)
  IN2 w0.102: v1(240.84,55.8) 239.41,57.23 239.41,60.93 239.78,61.3 239.78,63.23 238.96,64.05 238.96,66.38 239.3,66.72 239.67,66.72 240.28,67.34 240.28,67.73 239.36,68.65 v1(239.36,69.73)
  BOTTOM w0.076: UC1.BB17 164.43,80.48 164.43,78.77 165.25,77.95 165.25,77.33 165.6,76.98 165.6,76.79
  BOTTOM w0.102: 165.6,76.79 165.6,76.24 166.71,75.11 v1(167.13,75.11) ; v1(242.52,48.69) 241.55,47.72 241.55,47.43 241.55,47.42 241.55,43.9 243.66,41.78 RZ71.1
SL_BAT_PRES#: length 4.7
  TOP w0.102: v2(89.63,76.18) 89.84,75.98 89.84,74.48 90.19,74.13 PR926.1
  TOP w0.254: PR926.1 90.27,73.31 89.69,72.73 PU901.21
SLEEVE: length 28.4
  IN4 w1.016: 297.53,65.95 296.14,67.34 296.14,68.11 295.06,69.19
  IN4 w1.27: 283.86,47.15 284.54,47.84 284.54,51.75 287.28,54.49 288.76,54.49 294.94,60.68 294.94,62.21 295.89,63.17 298.21,63.17
  vias: v1(282.85,47.35) v1(282.85,46.74) v1(293.19,69.44) v1(293.76,69.44) v1(297.79,64.99) v1(297.79,64.42) v2(299.02,66.12)
SLEEVE_R:
  vias: v1(289.28,48.04) v1(289.85,48.04) v2(285.68,48.26)
SLICE_BAT_ON: length 176.2
  TOP w0.102: RE17.2 228.04,74.91 v1(228.04,74.33) 228.23,74.33 228.93,73.63 229.65,73.63 229.92,73.37 UE1.A31
  TOP w0.254: PR930.2 v1(86.71,75.73)
  IN1 w0.102: v1(86.61,56.59) 85.63,57.57 85.63,74.65 v1(86.71,75.73)
  IN2 w0.102: v1(228.04,74.33) 228.04,73.38 225.97,71.31 222.96,71.31 220.82,69.17 220.82,66.53 210.53,56.23 89.73,56.23 88.85,57.11 87.13,57.11 v1(86.61,56.59)
SLICE_BAT_PRES#: length 349.6
  TOP w0.102: UE1.B33 v1(229.67,70.92) 229.22,70.92 228.5,71.65 228.5,73.61 228.21,73.9 226.59,73.9 226.16,74.33 RE5.2 225.65,75.52 225.65,76.45 225.94,76.74 227.01,76.74 228.09,77.82 228.09,78.1 228.41,78.42 233.66,78.42 234.03,78.05 235.19,78.05 v1(235.63,78.49)
  TOP w0.254: v1(72.44,39.62) 72.43,39.63 v2(72.43,41.64) 72.43,42.57 PR4.1 ; PR926.2 v1(90.27,75.66)
  IN1 w0.102: v1(235.63,78.49) 235.99,78.14 241.02,78.14 241.75,78.88 241.75,81.78 244.8,84.82 244.8,85.82 245.51,86.53 245.97,86.53 247.85,88.41 247.85,95.15 242.01,100.99 229.86,100.99 229.36,100.48 210.59,100.48 203.82,107.26 191.77,107.26 189.67,109.36 187.79,109.36 183.5,113.64 183.5,113.98 180.38,117.1 179.73,117.1 v1(178.97,117.86)
  IN2 w0.102: v1(229.67,70.92) 227.51,70.92 227.32,71.11 223.04,71.11 221.03,69.09 221.03,66.44 210.61,56.03 89.39,56.03 v1(89.22,56.21)
  IN4 w0.254: v1(90.27,75.66) 90.82,75.12 93.66,75.12 95.59,73.19 95.59,68.49 90.9,63.8 90.9,59.65 89.22,57.96 v1(89.22,56.21) 89.22,50.91 87.74,49.44 80.53,49.44 79.27,48.18 77.57,48.18 73.25,43.86 73.25,40.43 v1(72.44,39.62)
  BOTTOM w0.102: 171.5,129.4 171.14,129.4 171,129.54 JDOCK1.141 ; 171.5,129.4 JDOCK1.143 ; 171.5,129.4 171.57,129.32 171.57,124.51 173,123.08 173.75,123.08 v1(178.97,117.86)
SLOT2_CONFIG_0: length 65.6
  TOP w0.102: v1(238.99,73.59) 239.28,73.3 RPE11.1 ; UE1.B12 237.28,68.48 v1(237.13,68.33) ; v1(276.69,92.14) 276.69,91.6 v2(276.81,91.49)
  IN3 w0.102: v1(243.62,82.3) 243.63,82.3 244.32,82.99 249.94,82.99 251.29,84.34 252.08,84.34 252.41,84.67 261.47,84.67 263.42,82.72 265.58,82.72 267.64,84.78 267.64,88.44 271.33,92.14 v1(276.69,92.14)
  BOTTOM w0.102: v1(237.13,68.33) 237.51,68.71 237.51,72.22 238.88,73.59 v1(238.99,73.59) 239.89,74.5 239.89,74.68 241.54,76.32 241.54,80.58 243.26,82.3 v1(243.62,82.3) ; JNGFF2.13 278.16,93.6 v1(276.69,92.14)
SLOT2_CONFIG_1: length 77
  TOP w0.102: UE1.A18 236.42,73.09 236.93,73.61 237.28,73.61 238.08,72.8 RPE11.2 241.41,72.8 241.63,73.02 241.63,73.48 241.46,73.64 240.46,73.64 240.26,73.85 240.26,75.93 239.67,76.51 v2(239.67,79.76) 240.26,80.35 240.26,83.44 240.82,84 241.42,84 v1(241.82,84.4)
  IN3 w0.102: v1(251.25,97.47) 251.25,98.05 250.02,99.28 250.02,102 251.11,103.09 265.9,103.09 269.43,106.63 278.29,106.63 v1(278.61,106.31)
  IN4 w0.102: v1(251.25,97.47) 251.25,93.45 247.6,89.79 247.6,87.06 246.8,86.27 245.3,86.27 243.43,84.4 v1(241.82,84.4)
  BOTTOM w0.102: JNGFF2.61 279.31,105.6 v1(278.61,106.31)
SLOT2_CONFIG_2: length 116.6
  TOP w0.102: v1(239.85,71.03) 239.85,71.83 240.32,72.3 RPE11.3 ; v1(286.33,102.41) 287.04,102.41 v2(287.53,101.93) ; v1(227,65.25) 227.03,65.23 UE1.A44
  IN3 w0.102: v1(227,65.25) 227.35,64.91 230.11,64.91 230.77,64.25 234.97,64.25 235.9,65.18 235.9,66.02 236.54,66.66 238.56,66.66 238.72,66.82 240.31,66.82 v1(240.5,67.01) 241.45,67.01 242.29,66.17 246.07,66.17 246.16,66.26 247.34,66.26 247.9,65.71 248.92,65.71 250.14,66.92 251.16,66.92 251.96,66.12 256.41,66.12 257.16,66.88 259,66.88 259.94,65.93 262.95,65.93 263.43,65.45 278.25,65.45 280.49,67.7 280.49,71.94 283.28,74.73 283.28,79.15 280.93,81.5 280.93,88.56 286.33,93.95 v1(286.33,102.41)
  BOTTOM w0.102: v1(240.5,67.01) 240.5,70.38 v1(239.85,71.03) ; JNGFF2.67 281.04,107.1 281.2,106.94 281.2,104.21 281.43,103.98 285.62,103.98 286.33,103.28 v1(286.33,102.41)
SLOT2_CONFIG_3: length 79.9
  TOP w0.102: v1(239.85,70.05) 240.26,70.05 240.54,70.33 240.54,71.66 240.67,71.8 RPE11.4 ; v2(279.26,88.41) 278.44,89.23 v1(278.39,89.23) ; v1(228.89,72.17) 229,72.17 229.17,72.01 UE1.B34
  IN3 w0.102: v1(239.85,70.05) 240.28,70.48 240.28,71.15 239.88,71.56 229.5,71.56 v1(228.89,72.17) ; v1(278.39,89.23) 279.75,87.86 279.75,80.87 278.86,79.98 278.86,74.49 277.3,72.93 274.42,72.93 273.06,71.57 270.31,71.57 268.36,69.63 265.05,69.63 264.5,70.18 262.29,70.18 260.94,71.52 v1(260.08,71.52)
  IN4 w0.102: v1(239.85,70.05) 240.14,69.76 245.01,69.76 245.55,69.21 249.91,69.21 250.07,69.05 251.86,69.05 252.07,69.25 257.15,69.25 257.27,69.12 259.29,69.12 259.41,69.24 259.41,70.85 v1(260.08,71.52)
  BOTTOM w0.102: JNGFF2.1 279.02,88.6 v1(278.39,89.23)
SM_RCOMP0: length 11.4
  TOP w0.381: RC5.1 v2(162.69,77.58) v1(163.19,78.07)
  IN1 w0.305: v1(163.19,78.07) 163.19,78.47 162.3,79.36 162.3,83.52 163.42,84.64 v1(163.64,84.64)
  BOTTOM w0.254: UC1.AR18 164.07,84.98 v1(163.64,84.64)
SM_RCOMP1: length 10.4
  TOP w0.381: RC6.1 163.81,75.34 v2(163.81,76.28) 163.81,76.98 v1(164.22,77.39)
  IN1 w0.305: v1(164.22,77.39) 164.22,78.78 163.15,79.84 163.15,83.59 163.57,84 v1(163.64,84)
  BOTTOM w0.254: v1(163.64,84) 164.07,84.33 UC1.AT18
SM_RCOMP2: length 11.8
  TOP w0.381: v1(166.25,76.56) v2(166.25,75.85) 166.25,75.14 165.95,74.84 RC7.1
  IN1 w0.305: v1(163.64,83.37) 164.2,82.81 164.2,80.35 166.25,78.3 v1(166.25,76.56)
  BOTTOM w0.254: UC1.AU18 164.07,83.68 v1(163.64,83.37)
SML0_SMBCLK: length 115.3
  TOP w0.102: RC19.1 253.15,88.74 253.27,88.74 v1(253.46,88.55) 253.65,88.73 253.77,88.73 RC347.1 ; UL1.28 v1(256.34,94.89)
  IN4 w0.084: v1(181.33,94.83) 181.33,95.12 181.42,95.21 181.78,95.21 182.12,94.87 184.47,94.87 189.23,90.11 194.62,90.11 199.42,85.31 200.53,85.31 202.63,83.21 202.63,82.29 204.21,80.7 204.96,80.7 206.31,79.35 206.31,79.25 208.32,77.24 232.82,77.24 233.19,77.61 240.78,77.61 241.66,78.49 243.74,78.49 245.72,80.46 246.49,80.46 247.09,81.06 249.35,81.06 250.4,82.11 251.82,82.11 252.86,83.14 252.86,88.49 253.07,88.71 253.31,88.71 v1(253.46,88.55) 253.64,88.72 254.94,88.72 255.25,89.04 255.25,90.24 257.05,92.03 257.05,94.06 256.83,94.28 256.49,94.28 256.34,94.42 v1(256.34,94.89)
  BOTTOM w0.076: 180.75,93.53 180.69,93.48 180.03,93.48 179.61,93.06 177.81,93.06 177.35,92.6 176.29,92.6 176.11,92.78 174.52,92.78 174.38,92.64 173.93,92.64 173.75,92.72 172.6,92.72 172.41,92.91 172.41,93.29 172.11,93.6 172.11,93.89 171.54,94.46 170.82,94.46 170.81,94.47 170.51,94.47 170.49,94.46 170.18,94.46 169.96,94.67 169.96,94.88 169.61,95.23 UC1.R9
  BOTTOM w0.102: 180.75,93.53 180.82,93.6 180.84,93.6 180.88,93.65 180.89,93.65 181.09,93.84 181.09,94.59 v1(181.33,94.83)
SML0_SMBDATA: length 109.1
  TOP w0.102: UL1.31 256.54,93.69 v1(256.37,93.52) ; RC348.1 253.74,88.96 253.64,88.96 v1(253.46,89.13) 253.3,88.97 253.15,88.97 RC20.1
  IN4 w0.084: v1(256.37,93.52) 256.37,93.91 256.52,94.06 256.75,94.06 256.84,93.97 256.84,92.12 255.04,90.32 255.04,89.12 254.85,88.93 253.66,88.93 v1(253.46,89.13) 253.25,88.92 252.98,88.92 252.64,88.58 252.64,83.23 251.74,82.32 250.31,82.32 249.26,81.27 247,81.27 246.4,80.67 245.63,80.67 243.66,78.7 241.58,78.7 240.7,77.82 233.1,77.82 232.73,77.45 208.4,77.45 206.52,79.33 206.52,79.43 205.05,80.91 204.3,80.91 202.84,82.37 202.84,83.29 200.61,85.52 199.51,85.52 194.71,90.32 189.32,90.32 184.56,95.08 182.21,95.08 181.86,95.42 181.34,95.42 v1(180.74,94.83)
  BOTTOM w0.076: 180.75,93.82 180.68,93.75 180.64,93.75 180.57,93.68 179.95,93.68 179.53,93.26 177.72,93.26 177.26,92.81 176.38,92.81 176.2,92.99 174.44,92.99 174.26,92.8 173.97,92.8 173.89,92.84 173.82,92.87 173.72,92.92 173.72,92.93 173.71,92.93 173.57,93.07 UC1.W2
  BOTTOM w0.102: 180.75,93.82 180.86,93.93 180.86,94.72 v1(180.74,94.83)
SML1_SMBCLK: length 98
  TOP w0.102: v1(180.19,94.7) 179.78,95.11 179.4,95.11 179.25,94.95 RC15.1 ; UE2.B6 v1(250.42,68.54)
  IN4 w0.084: v1(180.19,94.7) 180.01,94.52 180.01,94.45 180.13,94.32 184.36,94.32 187.03,91.66 187.03,90.27 191.7,85.59 195.51,85.59 195.72,85.8 197.55,85.8 198.5,84.84 199.67,84.84 202.02,82.49 202.02,81.36 204.16,79.22 204.82,79.22 206.3,77.75 207.15,77.75 208.61,76.28 233.91,76.28 233.94,76.32 235.73,76.32 235.77,76.28 241.37,76.28 241.82,75.84 247.84,75.84 v1(248.03,76.02)
  BOTTOM w0.076: 179.93,94.44 179.88,94.39 179.88,94.12 v5(179.59,93.83) 179.42,93.66 176.28,93.66 175.96,93.34 173.98,93.34 173.84,93.28 173.71,93.28 173.48,93.35 173.48,93.35 173.34,93.35 173.13,93.27 172.97,93.27 UC1.W3
  BOTTOM w0.102: v1(180.19,94.7) 179.93,94.44 ; v1(248.03,76.02) 248.24,75.81 248.47,75.81 249.25,75.04 249.25,72.28 248.9,71.94 248.9,68.89 249.45,68.35 250.23,68.35 v1(250.42,68.54)
SML1_SMBDATA: length 95.9
  TOP w0.102: v1(248.24,68.79) UE2.A5 ; RC17.1 178.99,94.06 v1(179.63,94.7)
  IN4 w0.084: v1(179.63,94.7) 179.8,94.53 179.8,94.36 180.05,94.11 184.27,94.11 186.81,91.57 186.81,90.18 191.61,85.38 195.6,85.38 195.8,85.59 197.46,85.59 198.42,84.63 199.58,84.63 201.81,82.4 201.81,81.28 204.08,79.01 204.74,79.01 206.21,77.53 207.06,77.53 208.52,76.07 234,76.07 234.03,76.11 235.65,76.11 235.68,76.07 241.28,76.07 241.73,75.62 247.84,75.62 v1(248.03,75.44)
  BOTTOM w0.076: UC1.V3 172.71,93.46 173.18,93.46 173.31,93.51 173.5,93.51 173.53,93.5 173.73,93.45 173.8,93.45 173.94,93.5 175.84,93.5 176.2,93.86 v5(177.98,93.86) 179.33,93.86 179.68,94.2 179.68,94.44
  BOTTOM w0.102: v1(179.63,94.7) 179.68,94.65 179.68,94.44 ; v1(248.24,68.79) 248.32,68.79 248.68,69.15 248.68,72.03 249.02,72.37 249.02,74.95 248.38,75.59 248.18,75.59 v1(248.03,75.44)
SNB_+1VALWP: length 1.4
  BOTTOM w0.102: PC302.1 221.52,86.65 v2(220.69,87.49)
SNUB_1.2V: length 0.5
  TOP w0.102: 76.91,70.25 v2(76.91,70.73)
SNUB_1.8VALW: length 1.3
  TOP w0.102: PC506.1 v2(291.11,2.07)
SNUB_1V_PRIM: length 1.3
  TOP w0.102: PR409.2 v2(238.8,96.07)
SNUB_1VS_VCCIO: length 1
  TOP w0.102: PC401.1 v2(241.68,47.04)
SOFT_START_GC: length 77.4
  TOP w0.102: v1(65.69,61.74) 65.69,61.5 v2(65.47,61.27)
  TOP w0.254: v1(77.25,92.69) 77.06,92.88 77.06,94.9 77.88,95.72 81.27,95.72 81.91,96.37 81.91,101.36 81.12,102.15 PR14.2 ; v1(87.03,65.31) 87.19,65.47 PU901.2
  IN3 w0.102: v1(87.03,65.31) 84.08,65.31 79.57,60.8 72.73,60.8 72.58,60.65 66.79,60.65 v1(65.69,61.74)
  BOTTOM w0.254: v1(77.25,92.69) 76.38,92.69 74.98,91.29 74.98,82.29 65.48,72.79 65.48,66.03 64.48,65.03 64.48,62.28 65.01,61.74 v1(65.69,61.74)
SPKR: length 134.5
  TOP w0.102: v2(184.34,71.23) v1(184.34,71.73) 184.66,72.05 RC183.2 ; v1(284.45,61.57) 284.57,61.57 RA12.2
  IN1 w0.076: v1(171.95,83.3) 172,83.3 172.32,82.98 172.32,80.36 175.13,77.55 176.43,77.55 177.04,76.94
  IN1 w0.102: v1(264.88,56.28) 264.82,56.22 263.68,56.22 262.8,57.11 260.16,57.11 259.93,57.34 259.93,58.11 259.67,58.37 250.17,58.37 249.96,58.16 248.33,58.16 247.58,58.91 246.36,58.91 243.56,61.71 240.86,61.71 240.27,61.12 238.16,61.12 237.78,61.5 235.06,61.5 234.9,61.66 229.27,61.66 229.06,61.45 222.08,61.45 219.8,63.74 218.75,63.74 217.71,62.7 205.48,62.7 195.02,73.16 193.68,73.16 191.86,71.35 184.73,71.35 v1(184.34,71.73) 184.34,72.31 182.13,74.52 179.46,74.52 177.04,76.94
  IN3 w0.102: v1(284.45,61.57) 282.12,61.57 277.1,56.55 271.43,56.55 271.1,56.88 268.37,56.88 267.9,56.41 265,56.41 v1(264.88,56.28)
  BOTTOM w0.076: v1(171.95,83.3) 171.64,82.99 UC1.AW5
SRTCRST#: length 16.2
  TOP w0.102: RC56.1 CC24.1 168.6,73.37 168.6,75.97 167.68,76.89 v2(167.68,77.45) 167.68,78.24 v1(167.31,78.61)
  IN4 w0.076: v1(163.64,85.91) 164.01,85.54 164.01,82.7 166.44,80.27 166.44,79.49 167.32,78.61 v1(167.31,78.61)
  BOTTOM w0.076: UC1.AN18 v1(163.64,85.91)
SS_1V_PRIM: length 4.2
  TOP w0.254: PU402.7 241.95,89.78 v2(241.27,89.09) 241.07,88.9 241.07,87.7 PC420.1 PR428.1
SS_1VS_VCCIO: length 5
  TOP w0.254: PU401.7 235.57,44.86 235.16,44.46 235.16,43.58 v2(234.95,43.37) 234.29,42.71 PC410.1 233.98,42.71 233.61,42.34 233.61,42.33 233.02,41.74 PR427.1
STSTART_DCBLOCK_GC: length 126.3
  TOP w0.254: PU901.16 92.36,70.14 v1(92.56,70.33)
  IN3 w0.254: v1(5.7,43.55) 6.86,42.39 8.3,42.39 10.62,40.08 12.58,40.08 13.23,39.43 20.01,39.43 24.52,34.92 26.02,34.92 27.09,35.99 27.09,37.68 28.33,38.92 29.32,38.92 33.26,42.86 35.89,42.86 39.9,38.85 55.26,38.85 56.54,40.13 59.5,40.13 60.67,38.97 66.79,38.97 71.08,43.27 71.08,50.73 70.81,51 70.81,52.65 72.32,54.16 74.48,54.16 74.95,53.69 78,53.69 78.81,54.5 84.88,54.5 85.79,55.41 86.83,55.41 93.42,61.99 93.42,69.46 v1(92.56,70.33)
  BOTTOM w0.254: PR906.2 v1(5.7,43.55)
SUS_STAT#: length 8.3
  TOP w0.102: RC26.1 171.78,75.19 v1(171.78,75.66)
  BOTTOM w0.076: UC1.BA11 167.68,80.97 167.68,79.7 169.34,78.04 169.53,78.04 v2(169.8,77.77) 170.3,77.26 170.46,77.26 170.89,76.83
  BOTTOM w0.102: v1(171.78,75.66) 171.78,75.94 170.89,76.83
SUSACK#: length 107.1
  TOP w0.102: UE2.B7 250.5,68.04 v1(250.99,67.55)
  IN1 w0.076: 174.96,76.94 171.57,80.33 170.04,80.33 168.73,81.64 168.07,81.64 166.88,82.82 166.88,85.5 v1(167.3,85.91)
  IN1 w0.102: v1(220.67,61.73) 220.47,61.53 219.28,61.53 218.31,62.5 205.21,62.5 197.04,70.67 182.46,70.67 181.75,71.39 181.75,72.11 180.93,72.93 178.18,72.93 175.16,75.95 175.16,76.75 174.96,76.94
  IN4 w0.102: v1(250.99,67.55) 250.49,67.05 249.18,67.05 248.87,67.37 246.66,67.37 245.7,66.42 243.9,66.42 242.9,67.42 240.32,67.42 239.74,66.84 238.74,66.84 238.54,66.65 236.43,66.65 235.13,67.95 228.47,67.95 227.86,67.34 226.11,67.34 225.78,67.67 223.02,67.67 v1(222.92,67.78)
  BOTTOM w0.076: UC1.AP11 167.55,85.65 v1(167.3,85.91)
  BOTTOM w0.102: v1(222.92,67.78) 221.79,67.78 221.41,67.39 221.41,62.28 220.86,61.73 v1(220.67,61.73)
SUSCLK: length 309.1
  TOP w0.102: v1(256.32,54) 255.92,53.59 255.92,53.11 RZ56.1 ; RC48.1 167.71,73.41 v2(167.71,74.74) 167.71,75.1 v1(167.13,75.68)
  IN1 w0.084: v1(256.32,54) 256.17,54.15 253.52,54.15 252.52,55.15 248.07,55.15 247.33,54.42 243.85,54.42 243.31,54.96 240.18,54.96 239.18,55.96 238.66,55.96 238.16,55.46 188.1,55.46 187.22,56.33 185.99,56.33 178.93,63.4 178.93,64.67 177.37,66.22 176.4,66.22 176.01,66.62 171.8,66.62 168.8,69.61 168.8,72.19 166.74,74.25 166.74,75.3 v1(167.13,75.68)
  IN2 w0.122: v1(11.28,41.06) 11.28,41.25 9.17,43.35 6.53,43.35 4.97,44.91 4.97,49.47 5.48,49.98 5.48,54.21 8.72,57.45 24.36,57.45 24.82,56.99 42.5,56.99 43.16,56.34 48.14,56.34 49.25,57.45 50.06,57.45 50.81,58.2 59.03,58.2 60.42,59.6 60.42,60.83 61.17,61.58 62.08,61.58 62.33,61.33 62.33,61.06 62.77,60.63 63.66,60.63 63.97,60.93 65.03,60.93 65.32,60.65 67.18,60.65 68.18,59.65 73.42,59.65 73.8,59.27 74.83,59.27 76.07,60.51 79.06,60.51 82.59,64.04 83.91,64.04 84.53,64.65 91.3,64.65 92.1,65.45 161.32,65.45 166.16,70.29 166.16,71.71 166.43,71.98 166.43,74.99 v1(167.13,75.68)
  BOTTOM w0.076: 165.83,76.79 165.83,77 165.41,77.42 165.41,78.02 164.6,78.84 164.6,80.76 164.33,81.03 UC1.BA17
  BOTTOM w0.102: RN99.2 v1(11.28,41.06) ; v1(167.13,75.68) 166.48,75.68 165.83,76.34 165.83,76.79
SUSCLK_R: length 7.5
  IN2 w0.122: JNGFF3.60 8.7,36.3 v1(11.28,38.87)
  BOTTOM w0.102: RN99.1 v1(11.28,38.87)
SW1_DP1_AUXN: length 44
  TOP w0.094: UV26.25 228.71,109.96 227.7,110.97 227.7,112.52 227.38,112.85 227.38,113.43 227.3,113.51 227.05,113.51 226.97,113.43 v1(226.97,113.3) ; UV7.27 247.63,124.59 247.71,124.67 247.79,124.67 247.85,124.74 247.85,125.02 247.97,125.14 247.97,125.47 v1(247.88,125.56) 247.88,126.05 RV69.2 ; v1(227.96,113.31) 228.12,113.14 228.12,111.23 228.41,110.94 228.49,110.94 228.66,110.76 UV26.23
  IN1 w0.084: v1(226.97,113.3) 226.97,113.39 226.83,113.53 226.58,113.53 226.48,113.43 226.48,113.15 226.84,112.78 227.21,112.78 227.42,112.58 228.23,112.58 228.38,112.73 228.38,112.89 v1(227.96,113.31) 228.38,113.72 228.38,114.08 228.19,114.27 228.19,118.4 233.65,123.86 239.04,123.86 239.55,124.37 247.73,124.37 248.3,124.94 248.3,125.15 247.89,125.56 v1(247.88,125.56)
SW1_DP1_AUXP: length 43.8
  TOP w0.094: v1(228.54,113.31) 228.31,113.07 228.31,111.3 228.49,111.12 228.62,111.12 228.66,111.16 UV26.22 ; UV7.26 248.03,124.94 248.16,125.07 248.16,125.25 v1(248.47,125.56) 248.87,125.96 RV70.2 ; v1(226.97,113.88) 227.16,113.69 227.37,113.69 227.56,113.5 227.56,112.92 227.89,112.6 227.89,111.04 228.57,110.36 UV26.24
  IN1 w0.084: v1(226.97,113.88) 226.97,113.87 226.8,113.7 226.51,113.7 226.31,113.5 226.31,113.08 226.77,112.62 227.14,112.62 227.35,112.42 228.3,112.42 228.54,112.66 v1(228.54,113.31) 228.54,114.15 228.36,114.33 228.36,118.33 233.72,123.69 239.11,123.69 239.62,124.2 247.8,124.2 248.47,124.87 v1(248.47,125.56)
SW1_DP1_CADET: length 15.3
  TOP w0.102: UV7.43 v2(244.23,118.55) 243.66,118.55 v1(242.13,120.08) RV67.2 ; UV26.4 236.38,113.12 v1(236.55,113.29)
  IN1 w0.102: v1(242.13,120.08) 242.13,118.88 v1(236.55,113.29)
SW1_DP1_HPD: length 11.7
  TOP w0.102: v1(237.11,113.29) 236.78,112.97 UV26.3 ; UV7.48 v1(244.73,116.55) v2(244.22,116.55)
  IN1 w0.102: v1(237.11,113.29) 240.37,116.55 v1(244.73,116.55)
SW1_DP1_N0: length 12.7
  TOP w0.094: CV607.1 235.68,115.68 235.68,116.15 235.64,116.19 235.64,116.77 235.68,116.81 235.68,116.91 236.45,117.68 v5(237.89,117.68) 241.97,117.68 243.61,116.05 245.01,116.05 245.12,116.15 UV7.49
SW1_DP1_N0_C: length 2.7
  TOP w0.094: UV26.7 235.18,112.88 235.29,112.99 235.29,113.52 235.78,114.01 235.78,114.16 CV607.2
SW1_DP1_N1: length 14.9
  TOP w0.094: UV7.46 245.12,117.35 245.01,117.25 243.23,117.25 242.21,118.26 v5(235.54,118.26) 234.64,118.26 233.9,117.53 233.9,117.1 233.87,117.07 233.87,116.48 233.9,116.44 233.9,115.68 CV609.1
SW1_DP1_N1_C: length 2.5
  TOP w0.094: UV26.10 233.98,112.88 234.05,112.95 234.05,113.95 234.01,114 234.01,114.16 CV609.2
SW1_DP1_N2: length 16.9
  TOP w0.094: CV611.1 232.23,115.78 v5(232.23,116.85) 232.23,117.77 233.31,118.85 233.54,118.85 233.57,118.88 234.16,118.88 234.2,118.85 242.46,118.85 243.26,118.05 245.01,118.05 245.12,118.15 UV7.44
SW1_DP1_N2_C: length 2.7
  TOP w0.094: UV26.13 232.78,112.88 232.89,112.99 232.89,113.24 232.5,113.62 232.5,113.67 232.22,113.95 232.22,114.16 CV611.2
SW1_DP1_N3: length 21
  TOP w0.094: UV7.41 245.12,119.35 245.01,119.25 243.97,119.25 241.86,121.36 v5(236.84,121.36) 235.14,121.36 235.1,121.39 234.51,121.39 234.48,121.36 232.75,121.36 230.34,118.96 230.34,115.68 CV613.1
SW1_DP1_N3_C: length 3.4
  TOP w0.094: CV613.2 230.51,114.1 230.51,113.97 230.91,113.57 v5(231.24,113.57) 231.59,113.57 231.69,113.47 231.69,112.99 231.58,112.88 UV26.16
SW1_DP1_P0: length 12.7
  TOP w0.094: CV606.1 235.94,115.43 235.86,115.5 v5(235.86,116.48) 235.86,116.84 236.52,117.5 237.56,117.5 237.6,117.46 238.19,117.46 238.22,117.5 241.9,117.5 243.53,115.86 245.01,115.86 245.12,115.75 UV7.50
SW1_DP1_P0_C: length 2.7
  TOP w0.094: CV606.2 235.97,114.16 235.97,113.89 v5(235.66,113.58) 235.47,113.39 235.47,112.99 235.58,112.88 UV26.6
SW1_DP1_P1: length 14.9
  TOP w0.094: CV608.1 234.16,115.43 234.08,115.5 v5(234.08,116.77) 234.08,117.45 234.71,118.08 235.22,118.08 235.25,118.04 235.84,118.04 235.87,118.08 242.14,118.08 243.16,117.06 245.01,117.06 245.12,116.95 UV7.47
SW1_DP1_P1_C: length 2.5
  TOP w0.094: UV26.9 234.38,112.88 234.27,112.99 v5(234.27,113.51) 234.27,113.99 234.19,114.07 234.19,114.16 CV608.2
SW1_DP1_P2: length 16.6
  TOP w0.094: CV610.1 232.41,115.78 232.41,116.52 232.45,116.56 232.45,117.14 232.41,117.18 232.41,117.69 233.38,118.66 v5(233.87,118.66) 242.38,118.66 243.18,117.86 245.01,117.86 245.12,117.75 UV7.45
SW1_DP1_P2_C: length 2.7
  TOP w0.094: UV26.12 233.18,112.88 233.07,112.99 233.07,113.37 v5(232.86,113.57) 232.41,114.03 232.41,114.16 CV610.2
SW1_DP1_P3: length 21
  TOP w0.094: CV612.1 230.63,115.43 230.53,115.53 230.53,118.88 232.82,121.18 v5(234.81,121.18) 236.51,121.18 236.55,121.14 237.13,121.14 237.17,121.18 241.78,121.18 243.9,119.06 245.01,119.06 245.12,118.95 UV7.42
SW1_DP1_P3_C: length 3.3
  TOP w0.094: UV26.15 231.98,112.88 231.87,112.99 231.87,113.55 231.64,113.79 230.95,113.79 230.69,114.05 230.69,114.22 CV612.2
SW1_DP2_AUXN: length 39.3
  TOP w0.094: v1(246.38,125.43) 246.79,125.03 246.91,125.03 247.01,124.93 247.01,124.76 246.83,124.58 UV7.29
  IN1 w0.084: v1(246.38,125.43) 246.42,125.4 246.52,125.4 246.58,125.46 246.58,125.82 246.49,125.92 245.68,125.92 244.61,124.85 225.13,124.85 223.42,126.56 218.72,126.56 216.68,128.6 216.35,128.6 216.21,128.46 216.21,128.18 216.29,128.1 216.39,128.1 v1(216.43,128.14)
  BOTTOM w0.094: JMDP1.18 216.45,128.72 216.22,128.49 216.22,128.35 v1(216.43,128.14) 216.22,127.93 216.22,127.43 216.28,127.37 216.28,126.57 RV501.2
SW1_DP2_AUXP: length 39.3
  TOP w0.094: v1(246.96,125.43) 246.96,125.23 247.19,125.01 247.19,124.63 247.23,124.59 UV7.28
  IN1 w0.084: v1(246.96,125.43) 246.96,125.43 246.75,125.64 246.75,125.89 246.56,126.08 245.61,126.08 244.54,125.01 225.2,125.01 223.48,126.73 218.79,126.73 216.75,128.76 216.28,128.76 216.05,128.53 216.05,128.35 v1(215.84,128.14)
  BOTTOM w0.094: JMDP1.16 215.85,128.7 216.04,128.51 216.04,128.33 v1(215.84,128.14) 216.04,127.95 216.04,127.35 216.1,127.29 216.1,126.57 RV502.2
SW1_DP2_CADET: length 43.8
  TOP w0.102: v1(243.27,123.1) 243.69,122.68 RV68.2 244.04,122.55 UV7.33 ; v1(227.81,129.9) v2(228.34,129.9)
  IN1 w0.102: v1(227.81,129.9) 227.37,129.46 224.53,129.46 223.85,128.79 217.4,128.79 216.95,129.23 213.27,129.23 v1(212.25,128.21)
  BOTTOM w0.102: v1(243.27,123.1) 242.17,122 230.21,122 228.8,123.41 228.8,128.91 v1(227.81,129.9) ; v1(212.25,128.21) 212.25,128.21 JMDP1.4
SW1_DP2_HPD: length 44.2
  TOP w0.102: UV7.38 v1(244.77,120.55) ; v1(227.24,129.9) v2(226.64,129.9)
  IN1 w0.102: v1(211.65,128.2) 212.89,129.44 217.03,129.44 217.48,128.99 223.77,128.99 224.69,129.9 v1(227.24,129.9)
  BOTTOM w0.102: v1(227.24,129.9) 228.6,128.55 228.6,123.33 230.13,121.8 243.52,121.8 v1(244.77,120.55) ; v1(211.65,128.2) 211.65,128.2 JMDP1.2
SW1_DP2_N0: length 23.1
  TOP w0.094: CV508.2 225.2,124.76 226.89,124.76 229.58,122.07 v5(230.41,122.07) 232.48,122.07 232.52,122.11 233.11,122.11 233.14,122.07 241.98,122.07 244,120.05 245.01,120.05 245.12,120.15 UV7.39
SW1_DP2_N0_C: length 16.3
  TOP w0.094: CV508.1 223.67,124.88 222.88,124.88 221.63,126.12 217.29,126.12 217.26,126.16 216.67,126.16 216.64,126.12 216.29,126.12 v5(213.21,129.2) 212.8,129.61 212.8,132 212.75,132.05 JMDP1.5
SW1_DP2_N1: length 21
  TOP w0.094: CV506.2 227.35,126.05 227.91,126.05 227.95,126.08 228.54,126.08 228.57,126.05 228.98,126.05 230.18,124.85 235.4,124.85 237.36,122.89 v5(237.8,122.89) 241.98,122.89 243.63,121.25 245.01,121.25 245.12,121.35 UV7.36
SW1_DP2_N1_C: length 16
  TOP w0.094: CV506.1 226.08,126.04 225.98,125.94 222.67,125.94 221.9,126.71 218.76,126.71 217.91,127.56 217.91,127.61 217.49,128.03 217.44,128.03 v5(215.86,129.61) 214.42,131.05 214.42,132.26 JMDP1.11
SW1_DP2_N2: length 23.3
  TOP w0.094: CV504.2 225.19,127.32 228.56,127.32 230.44,125.43 233.36,125.43 233.4,125.47 233.98,125.47 234.02,125.43 236.79,125.43 238.54,123.69 v5(239.29,123.69) 242.01,123.69 243.65,122.05 245.01,122.05 245.12,122.15 UV7.34
SW1_DP2_N2_C: length 11.9
  TOP w0.094: CV504.1 223.92,127.31 223.82,127.21 222.65,127.21 222.28,127.58 v5(221.59,127.58) 220.21,127.58 220.18,127.62 219.59,127.62 219.56,127.58 218.89,127.58 216.08,130.39 216.08,130.75 216.21,130.88 216.84,130.88 216.98,131.01 216.98,131.4 216.89,131.49 JMDP1.17
SW1_DP2_N3: length 21.6
  TOP w0.094: CV502.2 227.35,128.59 228.11,128.59 230.55,126.15 236.92,126.15 238.55,124.51 240.55,124.51 240.58,124.55 241.17,124.55 241.21,124.51 v5(242.87,124.51) 244.24,124.51 244.68,124.07 244.68,123.44 244.87,123.25 245.07,123.25 245.17,123.35 UV7.31
SW1_DP2_N3_C: length 22.5
  TOP w0.094: v1(225.4,128.79) 225.6,128.59 225.73,128.59 CV502.1
  BOTTOM w0.094: v1(225.4,128.79) 225.21,128.6 224.81,128.6 224.39,128.18 224.39,124.65 223.67,123.93 223.17,123.93 223.14,123.89 221.74,123.89 220.83,122.98 216.11,122.98 214.23,124.86 214.23,128.47 214.32,128.56 214.57,128.56 214.65,128.63 JMDP1.12
SW1_DP2_P0: length 23.1
  TOP w0.094: CV507.2 225.18,124.58 226.82,124.58 229.51,121.89 230.08,121.89 230.12,121.85 230.71,121.85 230.74,121.89 v5(232.81,121.89) 241.9,121.89 243.93,119.86 245.01,119.86 245.12,119.75 UV7.40
SW1_DP2_P0_C: length 16.3
  TOP w0.094: CV507.1 224.17,124.48 224.17,124.61 224.08,124.7 222.8,124.7 221.56,125.94 v5(216.96,125.94) 216.21,125.94 213.31,128.84 213.26,128.84 212.85,129.26 212.85,129.31 212.62,129.54 212.62,130.84 212.54,130.91 212.32,130.91 212.25,130.97 JMDP1.3
SW1_DP2_P1: length 21
  TOP w0.094: UV7.37 245.12,120.95 245.01,121.06 243.55,121.06 241.91,122.71 238.13,122.71 238.1,122.67 237.51,122.67 237.48,122.71 237.29,122.71 235.33,124.67 230.1,124.67 228.9,125.86 v5(228.24,125.86) 227.35,125.86 CV505.2
SW1_DP2_P1_C: length 16
  TOP w0.094: CV505.1 225.83,125.76 222.6,125.76 221.83,126.53 218.69,126.53 v5(217.54,127.67) 215.96,129.25 215.91,129.25 215.5,129.66 215.5,129.72 214.23,130.98 214.23,132.31 JMDP1.9
SW1_DP2_P2: length 23.3
  TOP w0.094: CV503.2 225.19,127.13 228.48,127.13 230.37,125.25 v5(233.69,125.25) 236.72,125.25 238.46,123.5 238.96,123.5 239,123.47 239.58,123.47 239.62,123.5 241.93,123.5 243.57,121.86 245.01,121.86 245.12,121.75 UV7.35
SW1_DP2_P2_C: length 11.9
  TOP w0.094: JMDP1.15 215.95,132.01 215.9,131.96 215.9,130.32 218.82,127.4 v5(219.89,127.4) 221.26,127.4 221.29,127.36 221.88,127.36 221.92,127.4 222.21,127.4 222.58,127.03 223.67,127.03 CV503.1
SW1_DP2_P3: length 21.6
  TOP w0.094: UV7.32 245.18,122.95 245.07,123.06 244.79,123.06 244.49,123.36 244.49,124 244.16,124.33 243.2,124.33 243.17,124.29 242.58,124.29 242.54,124.33 v5(240.88,124.33) 238.47,124.33 236.84,125.96 230.47,125.96 228.03,128.4 227.35,128.4 CV501.2
SW1_DP2_P3_C: length 22.5
  TOP w0.094: CV501.1 225.73,128.4 225.6,128.4 v1(225.4,128.2)
  BOTTOM w0.094: v1(225.4,128.2) 225.18,128.42 224.89,128.42 224.58,128.11 224.58,124.58 223.71,123.71 v5(223.47,123.71) 221.82,123.71 220.9,122.79 216.04,122.79 214.05,124.78 JMDP1.10
SW1_DP2_P14: length 3.5
  BOTTOM w0.102: RV503.2 212.85,126.25 v2(212.85,127.26) JMDP1.6
SW1_PS8338_CFG0: length 3.3
  TOP w0.102: UV7.59 249.63,114.7 249.93,114.41 250.12,114.41 250.51,114.01 250.51,112.86 RV51.2
SW1_PS8338_P0: length 4.7
  TOP w0.102: UV7.60 250.03,114.78 250.29,114.52 250.61,114.52 250.8,114.33 250.8,112.2 250.08,111.48 RV60.2
SW1_PS8338_P1: length 5.8
  TOP w0.102: UV7.1 251.37,115.75 251.92,115.2 v2(251.92,114.83) 251.92,113.09 RV100.1 RV53.2
SW1_PS8338_PC10: length 4.6
  TOP w0.102: UV7.56 248.43,114.03 248.69,113.78 RV65.1 249.12,113.33 249.58,112.87 249.58,111.58 RV58.2
SW1_PS8338_PC11: length 4.7
  TOP w0.102: RV57.2 248.56,111.58 248.56,112.81 248.11,113.26 RV63.1 247.64,113.81 247.64,114.1 248.03,114.49 UV7.55
SW1_PS8338_PC20: length 4.5
  TOP w0.102: UV7.54 247.63,114.52 247.44,114.33 247.44,113.69 RV64.1 247.09,113.33 247.55,112.87 247.55,111.58 RV56.2
SW1_PS8338_PC21: length 6
  TOP w0.102: v2(245.11,111.12) RV55.2 246.14,111.55 245.71,111.98 245.71,112.91 RV62.1 246.55,113.75 246.9,113.75 247.23,114.08 UV7.53
SW1_PS8338_PEQ: length 8.2
  TOP w0.102: v2(253.96,113.7) v1(253.96,114.36) RV54.2 RV61.1 ; UV7.8 v1(251.69,118.55)
  IN4 w0.102: v1(253.96,114.36) 253.96,116.28 v1(251.69,118.55)
SW1_PS8338_SW: length 5
  TOP w0.102: v2(255.01,124.24) 254.81,124.04 RV52.2 253.48,123.54 252.64,123.54 251.65,122.55 UV7.18
SW2_DP1_AUXN: length 86.3
  TOP w0.094: v1(248.03,53.62) 248.33,53.31 248.33,53.04 248.23,52.94 CV150.1 ; RV605.2 227.35,109.99 227.47,109.99 v1(227.67,109.79) 227.8,109.91 227.91,109.91 228.66,109.16 UV26.27
  IN2 w0.122: v1(227.67,109.79) 228.04,110.16 228.75,110.16 229.68,109.23 231.89,109.23 234.25,106.87 235.44,106.87 236.4,105.91 236.4,104.55 238.32,102.62 241.96,102.62 249.54,95.04 249.54,90.01 249.03,89.5 249.03,87.08 249.54,86.57 249.54,83.41 249.39,83.26 245.3,83.26 244.71,82.67 244.71,82.15 243.47,80.91 243.47,74.25 242.97,73.76 242.97,71.13 243.45,70.65 243.45,64.81 244.42,63.84 244.42,58.92 243.22,57.72 243.22,56.31 243.05,56.14 243.05,54.89 244.03,53.91 247.14,53.91 247.48,54.25 248,54.25 248.19,54.06 248.19,53.78 v1(248.03,53.62)
SW2_DP1_AUXN_C: length 2.8
  TOP w0.094: CV150.2 248.22,51.68 248.22,51.4 248.31,51.31 v1(248.31,50.98)
  BOTTOM w0.094: JNGFF1.12 248.35,51.53 248.45,51.43 248.45,51.12 v1(248.31,50.98)
SW2_DP1_AUXP: length 86.1
  TOP w0.094: UV26.26 228.52,109.56 227.99,110.1 227.94,110.1 v1(227.67,110.37) 227.47,110.17 227.35,110.17 RV609.2 ; CV149.1 248.52,53.19 248.52,53.52 v1(248.61,53.62)
  IN2 w0.122: v1(227.67,110.37) 228.84,110.37 229.77,109.44 231.98,109.44 234.34,107.08 235.53,107.08 236.61,106 236.61,104.64 238.41,102.84 242.05,102.84 249.76,95.13 249.76,89.92 249.25,89.41 249.25,87.17 249.76,86.66 249.76,83.32 249.48,83.04 245.39,83.04 244.93,82.58 244.93,82.06 243.69,80.82 243.69,74.16 243.19,73.67 243.19,71.22 243.67,70.74 243.67,64.9 244.64,63.93 244.64,58.83 243.43,57.63 243.43,56.22 243.27,56.05 243.27,54.97 244.12,54.12 247.05,54.12 247.39,54.47 248.09,54.47 248.41,54.15 248.41,53.82 v1(248.61,53.62)
SW2_DP1_AUXP_C: length 3
  TOP w0.094: v1(248.89,50.98) 248.4,51.47 248.4,51.66 CV149.2
  BOTTOM w0.094: JNGFF1.14 248.85,51.6 248.63,51.39 248.63,51.25 v1(248.89,50.98)
SW2_DP1_CADET: length 8.4
  TOP w0.102: UV26.43 v1(234.78,106.35) ; v2(240.31,104.34) RV606.2 239.44,105.32 v1(239.43,105.33)
  BOTTOM w0.102: v1(234.78,106.35) 235.32,106.89 238.11,106.89 239.43,105.57 v1(239.43,105.33)
SW2_DP1_HPD: length 77.1
  TOP w0.102: UV26.48 v1(236.78,106.41)
  IN2 w0.102: v1(238.5,84.15) 239.21,83.43 239.21,78.88 237.96,77.62 237.96,74.13 238.11,73.97 238.11,73.43 237.7,73.02 237.7,71.82 238.11,71.41 238.11,67.34 237.92,67.15 237.92,63.4 238.26,63.07 238.26,62.09 238.76,61.58 238.76,59.4 238.19,58.82 238.19,57.16 239.42,55.93 239.42,55.25 239,54.83 239,54.33 241.2,52.13 244.56,52.13 v1(247.62,49.07)
  IN3 w0.102: v1(236.78,106.41) 236.67,106.31 236.67,101.52 v1(238.24,99.96) 238.24,96.71 235.72,94.19 235.72,86.02 237.2,84.54 238.11,84.54 v1(238.5,84.15)
  BOTTOM w0.102: v1(247.62,49.07) 250.66,49.07 251.1,48.63 JNGFF1.23
SW2_DP1_N0: length 73.2
  TOP w0.094: UV26.49 237.18,106.7 237.3,106.58 237.3,106.41 237.62,106.09 238.3,106.09 238.48,105.91 238.48,105.55 v1(238.28,105.35) ; CV156.1 251.58,53.09 251.58,53.59 v1(251.23,53.95)
  IN2 w0.122: v1(251.23,53.95) 251.38,54.1 251.38,54.3 249.98,55.7 246.28,55.7 245.71,56.27 245.71,57.05 246.09,57.43 246.09,58.91 245.71,59.29 245.71,64.41 245.23,64.89 245.23,70.07 244.75,70.55 244.75,71.33 245.06,71.64 245.06,73.9 244.75,74.2 244.75,80.08 245.66,80.99 249.58,80.99 250.83,82.23 250.83,95.67 242.57,103.93 239.04,103.93 238.49,104.48 238.49,105.14 v1(238.28,105.35)
SW2_DP1_N0_C: length 3
  TOP w0.094: CV156.2 251.67,51.79 251.67,51.64 251.49,51.46 251.49,51.14 v1(251.27,50.92)
  BOTTOM w0.094: v1(251.27,50.92) 251.51,51.16 251.51,51.37 251.35,51.53 JNGFF1.24

# Allegro board LAC451PR10-0923B.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR_A_D1: length 76.5
  IN1 w0.084: v1(84.15,46.52) 83.77,46.9 83.77,48.36 85.89,50.49 85.89,51.94 122.45,88.49 128.93,88.49 130.95,86.47 v1(132.16,86.47)
  BOTTOM w0.076: UC1.AL68 135.39,86.75 135.19,86.55 134.67,86.55 134.52,86.47 134.33,86.47 134.18,86.53 134.03,86.53 133.81,86.47 133.7,86.47 133.62,86.5 133.59,86.51 133.08,86.51 132.84,86.27 132.36,86.27 v1(132.16,86.47)
  BOTTOM w0.102: JDIMM1.3 83.88,48.97 83.72,48.82 83.72,46.94 v1(84.15,46.52)
DDR_A_D2: length 77.7
  IN1 w0.076: v1(127.53,84.46) 127.53,81.86 127.36,81.69
  IN1 w0.084: v1(87.29,46.49) 88.2,47.41 88.2,48.34 90.48,50.62 90.48,52.18 103.79,65.49 104.17,65.49 104.25,65.58 104.25,65.95 104.35,66.05 104.49,66.05 104.59,65.95 104.59,65.58 104.67,65.49 104.84,65.49 104.92,65.58 104.92,65.96 105.02,66.06 105.16,66.06 105.26,65.96 105.26,65.58 105.34,65.49 105.59,65.49 106.04,65.95 106.04,66.07 105.72,66.39 105.72,66.53 105.82,66.63 105.96,66.63 106.28,66.31 106.4,66.31 106.52,66.42 106.52,66.54 106.19,66.87 106.19,67.01 106.29,67.11 106.43,67.11 106.76,66.78 106.87,66.78 106.99,66.9 106.99,67.02 106.65,67.36 106.65,67.5 106.74,67.6 106.88,67.6 107.23,67.25 107.35,67.25 115.4,75.31 117.37,75.31 119.27,77.21 125.2,77.21 127.36,79.37 127.36,81.69
  BOTTOM w0.076: v1(127.53,84.46) 127.99,84.46 128.6,85.07 131.19,85.07 131.72,85.61 133.11,85.61 133.15,85.65 134.08,85.65 134.32,85.89 134.81,85.89 135.39,86.18 UC1.AN68
  BOTTOM w0.102: v1(87.29,46.49) 88.37,47.58 JDIMM1.21
DDR_A_D3: length 76.5
  IN1 w0.076: v1(126.45,85.54) 126.38,85.62 122.51,85.62 122.07,85.18
  IN1 w0.084: v1(87.29,43.45) 86.61,44.12 86.61,48.3 88.8,50.48 88.8,51.91 104.86,67.97 105.66,67.97 111.35,73.66 111.47,73.66 111.79,73.34 111.93,73.34 112.02,73.44 112.02,73.58 111.71,73.89 111.71,74.01 111.83,74.13 111.95,74.13 112.27,73.8 112.41,73.8 112.51,73.9 112.51,74.04 112.18,74.37 112.18,74.49 112.3,74.61 112.42,74.61 112.75,74.28 112.89,74.28 112.99,74.38 112.99,74.51 112.66,74.84 112.66,74.96 112.78,75.08 112.89,75.08 113.2,74.78 113.34,74.78 113.43,74.88 113.43,75.01 113.13,75.32 113.13,75.44 113.39,75.69 113.39,76.49 122.07,85.18
  BOTTOM w0.076: v1(126.45,85.54) 126.48,85.57 130.93,85.57 131.46,86.1 132.91,86.1 133.15,86.35 133.55,86.35 133.67,86.29 133.69,86.29 133.7,86.29 133.71,86.29 133.81,86.29 134.04,86.36 134.17,86.36 134.39,86.28 134.64,86.28 UC1.AN69
  BOTTOM w0.102: v1(87.29,43.45) 87.13,43.29 JDIMM1.16
DDR_A_D4: length 76.6
  IN1 w0.084: v1(129.05,86.39) 127.56,87.89 122.71,87.89 111.92,77.1 111.92,76.29 109.27,73.64 108.45,73.64 108.31,73.51 108.31,73.39 108.6,73.11 108.6,72.97 108.5,72.87 108.36,72.87 108.08,73.15 107.96,73.15 102.91,68.1 86.49,51.69 86.49,50.24 85.15,48.9 84.57,48.31 84.57,45.41 v1(84.15,45)
  BOTTOM w0.076: UC1.AL70 133.94,87.41 133.77,87.58 133.64,87.64 133.53,87.67 133.29,87.67 133.17,87.55 131.86,87.55 131.54,87.22 129.89,87.22 v1(129.05,86.39)
  BOTTOM w0.102: JDIMM1.4 84.13,42.72 83.77,43.07 83.77,44.61 v1(84.15,45)
DDR_A_D5: length 77.4
  IN1 w0.084: v1(84.15,43.47) 84.87,44.19 84.87,48.19 86.79,50.12 86.79,51.54 106.77,71.52 106.89,71.52 107.09,71.32 107.22,71.32 107.32,71.42 107.32,71.56 107.13,71.75 107.13,71.87 107.24,71.99 107.36,71.99 107.57,71.79 107.71,71.79 107.8,71.89 107.8,72.03 107.6,72.23 107.6,72.35 107.82,72.57 108.62,72.57 112.23,76.17 112.23,76.98 122.83,87.58 127.21,87.58 v1(128.4,86.39)
  BOTTOM w0.076: v1(128.4,86.39) 129.4,87.39 131.47,87.39 131.79,87.72 133.07,87.72 133.2,87.85 133.5,87.85 133.58,87.83 133.64,87.81 133.71,87.8 133.79,87.79 133.91,87.75 133.92,87.75 134.1,87.67 134.27,87.67 134.54,87.41 UC1.AL69
  BOTTOM w0.102: JDIMM1.8 85.13,42.49 v1(84.15,43.47)
DDR_A_D6: length 75.7
  IN1 w0.076: 127.06,81.69 127.16,81.79 127.16,84.63 127.45,84.92 v1(127.91,84.92)
  IN1 w0.084: 127.06,81.69 127.06,79.5 125.07,77.51 119.15,77.51 117.37,75.73 115.4,75.73 110.38,70.71 110.26,70.71 109.89,71.09 109.77,71.09 109.65,70.97 109.65,70.85 110.03,70.48 110.03,70.36 109.91,70.24 109.79,70.24 109.42,70.61 109.3,70.61 109.18,70.49 109.18,70.37 109.55,70 109.55,69.88 109.43,69.76 109.32,69.76 108.94,70.14 108.82,70.14 108.7,70.02 108.7,69.9 109.08,69.53 109.08,69.41 108.96,69.29 108.84,69.29 108.47,69.66 108.35,69.66 108.23,69.54 108.23,69.43 108.6,69.05 108.6,68.93 108.48,68.81 108.37,68.81 107.99,69.19 107.87,69.19 107.76,69.07 107.76,68.95 108.13,68.58 108.13,68.46 108.01,68.34 107.89,68.34 107.52,68.71 107.4,68.71 107.28,68.59 107.28,68.48 107.65,68.1 107.65,67.98 107.54,67.87 107.42,67.87 107.04,68.24 106.93,68.24 106.05,67.37 105.23,67.37 89.5,51.64 89.5,50.24 v1(87.29,48.02)
  BOTTOM w0.076: UC1.AN70 133.83,85.81 133.08,85.81 133.04,85.77 131.65,85.77 131.12,85.24 128.23,85.24 v1(127.91,84.92)
  BOTTOM w0.102: v1(87.29,48.02) 87.37,48.11 JDIMM1.17
DDR_A_D7: length 74.9
  IN1 w0.076: v1(126.99,85.08) 126.39,85.08 126.02,85.45 122.77,85.45 122.07,84.75
  IN1 w0.084: v1(87.29,44.97) 86.91,45.34 86.91,48.17 89.2,50.46 89.2,51.89 104.99,67.67 105.79,67.67 109.92,71.8 110.04,71.8 110.38,71.46 110.5,71.46 110.62,71.58 110.62,71.7 110.28,72.04 110.28,72.15 110.4,72.27 110.52,72.27 110.85,71.94 110.97,71.94 111.09,72.06 111.09,72.18 110.76,72.51 110.76,72.63 110.87,72.75 110.99,72.75 111.33,72.41 111.45,72.41 111.57,72.53 111.57,72.65 111.23,72.98 111.23,73.1 111.35,73.22 111.47,73.22 111.8,72.89 111.92,72.89 114.38,75.35 114.38,77.06 122.07,84.75
  BOTTOM w0.076: UC1.AN71 133.12,86.08 132.97,85.94 131.56,85.94 131.03,85.4 127.31,85.4 v1(126.99,85.08)
  BOTTOM w0.102: v1(87.29,44.97) 88.13,44.13 JDIMM1.20
DDR_A_D8: length 76
  IN1 w0.076: 127.85,83.03 127.85,81.69
  IN1 w0.084: v1(90.09,43.45) 89.82,43.45 89.39,43.88 89.03,43.88 88.95,43.96 88.95,44.13 89.03,44.21 89.27,44.21 89.35,44.3 89.35,44.46 89.27,44.55 89.03,44.55 88.95,44.63 88.95,44.8 89.03,44.88 89.27,44.88 89.35,44.97 89.35,45.13 89.27,45.22 88.97,45.22 88.88,45.3 88.88,45.47 88.97,45.55 89.27,45.55 89.35,45.64 89.35,45.8 89.27,45.89 88.97,45.89 88.88,45.97 88.88,46.14 88.97,46.22 89.27,46.22 89.35,46.31 89.35,46.47 89.27,46.56 88.97,46.56 88.88,46.64 88.88,46.81 88.97,46.89 89.27,46.89 89.35,46.98 89.35,47.14 89.27,47.23 88.97,47.23 88.88,47.31 88.88,47.48 88.97,47.56 89.27,47.56 89.35,47.65 89.35,48.81 90.97,50.42 90.97,51.39 91.51,51.93 91.51,52.36 104.15,65 105.79,65 115.61,74.82 117.57,74.82 119.48,76.72 125.4,76.72 127.85,79.17 127.85,81.69 ; v1(128.38,84.21) 128.45,84.14 128.45,83.62 127.85,83.03
  BOTTOM w0.076: UC1.AR70 133.94,85.05 133.68,85.32 133.29,85.32 133.25,85.28 132.01,85.28 131.48,84.74 129.59,84.74 129.33,84.49 129.33,84.06 129.12,83.84 128.75,83.84 v1(128.38,84.21)
  BOTTOM w0.102: JDIMM1.28 90.13,43.41 v1(90.09,43.45)
DDR_A_D9: length 77.5
  IN1 w0.076: 128.15,82.32 128.15,82.74
  IN1 w0.084: 128.15,82.32 128.15,79.05 125.53,76.42 119.6,76.42 117.7,74.52 115.73,74.52 105.4,64.19 105.26,64.19 104.75,64.7 104.61,64.7 104.51,64.6 104.51,64.47 105.02,63.95 105.02,63.84 104.9,63.72 104.78,63.72 104.26,64.24 104.12,64.24 104.02,64.14 104.02,64 104.55,63.48 104.55,63.36 104.43,63.24 104.31,63.24 103.62,63.93 103.51,63.93 91.81,52.23 91.81,50.84 89.65,48.68 89.65,45.41 v1(90.09,44.97) ; 128.15,82.74 128.96,83.55 v1(128.96,84.22)
  BOTTOM w0.076: UC1.AR68 134.86,85.24 134.32,85.24 134.08,85.48 133.22,85.48 133.18,85.44 131.91,85.44 131.37,84.91 129.4,84.91 128.96,84.48 v1(128.96,84.22)
  BOTTOM w0.102: JDIMM1.24 89.13,42.83 89.02,42.93 88.85,42.93 88.73,43.05 88.73,43.22 88.85,43.34 89.02,43.34 89.13,43.44 89.13,43.64 89.02,43.75 88.85,43.75 88.73,43.86 88.73,44.03 88.85,44.15 89.02,44.15 89.13,44.25 89.13,44.6 89.5,44.97 v1(90.09,44.97)
DDR_A_D10: length 74.2
  IN1 w0.084: v1(92.63,43.45) 93.05,43.86 94.52,43.86 94.73,43.66 94.73,43.09 94.58,42.94 94.35,42.94 94.26,43.03 94.26,43.48 94.17,43.58 94.03,43.58 93.93,43.48 93.93,43.03 93.84,42.94 93.68,42.94 93.59,43.03 93.59,43.48 93.49,43.58 93.36,43.58 93.26,43.48 93.26,43.03 93.17,42.94 92.16,42.94 91.96,43.15 91.96,48.39 94.9,51.33 94.9,51.76 102.52,59.38 103.1,59.38 107.16,63.44 107.16,63.46 116,72.3 116.46,72.76 118.43,72.76 120.33,74.66 126.31,74.66 130.08,78.44 130.08,81.2 130.45,81.56 v1(130.45,81.73)
  BOTTOM w0.076: UC1.AU71 133.34,83.62 132.33,83.62 130.45,81.74 v1(130.45,81.73)
  BOTTOM w0.102: v1(92.63,43.45) 92.62,43.44 92.62,43.25 92.73,43.15 93.2,43.15 93.3,43.05 93.3,42.85 93.2,42.75 92.73,42.75 92.62,42.64 JDIMM1.38
DDR_A_D11: length 76.4
  IN1 w0.084: v1(130.83,83.46) 130.83,81.47 130.4,81.03 130.4,78.32 126.44,74.36 126.31,74.36 126.22,74.28 126.22,74.03 126.12,73.93 125.99,73.93 125.89,74.03 125.89,74.28 125.8,74.36 125.64,74.36 125.55,74.28 125.55,73.72 125.45,73.62 125.32,73.62 125.22,73.72 125.22,74.28 125.13,74.36 124.97,74.36 124.88,74.28 124.88,73.72 124.78,73.62 124.65,73.62 124.55,73.72 124.55,74.28 124.46,74.36 124.3,74.36 124.21,74.28 124.21,73.72 124.11,73.62 123.97,73.62 123.88,73.72 123.88,74.28 123.79,74.36 123.62,74.36 123.54,74.28 123.54,73.96 123.44,73.86 123.3,73.86 123.21,73.96 123.21,74.28 123.12,74.36 120.45,74.36 118.55,72.46 116.61,72.46 103.22,59.08 102.64,59.08 95.2,51.63 95.2,51.2 92.26,48.26 92.26,45.34 v1(92.63,44.97)
  BOTTOM w0.076: UC1.AU68 135.39,84.48 135.19,84.68 134.95,84.68 134.92,84.66 134.33,84.66 134.18,84.6 134.03,84.6 133.81,84.67 133.7,84.67 133.62,84.63 133.59,84.62 133.22,84.62 133.06,84.78 132.48,84.78 131.16,83.46 v1(130.83,83.46)
  BOTTOM w0.102: JDIMM1.42 93.62,43.08 93.73,43.19 93.99,43.19 94.1,43.31 94.1,43.47 93.99,43.59 93.73,43.59 93.62,43.69 93.62,43.9 93.73,44 94.04,44 94.16,44.12 94.16,44.29 94.04,44.41 93.2,44.41 v1(92.63,44.97)
DDR_A_D12: length 74.5
  IN1 w0.084: v1(129.7,84.21) 129.7,83.62 128.45,82.36 128.45,78.92 125.65,76.12 119.72,76.12 117.82,74.22 115.85,74.22 104.4,62.76 104.28,62.76 103.58,63.46 103.46,63.46 103.34,63.34 103.34,63.22 104.04,62.52 104.04,62.4 103.92,62.29 103.8,62.29 103.11,62.98 102.99,62.98 102.87,62.86 102.87,62.74 103.57,62.05 103.57,61.93 103.47,61.83 103.33,61.83 102.64,62.52 102.52,62.52 102.4,62.4 102.4,62.28 103.09,61.59 103.09,61.46 102.99,61.36 102.85,61.36 102.17,62.05 102.05,62.05 101.93,61.93 101.93,61.81 102.62,61.12 102.62,60.98 102.52,60.88 102.38,60.88 101.69,61.57 101.57,61.57 101.45,61.45 101.45,61.33 101.85,60.94 101.85,60.82 101.73,60.7 101.61,60.7 101.22,61.1 101.1,61.1 92.11,52.11 92.11,50.72 90.09,48.7 v1(90.09,48.02)
  BOTTOM w0.076: v1(129.7,84.21) 130.07,84.58 131.58,84.58 132.11,85.11 133.38,85.11 UC1.AR71
  BOTTOM w0.102: v1(90.09,48.02) 90.37,48.3 JDIMM1.29
DDR_A_D13: length 76
  IN1 w0.084: v1(90.09,46.49) 90.8,47.2 90.8,48.98 92.42,50.6 92.42,51.88 98.63,58.09 98.74,58.09 99.05,57.79 99.18,57.79 99.28,57.88 99.28,58.02 98.94,58.37 98.94,58.51 99.03,58.61 99.17,58.61 99.57,58.21 99.71,58.21 99.81,58.31 99.81,58.45 99.41,58.84 99.41,58.98 99.51,59.08 99.65,59.08 100.05,58.68 100.18,58.68 100.28,58.78 100.28,58.92 99.88,59.32 99.88,59.46 99.98,59.56 100.12,59.56 100.52,59.16 100.66,59.16 100.76,59.26 100.76,59.37 100.35,59.78 100.35,59.92 100.45,60.02 100.59,60.02 100.99,59.62 101.12,59.62 101.22,59.72 101.22,59.86 100.82,60.26 100.82,60.4 100.92,60.5 101.06,60.5 101.47,60.09 101.59,60.09 102.04,60.54 102.6,60.54 115.98,73.92 117.95,73.92 119.85,75.82 125.77,75.82 128.75,78.8 128.75,81.96 v1(131,84.21)
  BOTTOM w0.076: v1(131,84.21) 131.65,84.21 131.81,84.37 132.39,84.95 133.13,84.95 133.29,84.78 133.55,84.78 133.67,84.84 133.69,84.84 133.7,84.84 133.71,84.84 133.81,84.84 134.04,84.78 134.17,84.78 134.39,84.85 134.64,84.85 UC1.AR69
  BOTTOM w0.102: JDIMM1.25 89.37,48.7 89.27,48.6 89.1,48.6 88.98,48.48 88.98,48.31 89.1,48.19 89.27,48.19 89.37,48.09 89.37,47.88 89.27,47.78 89.1,47.78 88.98,47.66 88.98,47.49 89.1,47.38 89.27,47.38 89.37,47.27 89.37,46.75 89.63,46.49 v1(90.09,46.49)
DDR_A_D14: length 74.7
  IN1 w0.084: v1(131.41,81.93) 131.41,78.47 129.11,76.17 129.11,73.97 127.77,72.62 126.57,72.62 126.16,73.02 123.29,73.02 122.55,73.76 122.04,73.76 121.96,73.68 121.96,73.12 121.86,73.02 121.72,73.02 121.62,73.12 121.62,73.68 121.54,73.76 120.7,73.76 120.53,73.59 120.53,73.47 120.74,73.26 120.74,73.12 120.64,73.02 120.5,73.02 120.29,73.23 120.17,73.23 118.8,71.86 116.86,71.86 103.48,58.48 102.89,58.48 96.61,52.2 96.61,51.26 94.28,48.93 94.28,48.07 94.2,47.99 93.45,47.99 93.37,47.9 93.37,47.74 93.45,47.65 94.2,47.65 94.28,47.57 94.28,47.4 94.2,47.32 93.45,47.32 93.37,47.23 93.37,47.06 93.45,46.98 94.2,46.98 94.28,46.9 94.28,46.73 94.2,46.65 93.45,46.65 93.37,46.56 93.37,46.39 93.45,46.31 94.2,46.31 94.28,46.23 94.28,46.06 94.2,45.98 93.15,45.98 v1(92.63,46.49)
  BOTTOM w0.076: UC1.AU70 133.81,83.45 132.4,83.45 131.41,82.45 v1(131.41,81.93)
  BOTTOM w0.102: v1(92.63,46.49) 93.37,47.24 JDIMM1.41
DDR_A_D15: length 75.2
  IN1 w0.084: v1(92.63,48.02) 92.63,48.21 92.96,48.54 93.08,48.54 93.33,48.29 93.47,48.29 93.56,48.38 93.56,48.52 93.31,48.77 93.31,48.89 93.43,49.01 93.55,49.01 93.75,48.82 93.88,48.82 93.98,48.91 93.98,49.05 93.79,49.25 93.79,49.37 95.5,51.08 95.5,51.51 102.77,58.78 103.35,58.78 104.3,59.72 116.74,72.16 118.68,72.16 120.58,74.06 122.68,74.06 123.42,73.32 125.85,73.32 126.15,73.63 126.39,73.63 127.1,72.92 127.24,72.92 127.34,73.02 127.34,73.16 126.57,73.93 126.57,74.04 126.69,74.16 126.8,74.16 127.78,73.19 127.92,73.19 128.01,73.29 128.01,73.43 127.04,74.4 127.04,74.52 127.16,74.64 127.28,74.64 128.25,73.67 128.39,73.67 128.49,73.76 128.49,73.9 127.52,74.88 127.52,74.99 127.63,75.11 127.75,75.11 128.58,74.29 128.72,74.29 128.81,74.39 128.81,74.53 127.99,75.35 127.99,75.47 128.11,75.59 128.23,75.59 128.58,75.24 128.72,75.24 128.81,75.34 128.81,75.47 128.46,75.82 128.46,75.94 129.49,76.97 130.82,78.29 v1(130.82,80.81)
  BOTTOM w0.076: UC1.AU69 134.54,83.73 134.16,83.34 133.97,83.34 133.9,83.26 132.46,83.26 131.78,82.59 131.78,81.51 131.08,80.81 v1(130.82,80.81)
  BOTTOM w0.102: v1(92.63,48.02) 92.37,48.28 JDIMM1.37
DDR_A_D16: length 59.7
  IN4 w0.076: 130.59,85.39 130.59,85.43 134.65,89.48 ; v1(137.66,89.29) 137.03,89.93 135.43,89.93 ; 135.42,89.93 135.09,89.93 134.66,89.49
  IN4 w0.084: v1(134.27,43.45) 132.6,45.12 132.6,49.97 131.83,50.73 131.83,51.46 129.44,53.85 129.44,54.58 126.45,57.57 126.45,79.55 127.63,80.74 127.63,83.99 128.25,84.61 129.81,84.61 130.59,85.39 ; 135.43,89.93 135.42,89.93 ; 134.66,89.49 134.65,89.48
  BOTTOM w0.076: UC1.AF65 v1(137.66,89.29)
  BOTTOM w0.102: v1(134.27,43.45) 134.27,43.33 133.63,42.69 JDIMM1.194
DDR_A_D17: length 57.8
  IN4 w0.076: v1(138.29,89.29) 137.91,88.91 135.75,88.91 135.39,88.56 135.39,87.71 133.85,86.16 133.85,84.39 133.24,83.78 132.19,83.78 131.2,82.79 130.59,82.79
  IN4 w0.084: v1(134.27,48.02) 134.27,48.84 134.17,48.94 133.6,48.94 133.5,49.04 133.5,49.21 133.6,49.31 134.17,49.31 134.27,49.41 134.27,49.56 134.17,49.66 133.6,49.66 133.5,49.76 133.5,50.34 132.73,51.1 132.73,52.56 128.43,56.86 128.43,56.99 128.7,57.26 128.7,57.4 128.6,57.5 128.46,57.5 128.19,57.23 128.07,57.23 127.95,57.35 127.95,57.47 128.24,57.75 128.24,57.87 128.12,57.99 128,57.99 127.72,57.7 127.6,57.7 127.48,57.82 127.48,57.94 127.77,58.23 127.77,58.33 127.36,58.74 127.36,79.19 128.7,80.53 128.7,81.97 129.51,82.79 130.59,82.79
  BOTTOM w0.076: UC1.AF64 v1(138.29,89.29)
  BOTTOM w0.102: v1(134.27,48.02) 133.88,48.42 JDIMM1.195
DDR_A_D18: length 58.3
  IN4 w0.076: 129.56,77.67 129.56,78.16 132.14,80.73 132.14,81.03 132.35,81.24 132.35,81.93 132.5,82.08 133.06,82.08 135.57,84.59 135.57,86.47 136.01,86.91 137.11,86.91 v1(137.66,87.46)
  IN4 w0.084: 129.56,77.67 129.56,60.89 130.82,59.64 130.82,59.52 130.25,58.95 130.25,58.82 130.35,58.72 130.49,58.72 131.05,59.28 131.19,59.28 131.29,59.18 131.29,59.04 130.76,58.51 130.76,58.39 136.96,52.19 136.96,51.14 136.84,51.01 136.29,51.01 136.18,50.91 136.18,50.73 136.29,50.63 136.84,50.63 136.96,50.5 136.96,50.23 137.51,49.68 137.51,43.67 137.29,43.45 v1(136.81,43.45)
  BOTTOM w0.076: UC1.AK65 v1(137.66,87.46)
  BOTTOM w0.102: v1(136.81,43.45) 136.81,43.31 136.12,42.62 JDIMM1.204
DDR_A_D19: length 59.9
  IN4 w0.076: 130.59,80.32 131.01,80.32 131.64,80.94 131.64,81.25 131.86,81.47 131.86,82.5 132.54,83.19 133.47,83.19 134.35,84.07 134.35,85.96 136.23,87.83 137.93,87.83 v1(138.29,87.46)
  IN4 w0.084: 130.59,80.32 130.14,80.32 128.66,78.85 128.66,59.1 130.21,57.55 130.21,57.43 129.91,57.14 129.91,57.02 130.03,56.9 130.15,56.9 130.45,57.2 130.56,57.2 130.68,57.08 130.68,56.96 130.39,56.66 130.39,56.54 130.51,56.43 130.62,56.43 130.92,56.72 131.04,56.72 131.16,56.6 131.16,56.49 130.86,56.19 130.86,56.07 130.98,55.95 131.1,55.95 131.4,56.25 131.51,56.25 131.63,56.13 131.63,56.01 131.34,55.71 131.34,55.6 135.01,51.93 135.01,50.47 136.09,49.39 136.09,46.99 135.99,46.88 135.67,46.88 135.57,46.78 135.57,46.6 135.67,46.49 v1(136.81,46.49)
  BOTTOM w0.076: UC1.AK64 v1(138.29,87.46)
  BOTTOM w0.102: JDIMM1.203 135.88,48.69 136.39,48.17 136.39,47.06 136.81,46.64 v1(136.81,46.49)
DDR_A_D20: length 59.3
  IN4 w0.076: 130.59,83.83 131.27,83.83 132.08,84.64 132.08,84.86 134.96,87.74 134.96,88.85 135.86,89.75 136.57,89.75 v1(137.02,89.29)
  IN4 w0.084: v1(134.27,44.97) 132.9,46.35 132.9,50.09 132.13,50.85 132.13,51.58 130.26,53.46 130.26,53.57 130.5,53.82 130.5,53.94 130.38,54.05 130.26,54.05 130.1,53.89 129.96,53.89 129.86,53.99 129.86,54.13 130.03,54.29 130.03,54.42 126.75,57.69 126.75,79.43 128.1,80.78 128.1,82.22 129.71,83.83 130.59,83.83
  BOTTOM w0.076: UC1.AF66 v1(137.02,89.29)
  BOTTOM w0.102: JDIMM1.190 132.63,43.32 v1(134.27,44.97)
DDR_A_D21: length 58.4
  IN4 w0.076: 130.59,83.09 131.26,83.09 132.12,83.95 133.17,83.95 133.69,84.46 133.69,86.23 135.21,87.76 135.21,88.75 135.76,89.29 v1(136.39,89.29)
  IN4 w0.084: 130.59,83.09 129.39,83.09 128.4,82.1 128.4,80.66 127.05,79.31 127.05,57.81 130.95,53.92 130.95,53.8 130.73,53.58 130.73,53.46 130.85,53.35 130.97,53.35 131.18,53.56 131.3,53.56 131.41,53.45 131.41,53.33 131.17,53.09 131.17,52.97 131.29,52.85 131.41,52.85 131.65,53.1 131.77,53.1 131.89,52.98 131.89,52.86 131.65,52.62 131.65,52.5 132.43,51.71 132.43,50.98 133.2,50.22 133.2,46.86 133.56,46.49 v1(134.27,46.49)
  BOTTOM w0.076: UC1.AF67 v1(136.39,89.29)
  BOTTOM w0.102: JDIMM1.191 132.88,47.89 v1(134.27,46.49)
DDR_A_D22: length 56.8
  IN4 w0.076: 130.59,80.02 130.95,80.02 131.81,80.87 131.81,81.18 132.02,81.4 132.02,82.07 132.36,82.41 132.92,82.41 134.52,84 134.52,85.89 135.96,87.33 136.25,87.33 v1(136.39,87.46)
  IN4 w0.084: v1(136.81,48.02) 136.81,48.45 136.71,48.55 136.49,48.55 136.39,48.65 136.39,48.79 136.49,48.89 136.81,48.89 136.91,48.99 136.91,49.14 136.81,49.25 136.49,49.25 136.39,49.35 136.39,49.61 135.31,50.69 135.31,52.05 135.12,52.24 135.12,52.36 135.31,52.54 135.31,52.68 135.21,52.78 135.07,52.78 134.88,52.59 134.76,52.59 134.64,52.71 134.64,52.83 134.94,53.13 134.94,53.25 134.83,53.37 134.71,53.37 134.41,53.07 134.29,53.07 134.17,53.19 134.17,53.3 134.47,53.61 134.47,53.72 134.34,53.85 134.23,53.85 133.93,53.56 133.81,53.56 133.69,53.67 133.69,53.79 133.99,54.09 133.99,54.21 133.87,54.32 133.75,54.32 133.46,54.03 133.34,54.03 133.22,54.15 133.22,54.27 133.51,54.56 133.51,54.68 133.4,54.8 133.28,54.8 132.98,54.5 132.86,54.5 132.75,54.62 132.75,54.74 133.04,55.04 133.04,55.15 132.92,55.27 132.8,55.27 132.51,54.98 132.39,54.98 132.27,55.1 132.27,55.22 132.57,55.51 132.57,55.63 132.46,55.74 132.34,55.74 132.04,55.44 131.93,55.44 131.81,55.56 131.81,55.68 132.1,55.97 132.1,56.09 128.96,59.23 128.96,78.71 130.27,80.02 130.59,80.02
  BOTTOM w0.076: UC1.AK67 v1(136.39,87.46)
  BOTTOM w0.102: v1(136.81,48.02) 136.88,48.08 JDIMM1.207
DDR_A_D23: length 57.7
  IN4 w0.076: 130.59,79.7 130.87,79.7 131.97,80.8 131.97,81.09 132.19,81.31 132.19,82 132.43,82.24 132.99,82.24 134.68,83.94 134.68,85.82 135.95,87.09 136.65,87.09 v1(137.02,87.46)
  IN4 w0.084: v1(136.81,44.97) 137.21,45.36 137.21,49.28 135.61,50.89 135.61,51.72 135.71,51.82 136.47,51.82 136.57,51.93 136.57,52.08 136.47,52.18 135.71,52.18 135.61,52.28 135.61,53.04 129.79,58.85 129.79,58.97 130.17,59.35 130.17,59.49 130.08,59.59 129.94,59.59 129.55,59.21 129.43,59.21 129.32,59.33 129.32,59.45 129.89,60.02 129.89,60.14 129.26,60.76 129.26,78.58 130.39,79.7 130.59,79.7
  BOTTOM w0.076: UC1.AK66 v1(137.02,87.46)
  BOTTOM w0.102: v1(136.81,44.97) 137.23,44.55 137.23,42.64 137.12,42.53 JDIMM1.208
DDR_A_D24: length 68.9
  IN4 w0.076: v1(129.02,89.96) 129.7,89.28 131.18,89.28 131.46,89 131.46,88.68 130.17,87.39 123.94,87.39 123.25,86.7
  IN4 w0.084: 123.25,86.7 120.18,83.63 120.18,80.63 125.03,75.78 125.03,55.57 131.01,49.58 131.01,44.17 v1(131.73,43.45)
  BOTTOM w0.076: UC1.AF70 133.88,90.06 133.28,90.65 129.72,90.65 v1(129.02,89.96)
  BOTTOM w0.102: JDIMM1.186 131.63,43.34 v1(131.73,43.45)
DDR_A_D25: length 70.7
  IN4 w0.084: v1(127.72,89.96) 127.12,89.36 122.99,89.36 118.12,84.48 118.12,79.76 122.86,75.01 122.86,53.11 123.86,52.11 123.86,51.38 127.04,48.21 127.04,45.67 127.14,45.56 128.33,45.56 128.43,45.46 128.43,45.28 128.33,45.18 127.53,45.18 127.43,45.08 127.43,44.83 127.53,44.73 128.47,44.73 128.57,44.62 128.57,43.55 128.67,43.45 v1(129.19,43.45)
  BOTTOM w0.076: UC1.AF68 135.37,89.97 134.85,90.23 134.79,90.25 134.55,90.25 134.43,90.37 133.8,90.37 133.35,90.82 128.58,90.82 v1(127.72,89.96)
  BOTTOM w0.102: v1(129.19,43.45) 128.63,42.88 JDIMM1.174
DDR_A_D26: length 68
  IN4 w0.076: 122.03,87.13 123.23,88.32 127.21,88.32 v1(127.75,88.87)
  IN4 w0.084: v1(129.19,48.02) 129.19,48.02 127.32,49.88 127.32,51.59 126.3,52.61 126.18,52.61 125.73,52.16 125.59,52.16 125.49,52.25 125.49,52.39 125.94,52.85 125.94,52.97 125.77,53.14 125.65,53.14 124.95,52.44 124.83,52.44 124.71,52.56 124.71,52.68 125.42,53.38 125.42,53.5 125.3,53.61 125.18,53.61 124.48,52.91 124.36,52.91 124.24,53.03 124.24,53.15 124.94,53.85 124.94,53.97 124.82,54.09 124.7,54.09 124.04,53.43 123.91,53.43 123.81,53.53 123.81,53.67 124.47,54.33 124.47,54.44 124.35,54.56 124.23,54.56 124.02,54.36 123.88,54.36 123.78,54.45 123.78,54.59 123.99,54.8 123.99,54.92 123.78,55.13 123.78,75.39 119.02,80.15 119.02,84.11 122.03,87.13
  BOTTOM w0.076: v1(127.75,88.87) 128.61,88.02 131.33,88.02 132.12,88.81 133.15,88.81 133.22,88.73 UC1.AH71
  BOTTOM w0.102: JDIMM1.173 128.37,48.95 129.19,48.13 v1(129.19,48.02)
DDR_A_D27: length 70.3
  IN4 w0.076: 130.59,86.1 132.03,87.54 132.03,89.65 ; 132.03,89.68 132.03,89.75 v1(131.85,89.93)
  IN4 w0.084: 130.59,86.1 129.94,85.45 127.91,85.45 127.14,84.68 127.14,80.94 125.95,79.75 125.95,78.53 125.86,78.44 125.4,78.44 125.32,78.36 125.32,78.19 125.4,78.11 125.86,78.11 125.95,78.02 125.95,77.86 125.86,77.77 125.4,77.77 125.32,77.69 125.32,77.52 125.4,77.44 125.86,77.44 125.95,77.35 125.95,57.38 127.52,55.8 127.52,55.68 126.92,55.08 126.92,54.96 127.04,54.84 127.16,54.84 127.76,55.45 127.88,55.45 128,55.32 128,55.21 127.39,54.6 127.39,54.48 127.51,54.36 127.63,54.36 128.24,54.97 128.36,54.97 128.48,54.85 128.48,54.71 127.88,54.11 127.88,53.99 128,53.87 128.12,53.87 128.71,54.47 128.85,54.47 128.95,54.37 128.95,54.23 128.35,53.64 128.35,53.52 128.47,53.4 128.59,53.4 128.82,53.63 128.94,53.63 129.06,53.51 129.06,53.39 128.83,53.16 128.83,53.04 128.95,52.92 129.06,52.92 129.3,53.15 129.41,53.15 129.53,53.04 129.53,52.92 129.3,52.69 129.3,52.57 129.42,52.45 129.54,52.45 129.77,52.68 129.89,52.68 130.01,52.56 130.01,52.44 129.78,52.21 129.78,52.09 129.9,51.97 130.01,51.97 130.24,52.21 130.36,52.21 130.48,52.09 130.48,51.97 130.25,51.74 130.25,51.62 130.37,51.5 130.49,51.5 130.72,51.73 130.84,51.73 130.96,51.61 130.96,51.49 130.73,51.26 130.73,51.14 132.11,49.76 132.11,46.87 v1(131.73,46.49) ; 132.03,89.68 132.03,89.65
  BOTTOM w0.076: UC1.AH68 135.39,89.38 135.19,89.59 134.74,89.59 134.64,89.66 134.32,89.66 134.2,89.62 133.97,89.62 133.96,89.62 133.96,89.63 133.95,89.63 133.87,89.66 133.67,89.66 133.58,89.63 133.22,89.63 132.81,90.03 131.95,90.03 v1(131.85,89.93)
  BOTTOM w0.102: JDIMM1.183 130.88,47.35 v1(131.73,46.49)
DDR_A_D28: length 67.7
  IN4 w0.076: v1(129.67,89.96) 130.12,89.51 131.28,89.51 131.66,89.13 131.66,88.58 130.3,87.21 124.19,87.21 123.67,86.7
  IN4 w0.084: v1(131.73,44.97) 131.62,44.85 131.42,44.85 131.31,44.95 131.31,49.71 125.34,55.68 125.34,75.9 120.48,80.76 120.48,83.5 123.67,86.7
  BOTTOM w0.076: v1(129.67,89.96) 130.2,90.49 133.01,90.49 UC1.AF71
  BOTTOM w0.102: v1(131.73,44.97) 130.63,43.86 JDIMM1.182
DDR_A_D29: length 69.3
  IN4 w0.076: v1(130.96,89.96) 131.19,89.96 131.85,89.3 131.85,88.41 130.39,86.95 124.34,86.95 124.09,86.7
  IN4 w0.084: 124.09,86.7 120.78,83.38 120.78,80.88 122.55,79.1 125.52,79.1 125.63,79 125.63,78.85 125.52,78.75 124.7,78.75 124.6,78.65 124.6,78.48 124.7,78.38 124.9,78.38 125,78.28 125,77.24 125.11,77.14 125.54,77.14 125.64,77.03 125.64,76.91 125.54,76.81 125.22,76.81 125.12,76.7 125.12,76.55 125.22,76.45 125.54,76.45 125.64,76.35 125.64,57.24 126.11,56.77 126.11,56.65 125.64,56.18 125.64,56.04 125.74,55.94 125.88,55.94 126.35,56.42 126.47,56.42 126.59,56.3 126.59,56.18 126,55.59 126,55.45 126.1,55.35 126.24,55.35 126.83,55.94 126.94,55.94 127.09,55.8 127.09,55.68 126.49,55.08 126.49,54.96 131.73,49.71 v1(131.73,48.02)
  BOTTOM w0.076: UC1.AF69 134.64,89.86 134.38,89.86 134.19,89.79 133.99,89.79 133.9,89.83 133.65,89.83 133.63,89.83 133.54,89.79 133.29,89.79 132.75,90.32 131.32,90.32 v1(130.96,89.96)
  BOTTOM w0.102: JDIMM1.187 131.88,48.16 v1(131.73,48.02)
DDR_A_D30: length 69.1
  IN4 w0.076: v1(125.59,88.87) 125.22,88.5 122.98,88.5 122.03,87.55
  IN4 w0.084: v1(129.19,46.49) 128.14,47.55 128.14,48.34 127.01,49.48 127.01,49.84 126.91,49.95 126.15,49.95 126.04,50.05 126.04,50.21 126.15,50.31 126.91,50.31 127.01,50.41 127.01,50.55 126.91,50.66 125.43,50.66 125.33,50.76 125.33,50.9 125.43,51 126.32,51 126.43,51.1 126.43,51.67 126.32,51.77 125.04,51.77 123.47,53.34 123.47,75.26 118.72,80.02 118.72,84.23 122.03,87.55
  BOTTOM w0.076: v1(125.59,88.87) 126.25,88.21 127.92,88.21 128.28,87.85 131.4,87.85 132.19,88.64 133.08,88.64 133.2,88.52 133.26,88.47 133.55,88.47 133.8,88.58 133.8,88.59 133.8,88.59 133.94,88.73 UC1.AH70
  BOTTOM w0.102: JDIMM1.169 127.37,48.95 128.23,48.1 128.23,47.46 v1(129.19,46.49)
DDR_A_D31: length 70.5
  IN4 w0.076: 122.03,87.97 122.93,88.87 v1(124.96,88.87)
  IN4 w0.084: 122.03,87.97 118.42,84.36 118.42,79.89 123.17,75.14 123.17,53.22 124.19,52.2 124.19,51.48 127.34,48.33 127.34,46.68 127.44,46.58 128.66,46.58 128.76,46.48 128.76,46.33 128.66,46.22 127.49,46.22 127.39,46.12 127.39,45.97 127.49,45.87 128.66,45.87 128.76,45.77 128.76,45.07 128.86,44.97 v1(129.19,44.97)
  BOTTOM w0.076: v1(124.96,88.87) 126.14,87.69 131.47,87.69 132.26,88.48 133.01,88.48 133.14,88.35 133.19,88.3 133.58,88.3 133.66,88.34 134.14,88.34 134.54,88.73 UC1.AH69
  BOTTOM w0.102: JDIMM1.170 127.63,43.4 v1(129.19,44.97)
DDR_A_D32: length 65.4
  IN1 w0.084: v1(95.2,43.45) 95.88,44.13 95.88,44.74 95.96,44.83 96.19,44.83 96.28,44.91 96.28,45.08 96.19,45.16 95.96,45.16 95.88,45.25 95.88,48.43 98,50.56 98,51.62 103.24,56.86 103.83,56.86 117.44,70.47 119.38,70.47 120.14,71.23 128.34,71.23 130.5,73.39 130.5,75.03 v1(132,76.52)
  BOTTOM w0.076: UC1.BB65 137.1,80.48 137.1,79.41 136.52,78.83 133.2,78.83 132.56,78.19 132.56,77.08 132.08,76.6
  BOTTOM w0.089: 132.08,76.6 v1(132,76.52)
  BOTTOM w0.102: JDIMM1.46 94.62,42.88 v1(95.2,43.45)
DDR_A_D33: length 67.8
  IN1 w0.084: v1(98.27,43.45) 97.6,44.12 97.6,48.51 99.87,50.78 99.87,51.85 103.72,55.7 104.31,55.7 117.92,69.31 119.86,69.31 120.24,69.7 124.04,69.7 124.13,69.79 124.13,69.99 124.22,70.07 124.39,70.07 124.47,69.99 124.47,69.79 124.55,69.71 124.72,69.71 124.8,69.79 124.8,69.99 124.89,70.07 128.82,70.07 132,73.24 v1(132,73.27)
  BOTTOM w0.076: 138.25,79.76 138.25,80.15 138.09,80.31 138.09,80.72 138.14,80.84 138.14,80.95 138.08,81.17 138.08,81.32 138.13,81.47 138.13,81.66 138.06,81.81 138.06,82.33 137.85,82.53 UC1.AW65
  BOTTOM w0.089: v1(132,73.27) 133.39,74.67 133.39,77.9 133.71,78.21 135.31,78.21 135.37,78.27 135.39,78.27 136.75,78.27 138.25,79.76
  BOTTOM w0.102: JDIMM1.62 98.62,43.27 98.44,43.45 v1(98.27,43.45)
DDR_A_D34: length 68.6
  IN1 w0.084: v1(98.27,46.49) 99.2,46.49 99.36,46.65 99.36,48.62 100.77,50.03 100.77,51.22 101.23,51.68 101.35,51.68 101.52,51.5 101.64,51.5 101.76,51.62 101.76,51.74 101.59,51.92 101.59,52.03 101.7,52.15 101.82,52.15 101.96,52.02 102.04,52.02 103.84,53.82 118.43,68.41 120.23,68.41 120.62,68.8 128.2,68.8 128.57,69.17 129.2,69.17 130.85,70.82 131.29,70.82 133.85,73.37 v1(133.85,74.49)
  BOTTOM w0.076: UC1.AW63 138.43,82.32 138.74,82.01 138.74,81.46 138.96,81.24 138.96,79.53 137.03,77.6 135.67,77.6 134.62,76.56 134.62,74.71 134.4,74.49 v1(133.85,74.49)
  BOTTOM w0.102: v1(98.27,46.49) 98.65,46.11 98.65,45.41 98.84,45.22 99.17,45.22 99.31,45.36 99.31,46.26 98.88,46.69 JDIMM1.63
DDR_A_D35: length 67.4
  IN1 w0.084: v1(95.2,46.49) 94.79,46.9 94.79,48.62 97.1,50.93 97.1,51.99 102.87,57.76 103.45,57.76 117.07,71.37 119,71.37 120.17,72.53 125.96,72.53 126.36,72.13 127.97,72.13 129.6,73.76 129.6,75.97 131.84,78.2 133.48,78.2 v1(133.85,77.82)
  BOTTOM w0.076: UC1.AY63 138.32,81.78 138.32,81.53 138.25,81.31 138.25,81.18 138.31,80.95 138.31,80.81 138.26,80.69 138.26,80.43 138.44,80.25 138.44,79.71 136.82,78.1 135.46,78.1 135.19,77.82 v1(133.85,77.82)
  BOTTOM w0.102: v1(95.2,46.49) 94.37,47.31 JDIMM1.45
DDR_A_D36: length 66.7
  IN1 w0.084: v1(132,77.17) 130.2,75.38 130.2,73.52 128.22,71.53 120.01,71.53 119.25,70.77 117.31,70.77 103.7,57.16 103.12,57.16 97.7,51.75 97.7,50.68 95.58,48.55 95.58,45.35 v1(95.2,44.97)
  BOTTOM w0.076: UC1.BA65 137.2,81.08 137.06,80.94 137.06,80.94 137.05,80.94 136.93,80.69 136.93,79.49 136.44,79 133.08,79 132.39,78.31 132.39,77.57 v1(132,77.17)
  BOTTOM w0.102: JDIMM1.50 95.62,42.81 95.73,42.91 95.98,42.91 96.1,43.03 96.1,43.2 95.98,43.32 95.73,43.32 95.62,43.42 95.62,43.63 95.73,43.73 95.94,43.73 96.06,43.85 96.06,44.01 95.94,44.13 95.73,44.13 95.62,44.24 95.62,44.54 v1(95.2,44.97)
DDR_A_D37: length 66.8
  IN1 w0.084: v1(132,77.82) 129.9,75.73 129.9,73.64 128.09,71.83 126.02,71.83 125.93,71.91 125.93,72.14 125.85,72.22 125.68,72.22 125.6,72.14 125.6,71.91 125.51,71.83 125.34,71.83 125.26,71.91 125.26,72.14 125.18,72.22 125.01,72.22 124.93,72.14 124.93,71.91 124.84,71.83 124.67,71.83 124.59,71.91 124.59,72.14 124.49,72.23 124.35,72.23 124.26,72.14 124.26,71.93 124.16,71.83 124.02,71.83 123.92,71.93 123.92,72.14 123.82,72.23 123.68,72.23 123.58,72.14 123.58,71.91 123.5,71.83 123.33,71.83 123.25,71.91 123.25,72.15 123.17,72.23 123,72.23 122.91,72.15 122.91,71.91 122.83,71.83 122.66,71.83 122.58,71.91 122.58,72.15 122.49,72.23 122.33,72.23 122.24,72.15 122.24,71.91 122.16,71.83 121.99,71.83 121.91,71.91 121.91,72.15 121.82,72.23 121.66,72.23 121.57,72.15 121.57,71.91 121.49,71.83 121.32,71.83 121.24,71.91 121.24,72.15 121.15,72.23 120.99,72.23 120.9,72.15 120.9,71.91 120.82,71.83 120.65,71.83 120.57,71.91 120.57,72.15 120.48,72.23 120.32,72.23 120.23,72.15 120.23,71.91 120.15,71.83 119.89,71.83 119.13,71.07 117.19,71.07 103.58,57.46 102.99,57.46 97.4,51.87 97.4,50.81 95.2,48.6 v1(95.2,48.02)
  BOTTOM w0.076: UC1.AY65 137.2,81.68 136.93,81.41 136.93,81.13 136.88,81 136.88,80.96 136.85,80.89 136.77,80.73 136.77,79.56 136.37,79.16 132.98,79.16 132.19,78.37 132.19,78.02 v1(132,77.82)
  BOTTOM w0.102: JDIMM1.49 95.37,48.2 v1(95.2,48.02)
DDR_A_D38: length 66.7
  IN1 w0.084: v1(98.27,48.02) 98.55,48.02 98.66,47.9 98.66,46.91 98.78,46.79 98.94,46.79 99.06,46.91 99.06,48.81 100.47,50.22 100.47,51.34 101.58,52.45 102.02,52.45 102.18,52.61 102.18,52.73 101.95,52.96 101.95,53.08 102.07,53.2 102.19,53.2 102.42,52.97 102.54,52.97 102.66,53.09 102.66,53.21 102.43,53.44 102.43,53.56 102.55,53.67 102.66,53.67 102.89,53.44 103.01,53.44 103.13,53.56 103.13,53.68 102.9,53.91 102.9,54.03 103.02,54.15 103.14,54.15 103.37,53.92 103.49,53.92 103.61,54.04 103.61,54.16 103.38,54.39 103.38,54.5 103.49,54.62 103.61,54.62 103.84,54.39 103.96,54.39 104.08,54.51 104.08,54.63 103.85,54.86 103.85,54.98 103.97,55.1 104.09,55.1 104.32,54.87 104.44,54.87 118.28,68.71 120.11,68.71 120.49,69.1 128.07,69.1 128.45,69.47 129.07,69.47 130.63,71.03 131.26,71.03 131.37,71.14 133.03,72.8 133.03,75.46 133.44,75.87 v1(133.85,75.87)
  BOTTOM w0.076: v1(133.85,75.87) 134.26,75.87 134.41,76.03 134.41,76.85 134.57,77.01 134.84,77.01 135.6,77.77 136.96,77.77 138.79,79.6 138.79,80.76 138.52,81.02 UC1.BA63
  BOTTOM w0.102: v1(98.27,48.02) 98.27,48.45 97.88,48.84 JDIMM1.59
DDR_A_D39: length 65.8
  IN1 w0.076: 130.79,71.24 132.85,73.3 132.85,73.61
  IN1 w0.084: v1(98.27,44.97) 97.9,45.34 97.9,48.3 100.17,50.57 100.17,51.72 103.84,55.4 104.54,55.4 118.16,69.01 119.98,69.01 120.37,69.4 125.2,69.4 125.29,69.48 125.29,69.67 125.37,69.76 125.54,69.76 125.62,69.67 125.62,69.48 125.71,69.4 125.87,69.4 125.96,69.48 125.96,69.67 126.04,69.76 126.21,69.76 126.29,69.67 126.29,69.48 126.38,69.4 126.54,69.4 126.63,69.48 126.63,69.67 126.73,69.77 126.86,69.77 126.96,69.67 126.96,69.48 127.05,69.4 127.21,69.4 127.3,69.48 127.3,69.67 127.4,69.77 127.54,69.77 127.63,69.67 127.63,69.48 127.72,69.4 127.95,69.4 128.32,69.77 128.95,69.77 130.42,71.24 130.79,71.24 ; v1(133.85,76.52) 132.86,75.54 132.86,73.62 132.85,73.61
  BOTTOM w0.076: v1(133.85,76.52) 134.5,77.17 134.62,77.17 135.1,77.66 135.25,77.66 135.53,77.93 136.89,77.93 138.6,79.64 138.6,80.51 UC1.BB63
  BOTTOM w0.102: v1(98.27,44.97) 97.62,44.33 JDIMM1.58
DDR_A_D40: length 64.9
  IN1 w0.084: v1(135.98,75.94) 135.17,75.94 134.85,75.62 134.85,73.48 129.75,68.38 128.9,68.38 128.52,68.01 120.94,68.01 120.56,67.62 118.76,67.62 102.69,51.55 102.69,50.84 100.15,48.3 100.15,45.18 100.36,44.97 v1(100.82,44.97)
  BOTTOM w0.076: UC1.BA61 139.55,81.01 139.29,80.75 139.29,79.39 136.8,76.91 136.8,75.75 136.61,75.56 136.35,75.56 v1(135.98,75.94)
  BOTTOM w0.102: v1(100.82,44.97) 99.78,44.97 99.62,44.81 JDIMM1.66
DDR_A_D41: length 66
  IN1 w0.084: v1(135.98,77.24) 134.87,77.24 134.55,76.91 134.55,73.83 129.4,68.68 128.77,68.68 128.4,68.31 120.82,68.31 120.43,67.92 118.64,67.92 102.4,51.68 102.4,50.97 99.85,48.42 99.85,44.45 99.76,44.36 99.47,44.36 99.37,44.26 99.37,44.13 99.47,44.03 99.76,44.03 99.85,43.94 99.85,43.77 100.18,43.45 v1(100.82,43.45)
  BOTTOM w0.076: v1(135.98,77.24) 136.9,77.24 139.12,79.46 139.12,81.26 139.33,81.47 139.33,82.02 139.65,82.34 UC1.AW61
  BOTTOM w0.102: v1(100.82,43.45) 100.62,43.25 JDIMM1.70
DDR_A_D42: length 64.8
  IN1 w0.076: v1(137.91,74.18) 137.42,74.18 137.22,73.97 137.22,72.85
  IN1 w0.084: 137.22,72.85 129.93,65.56 129.61,65.56 129.53,65.48 129.53,65.03 129.43,64.93 129.29,64.93 129.2,65.03 129.2,65.48 129.11,65.56 128.94,65.56 128.86,65.48 128.86,64.95 128.76,64.85 128.62,64.85 128.52,64.95 128.52,65.48 128.44,65.56 128.27,65.56 128.19,65.48 128.19,65.14 128.09,65.04 127.95,65.04 127.85,65.14 127.85,65.48 127.77,65.56 119.61,65.56 106.61,52.56 106.61,51.6 106.52,51.51 106.41,51.51 106.05,51.87 105.93,51.87 105.82,51.75 105.82,51.63 106.17,51.28 106.17,51.16 104.13,49.12 103.93,49.12 102.94,48.13 102.94,46.68 103.13,46.49 v1(103.36,46.49)
  BOTTOM w0.076: v1(137.91,74.18) 138.32,74.18 138.83,74.68 138.83,77.13 140.63,78.93 140.63,79.44 140.98,79.8 140.98,80.48 UC1.BB59
  BOTTOM w0.102: JDIMM1.79 102.88,46.7 103.08,46.49 v1(103.36,46.49)
DDR_A_D43: length 67
  IN1 w0.084: v1(137.91,75.48) 136.89,74.46 136.89,72.94 129.81,65.86 119.49,65.86 105,51.37 105,50.61 102.55,48.16 102.55,45.78 v1(103.36,44.97)
  BOTTOM w0.076: UC1.AW59 140.23,82.53 140.02,82.33 140.02,81.81 139.95,81.71 139.95,81.46 139.99,81.34 139.99,81.11 139.99,81.1 139.99,81.1 139.99,81.09 139.95,81.01 139.95,80.81 139.99,80.72 139.99,80.36 139.78,80.16 139.78,79.18 137.3,76.69 137.3,76.08 137.9,75.48 v1(137.91,75.48)
  BOTTOM w0.102: v1(103.36,44.97) 104,44.33 104.75,44.33 104.87,44.21 104.87,44.05 104.75,43.93 104.23,43.93 104.13,43.82 104.13,43.62 104.23,43.52 104.74,43.52 104.86,43.4 104.86,43.23 104.74,43.11 104.23,43.11 104.13,43.01 JDIMM1.84
DDR_A_D44: length 64.5
  IN1 w0.084: v1(135.97,75.26) 135.37,75.26 135.15,75.04 135.15,73.32 129.54,67.71 129.36,67.71 129.27,67.79 129.27,68 129.19,68.08 129.02,68.08 128.94,68 128.94,67.79 128.85,67.71 121.07,67.71 120.68,67.32 118.89,67.32 102.99,51.43 102.99,50.72 100.45,48.17 100.45,46.87 v1(100.82,46.49)
  BOTTOM w0.076: v1(135.97,75.26) 136.42,74.81 136.76,74.81 136.97,75.01 136.97,76.84 139.45,79.32 139.45,80.48 UC1.BB61
  BOTTOM w0.102: v1(100.82,46.49) 100.82,46.49 100.62,46.29 100.08,46.29 99.88,46.49 99.88,46.78 99.77,46.88 99.6,46.88 99.48,47 99.48,47.17 99.6,47.29 99.77,47.29 99.88,47.39 99.88,47.59 99.77,47.7 99.6,47.7 99.48,47.82 99.48,47.98 99.6,48.1 99.77,48.1 99.88,48.2 99.88,48.41 99.77,48.51 99.6,48.51 99.48,48.63 99.48,48.8 99.6,48.92 99.77,48.92 99.88,49.02 JDIMM1.67
DDR_A_D45: length 65.4
  IN1 w0.084: v1(100.82,48.02) 100.82,48.07 103.84,51.09 103.84,51.85 119.01,67.02 121.19,67.02 121.27,67.1 121.27,67.31 121.37,67.41 121.51,67.41 121.61,67.31 121.61,67.1 121.69,67.02 121.86,67.02 121.94,67.1 121.94,67.31 122.04,67.41 122.18,67.41 122.28,67.31 122.28,67.1 122.36,67.02 122.53,67.02 122.61,67.1 122.61,67.31 122.71,67.41 122.85,67.41 122.95,67.31 122.95,67.1 123.03,67.02 123.2,67.02 123.28,67.1 123.28,67.3 123.38,67.39 123.52,67.39 123.62,67.3 123.62,67.1 123.7,67.02 123.87,67.02 123.95,67.1 123.95,67.3 124.05,67.39 124.19,67.39 124.29,67.3 124.29,67.1 124.37,67.02 124.54,67.02 124.62,67.1 124.62,67.31 124.72,67.41 124.86,67.41 124.96,67.31 124.96,67.1 125.04,67.02 125.21,67.02 125.3,67.1 125.3,67.31 125.39,67.41 125.53,67.41 125.63,67.31 125.63,67.1 125.71,67.02 125.88,67.02 125.97,67.1 125.97,67.31 126.06,67.41 126.2,67.41 126.3,67.31 126.3,67.1 126.39,67.02 126.55,67.02 126.64,67.1 126.64,67.31 126.73,67.41 126.87,67.41 126.97,67.31 126.97,67.1 127.06,67.02 127.22,67.02 127.31,67.1 127.31,67.31 127.41,67.41 127.54,67.41 127.64,67.31 127.64,67.1 127.73,67.02 127.89,67.02 127.98,67.1 127.98,67.31 128.08,67.41 128.21,67.41 128.31,67.31 128.31,67.1 128.4,67.02 128.56,67.02 128.65,67.1 128.65,67.31 128.75,67.41 128.89,67.41 128.98,67.31 128.98,67.1 129.07,67.02 129.27,67.02 135.45,73.2 135.45,73.71 135.64,73.9 v1(135.98,73.9)
  BOTTOM w0.076: v1(135.98,73.9) 136.91,73.9 137.13,74.12 137.13,76.77 139.62,79.26 139.62,80.23 139.82,80.43 139.82,80.69 139.78,80.78 139.78,80.79 139.78,81.04 139.82,81.13 139.82,81.33 139.79,81.42 139.79,81.42 139.75,81.52 139.75,81.78 UC1.AY61
  BOTTOM w0.102: JDIMM1.71 100.88,48.07 v1(100.82,48.02)
DDR_A_D46: length 65.3
  IN1 w0.076: v1(137.91,73.53) 137.5,73.12 137.5,72.57
  IN1 w0.084: 137.5,72.57 129.48,64.55 128.02,64.55 127.31,65.26 119.74,65.26 106.94,52.46 106.94,51.51 105.33,49.9 105.33,49.42 105.25,49.33 104.77,49.33 104.67,49.24 104.67,49.1 104.77,49 105.25,49 105.33,48.91 105.33,48.75 105.25,48.66 104.26,48.66 104.16,48.56 104.16,48.43 104.26,48.33 105.25,48.33 105.33,48.24 105.33,48.08 105.25,47.99 104.25,47.99 104.15,47.89 104.15,47.76 104.25,47.66 105.25,47.66 105.33,47.57 105.33,47.27 105.25,47.19 104.19,47.19 v1(103.36,48.02)
  BOTTOM w0.076: UC1.BA59 141.09,80.83 141.15,80.68 141.15,79.73 140.79,79.37 140.79,78.84 139.02,77.07 139.02,74.64 v1(137.91,73.53)
  BOTTOM w0.102: v1(103.36,48.02) 103.88,48.53 JDIMM1.83
DDR_A_D47: length 66.4
  IN1 w0.084: v1(137.91,72.24) 137.6,72.24 129.6,64.25 127.9,64.25 127.18,64.96 119.86,64.96 107.24,52.34 107.24,51.38 105.63,49.77 105.63,47.15 105.43,46.95 105.43,46.83 105.8,46.47 105.8,46.33 105.7,46.23 105.56,46.23 105.2,46.6 105.08,46.6 104.96,46.48 104.96,46.36 105.3,46.02 105.3,45.88 105.2,45.79 105.06,45.79 104.72,46.12 104.6,46.12 104.48,46 104.48,45.89 104.78,45.59 104.78,45.45 104.69,45.35 104.55,45.35 104.25,45.65 104.13,45.65 103.73,45.25 103.73,43.82 v1(103.36,43.45)
  BOTTOM w0.076: 139.21,73.55 139.21,77.02 140.96,78.76 140.96,79.31 141.31,79.66 141.31,80.71 141.28,80.79 141.15,81.22 141.15,81.41 140.88,81.68 UC1.AY59
  BOTTOM w0.102: JDIMM1.80 103.13,43.21 v1(103.36,43.45) ; 139.21,73.55 v1(137.91,72.24)
DDR_A_D48: length 50.4
  IN4 w0.076: 130.65,77.77 130.65,78.26 132.61,80.22 132.89,80.22 133.56,80.88 133.56,81.84 135.72,84 v1(136.21,84)
  IN4 w0.084: v1(139.35,46.49) 138.6,47.25 138.6,50.14 138.06,50.68 138.06,52.64 133.5,57.2 133.5,57.32 133.75,57.57 133.75,57.71 133.65,57.81 133.51,57.81 133.26,57.55 133.14,57.55 133.02,57.67 133.02,57.79 133.58,58.35 133.58,58.47 133.46,58.59 133.35,58.59 133.16,58.4 133.02,58.4 132.92,58.5 132.92,58.64 133.11,58.83 133.11,58.95 130.65,61.4 130.65,77.77
  BOTTOM w0.076: UC1.AT66 136.55,84.35 v1(136.21,84)
  BOTTOM w0.102: JDIMM1.211 137.88,47.97 v1(139.35,46.49)
DDR_A_D49: length 49.5
  IN4 w0.076: v1(136.21,83.37) 135.34,82.5 134.68,82.5 133.81,81.64 133.81,80.89 132.75,79.82 132.54,79.82 130.95,78.24 130.95,78.07
  IN4 w0.084: v1(139.35,48.02) 138.9,48.47 138.9,52.22 135.36,55.76 135.36,55.88 135.58,56.1 135.58,56.24 135.49,56.34 135.35,56.34 135.12,56.12 135,56.12 134.88,56.23 134.88,56.35 135.45,56.92 135.45,57.04 135.33,57.16 135.21,57.16 134.65,56.59 134.53,56.59 134.41,56.71 134.41,56.83 134.98,57.39 134.98,57.51 134.86,57.63 134.74,57.63 134.17,57.06 134.05,57.06 133.93,57.18 133.93,57.3 134.5,57.87 134.5,57.99 134.38,58.11 134.26,58.11 134.09,57.93 133.95,57.93 133.85,58.03 133.85,58.17 134.03,58.34 134.03,58.46 130.95,61.53 130.95,78.07
  BOTTOM w0.076: UC1.AU66 v1(136.21,83.37)
  BOTTOM w0.102: v1(139.35,48.02) 139.35,48.04 138.88,48.52 JDIMM1.215
DDR_A_D50: length 52.3
  IN4 w0.076: v1(137.12,85.91) 137.49,85.54 137.49,83.78 137.67,83.6 137.67,82.55 133.14,78.02 133.14,77.91
  IN4 w0.084: 133.14,77.91 133.14,73.97 132.99,73.82 132.99,62.06 139.28,55.77 139.28,55.65 138.69,55.06 138.69,54.92 138.78,54.82 138.92,54.82 139.51,55.41 139.65,55.41 139.75,55.31 139.75,55.17 139.16,54.58 139.16,54.45 139.26,54.35 139.4,54.35 139.99,54.94 140.11,54.94 140.23,54.82 140.23,54.7 139.64,54.11 139.64,53.97 139.74,53.87 139.87,53.87 140.47,54.47 140.59,54.47 140.71,54.35 140.71,54.23 140.12,53.64 140.12,53.52 141.25,52.4 141.25,48.66 v1(141.89,48.02)
  BOTTOM w0.076: UC1.AP65 137.38,85.65 v1(137.12,85.91)
  BOTTOM w0.102: JDIMM1.225 141.37,48.88 141.89,48.36 v1(141.89,48.02)
DDR_A_D51: length 53.2
  IN4 w0.076: v1(137.12,86.54) 137.65,86.01 137.65,83.85 137.84,83.67 137.84,83.66 137.85,83.65 137.85,82.03 135.95,80.14 135.95,79.72 135.69,79.46 134.96,79.46 133.45,77.95 133.45,77.61
  IN4 w0.084: v1(141.89,46.49) 142.24,46.49 142.35,46.6 142.35,48.12 141.55,48.92 141.55,52.52 141.02,53.04 141.02,53.16 141.55,53.69 141.55,53.83 141.45,53.92 141.31,53.92 140.79,53.4 140.67,53.4 140.56,53.5 140.56,53.66 141.02,54.12 141.02,54.46 133.31,62.18 133.31,73.71 133.45,73.85 133.45,77.61
  BOTTOM w0.076: v1(137.12,86.54) 137.36,86.3 UC1.AN65
  BOTTOM w0.102: v1(141.89,46.49) 142.77,47.37 142.77,48.62 142.37,49.02 JDIMM1.229
DDR_A_D52: length 52
  IN4 w0.076: 130.05,77.18 130.05,78.38 132.3,80.62 132.3,80.93 132.52,81.15 132.82,81.15 133.13,81.45 133.13,81.91 135.81,84.59 135.81,85.51 v1(136.21,85.91)
  IN4 w0.084: 130.05,77.18 130.05,61.11 132.09,59.08 132.09,58.96 131.55,58.42 131.55,58.3 137.45,52.39 137.45,50.44 138,49.89 138,44.8 v1(139.35,43.45)
  BOTTOM w0.076: v1(136.21,85.91) 136.6,86.3 UC1.AN66
  BOTTOM w0.102: JDIMM1.216 139.12,43.22 v1(139.35,43.45)
DDR_A_D53: length 52.1
  IN4 w0.076: 130.35,77.13 130.35,78.26 132.5,80.4 132.82,80.4 133.3,80.88 133.3,81.86 136.21,84.76 v1(136.21,85.27)
  IN4 w0.084: v1(139.35,44.97) 138.3,46.03 138.3,50.02 137.75,50.56 137.75,52.52 132.49,57.78 132.49,57.9 132.64,58.05 132.64,58.19 132.54,58.29 132.41,58.29 132.25,58.14 132.13,58.14 132.01,58.26 132.01,58.37 132.57,58.93 132.57,59.04 130.35,61.26 130.35,77.13
  BOTTOM w0.076: UC1.AP66 v1(136.21,85.27)
  BOTTOM w0.102: v1(139.35,44.97) 138.12,43.74 JDIMM1.212
DDR_A_D54: length 51.7
  IN4 w0.076: 132.91,78.15 133.03,78.27 133.16,78.27 137.5,82.6 137.5,83.53 137.32,83.7 137.32,83.8 v1(137.12,84)
  IN4 w0.084: v1(141.89,44.97) 141.45,45.42 141.45,47.99 140.36,49.08 140.36,52.83 138.2,54.98 138.2,55.1 138.79,55.69 138.79,55.81 138.68,55.93 138.56,55.93 137.96,55.34 137.85,55.34 137.73,55.46 137.73,55.58 138.32,56.17 138.32,56.29 132.67,61.93 132.67,77.91 132.91,78.15
  BOTTOM w0.076: UC1.AT65 137.47,84.35 v1(137.12,84)
  BOTTOM w0.102: JDIMM1.224 141.12,42.49 141.06,42.55 141.06,44.13 v1(141.89,44.97)
DDR_A_D55: length 50.6
  IN4 w0.076: v1(137.12,83.37) 137.12,82.46 133.13,78.47 132.79,78.47 132.45,78.13
  IN4 w0.084: v1(141.89,43.45) 141.15,44.19 141.15,47.87 140.06,48.96 140.06,52.7 137.22,55.54 137.22,55.66 137.72,56.16 137.72,56.3 137.62,56.39 137.48,56.39 136.98,55.9 136.86,55.9 136.75,56.02 136.75,56.13 137.33,56.72 137.33,56.84 132.37,61.8 132.37,78.05 132.45,78.13
  BOTTOM w0.076: UC1.AU65 137.45,83.7 v1(137.12,83.37)
  BOTTOM w0.102: v1(141.89,43.45) 142.12,43.21 JDIMM1.228
DDR_A_D56: length 51.1
  IN4 w0.076: 134.53,73.23 134.53,73.51 134.62,73.6 134.62,77.61 135.77,78.76 136.5,78.76 137.25,79.51 137.25,80.6 138.44,81.79 138.44,83.38 138.95,83.89 v1(138.95,84)
  IN4 w0.084: v1(144.52,46.49) 144.25,46.49 144.15,46.6 144.15,47.54 144.05,47.65 143.54,47.65 143.44,47.75 143.44,47.89 143.54,47.99 144.05,47.99 144.15,48.09 144.15,48.22 144.05,48.32 143.64,48.32 143.53,48.42 143.53,48.87 143.43,48.97 143.13,48.97 143.03,49.07 143.03,49.17 143.13,49.27 143.44,49.27 143.53,49.37 143.53,49.5 143.44,49.59 142.74,49.59 142.64,49.7 142.64,54.43 134.53,62.53 134.53,73.23
  BOTTOM w0.076: v1(138.95,84) 139.3,84.35 UC1.AT61
  BOTTOM w0.102: v1(144.52,46.49) 143.85,47.16 143.85,48.66 143.37,49.14 JDIMM1.233
DDR_A_D57: length 50.3
  IN4 w0.076: 134.83,73.23 134.83,77.42 135.88,78.47 136.54,78.47 137.44,79.37 137.44,80.53 138.62,81.72 138.62,82.51 138.95,82.84 v1(138.95,83.37)
  IN4 w0.084: 134.83,73.23 134.83,62.66 142.94,54.55 142.94,53.95 143.02,53.86 143.63,53.86 143.73,53.76 143.73,53.62 143.63,53.53 143.02,53.53 142.94,53.44 142.94,53.27 143.02,53.19 143.64,53.19 143.72,53.11 143.72,52.94 143.64,52.86 143.02,52.86 142.94,52.77 142.94,52.6 143.02,52.52 143.64,52.52 143.72,52.44 143.72,52.27 143.64,52.18 143.02,52.18 142.94,52.1 142.94,51.97 143.02,51.89 143.21,51.89 143.29,51.81 143.29,51.64 143.21,51.55 143.02,51.55 142.94,51.47 142.94,51.3 143.02,51.22 143.21,51.22 143.29,51.14 143.29,50.97 143.21,50.88 143.02,50.88 142.94,50.8 142.94,50.63 143.02,50.55 143.66,50.55 143.76,50.45 143.76,50.31 143.66,50.21 143.35,50.21 143.25,50.12 143.25,49.99 143.35,49.89 143.73,49.89 143.83,49.79 143.83,48.96 144.52,48.27 v1(144.52,48.02)
  BOTTOM w0.076: v1(138.95,83.37) 139.28,83.7 UC1.AU61
  BOTTOM w0.102: v1(144.52,48.02) 144.37,48.16 JDIMM1.237
DDR_A_D58: length 53.5
  IN4 w0.076: v1(139.86,85.91) 140.25,85.53 140.25,83.78 140.76,83.27 140.76,81.72 139.38,80.33 139.38,79.29 136.96,76.87 136.96,75.55
  IN4 w0.084: 136.96,75.55 136.96,63.02 146.39,53.6 146.39,52.14 146.49,52.04 146.94,52.04 147.04,51.94 147.04,51.77 146.94,51.67 146.49,51.67 146.39,51.57 146.39,50.94 146.49,50.84 147.6,50.84 147.7,50.74 147.7,45.35 v1(147.31,44.97)
  BOTTOM w0.076: UC1.AP60 140.12,85.65 v1(139.86,85.91)
  BOTTOM w0.102: JDIMM1.246 146.63,42.5 146.47,42.65 146.47,44.13 v1(147.31,44.97)
DDR_A_D59: length 54.1
  IN4 w0.076: 137.26,75.55 137.26,76.82 139.58,79.13 139.58,80.29 140.93,81.64 140.93,83.33 140.41,83.85 140.41,86.01 v1(139.86,86.56)
  IN4 w0.084: v1(147.31,43.45) 148.02,44.15 148.02,51.44 147.66,51.8 147.66,52.32 147.58,52.4 146.77,52.4 146.69,52.49 146.69,52.65 146.77,52.74 147.33,52.74 147.43,52.83 147.43,52.97 147.33,53.07 146.77,53.07 146.69,53.16 146.69,53.72 137.26,63.15 137.26,75.55
  BOTTOM w0.076: v1(139.86,86.56) 140.12,86.3 UC1.AN60
  BOTTOM w0.102: JDIMM1.250 147.63,43.13 v1(147.31,43.45)
DDR_A_D60: length 52.9
  IN4 w0.076: v1(138.95,85.91) 138.41,85.37 138.41,83.85 138.08,83.51 138.08,82.02 136.84,80.79 136.84,79.64 136.5,79.29 135.52,79.29 134.26,78.03 134.26,73.97 133.82,73.53 133.82,73.26
  IN4 w0.084: 133.82,73.26 133.82,62.4 142.04,54.18 142.04,49.12 142.84,48.32 142.84,47.32 143.12,47.05 143.45,47.05 143.55,46.95 143.55,43.55 143.65,43.45 v1(144.52,43.45)
  BOTTOM w0.076: UC1.AN61 139.34,86.3 v1(138.95,85.91)
  BOTTOM w0.102: v1(144.52,43.45) 144.12,43.05 JDIMM1.236
DDR_A_D61: length 52.2
  IN4 w0.076: v1(138.95,85.27) 138.58,84.9 138.58,83.77 138.26,83.44 138.26,81.92 137.03,80.7 137.03,79.57 136.54,79.08 135.65,79.08 134.43,77.87 134.43,73.72 134.24,73.52 134.24,73.36 134.23,73.35 134.23,73.23
  IN4 w0.084: v1(144.52,44.97) 143.95,44.97 143.85,45.07 143.85,47.25 143.75,47.35 143.24,47.35 143.14,47.45 143.14,48.54 142.34,49.34 142.34,54.31 134.23,62.41 134.23,73.23
  BOTTOM w0.076: v1(138.95,85.27) 139.33,85.65 UC1.AP61
  BOTTOM w0.102: JDIMM1.232 143.12,43.58 v1(144.52,44.97)
DDR_A_D62: length 52.5
  IN4 w0.076: 136.66,75.55 136.66,76.82 139.2,79.36 139.2,80.54 140.59,81.93 140.59,83.2 139.86,83.93 v1(139.86,84)
  IN4 w0.084: 136.66,75.55 136.66,62.9 146.09,53.47 146.09,50.59 146.17,50.5 147.31,50.5 147.39,50.42 147.39,50.25 147.31,50.17 145.94,50.17 145.84,50.07 145.84,49.93 145.94,49.83 147.31,49.83 147.39,49.75 147.39,49.58 147.31,49.5 146.17,49.5 146.09,49.41 146.09,49.22 146.19,49.12 147.21,49.12 147.31,49.02 147.31,48.87 147.21,48.76 146.37,48.76 146.29,48.68 146.29,48.51 146.39,48.41 147.21,48.41 147.31,48.31 v1(147.31,48.02)
  BOTTOM w0.076: UC1.AT60 140.21,84.35 v1(139.86,84)
  BOTTOM w0.102: v1(147.31,48.02) 147.38,48.08 JDIMM1.249
DDR_A_D63: length 52.3
  IN4 w0.076: v1(139.86,83.37) 140.41,82.82 140.41,82.08 139.02,80.69 139.02,79.44 136.36,76.78 136.36,75.55
  IN4 w0.084: 136.36,75.55 136.36,62.77 144.92,54.22 144.92,53.73 145,53.65 145.48,53.65 145.58,53.55 145.58,53.41 145.48,53.31 145.09,53.31 144.99,53.22 144.99,53.08 145.09,52.98 145.68,52.98 145.77,52.9 145.77,52.73 145.68,52.64 145.16,52.64 145.06,52.55 145.06,52.41 145.16,52.31 145.58,52.31 145.68,52.21 145.68,52.07 145.58,51.97 145.1,51.97 145,51.87 145,50.99 145.1,50.89 145.66,50.89 145.79,50.76 145.79,50.63 145.7,50.54 145.22,50.54 145.12,50.45 145.12,50.31 145.22,50.21 145.44,50.21 145.54,50.11 145.54,48.89 145.97,48.46 145.97,48.21 146.94,47.24 146.94,46.87 v1(147.31,46.49)
  BOTTOM w0.076: v1(139.86,83.37) 140.2,83.7 UC1.AU60
  BOTTOM w0.102: v1(147.31,46.49) 147.31,46.64 146.37,47.58 JDIMM1.245
DDR_A_DQS0: length 77
  IN1 w0.091: v1(127.1,86.39) 126.95,86.54 126.95,86.86 126.74,87.07 123.03,87.07 112.72,76.77 112.72,75.97 107.58,70.83 106.78,70.83 106.33,70.38 106.33,70.1 106.49,69.93 106.49,69.81 106.27,69.58 106.14,69.58 105.97,69.75 105.7,69.75 105.38,69.43 105.38,69.15 105.55,68.99 105.55,68.86 105.32,68.63 105.19,68.63 105.02,68.8 104.75,68.8 87.29,51.34 87.29,49.91 85.36,47.99 85.36,46.55 85.61,46.3 85.83,46.3 86.02,46.11 v1(86.02,46.11)
  BOTTOM w0.076: v1(127.1,86.39) 126.97,86.26 126.92,86.21 126.92,86.11 127.06,85.97 130.55,85.97 131.25,86.67 131.56,86.67 132.11,87.22 133.21,87.22 133.29,87.14 133.55,87.14 133.66,87.19 133.88,87.19 133.99,87.14 134.19,87.14 134.27,87.17 134.56,87.17 134.77,87.08 134.84,87.01 135.01,86.84 UC1.AM69
  BOTTOM w0.102: v1(86.02,46.11) 86.2,46.3 86.48,46.3 86.68,46.49 86.68,47.88 86.37,48.18 JDIMM1.13

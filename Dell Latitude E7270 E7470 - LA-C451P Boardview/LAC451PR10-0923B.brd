# Allegro board LAC451PR10-0923B.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
WWAN_WAKE#: length 98.3
  TOP w0.102: v2(280.5,93.8) 281.3,93.8 v1(281.85,94.34) ; v1(229.83,65.45) 229.83,66.47 229.33,66.98 UE1.B43 ; v1(224.62,68.73) 225.09,69.2 RE38.2
  IN3 w0.102: v1(229.83,65.45) 230.69,66.31 235.25,66.31 235.8,66.86 238.47,66.86 238.64,67.03 239.97,67.03 240.47,67.52 241.22,67.52 242.37,66.37 245.83,66.37 246.64,67.19 249.26,67.19 249.32,67.13 251.24,67.13 252.04,66.33 256.32,66.33 257.07,67.08 259.1,67.08 259.31,66.88 260.22,66.88 260.96,66.14 263.55,66.14 264.03,65.65 278.16,65.65 280.29,67.78 280.29,72.02 283.08,74.82 283.08,79.06 280.73,81.41 280.73,93.23 v1(281.85,94.34)
  BOTTOM w0.102: v1(229.83,65.45) 229.83,65.63 229.45,66.01 228.64,66.01 227.56,67.08 227.56,68.76 227.07,69.25 225.14,69.25 v1(224.62,68.73) ; JNGFF2.15 281.6,94.1 v1(281.85,94.34)
XCLK_BIASREF: length 15.3
  TOP w0.102: RC324.1 160.84,94.66 v1(160.5,95) 160.7,95.2 RC52.1
  IN1 w0.076: v1(160.5,95) 159.95,95 159.62,95.33 159.62,95.61 158.21,97.01 158.21,97.36 157.61,97.96 157.61,98.19 157.39,98.4 157,98.4 156.65,98.75 151.85,98.75 151.32,99.28 151.32,100.24 v1(150.83,100.73)
  BOTTOM w0.076: UC1.E42 150.59,100.49 v1(150.83,100.73)
XDP_DBRESET#: length 68.8
  TOP w0.102: v1(161.43,118.45) 160.84,117.86 156.93,117.86 156.58,117.51 156.58,117.22 154.42,115.06 150.11,115.06 v2(147.96,117.21) 145.53,119.64 144.04,119.64 143.24,120.44 140.31,120.44 139.85,119.99 138.9,119.99 137.72,118.8 136.4,118.8 RC137.2 CC32.1 135.24,118.56 134.69,118.02 129.58,118.02 129.42,118.17 129.42,118.58 v1(129.83,118.98)
  IN1 w0.084: v1(178.94,109.86) 178.21,110.59 174.48,110.59 172.99,112.08 168.89,112.08 166.97,114 165.76,114 161.43,118.33 v1(161.43,118.45)
  BOTTOM w0.102: RC290.1 180.3,108.29 180.73,108.72 180.73,109.36 180.48,109.61 179.19,109.61 v1(178.94,109.86) 178.94,111.35 178.67,111.62 177.43,111.62 177.25,111.8 UC12.1 ; v1(129.83,118.98) 129.89,119.04 JXDP1.48
XDP_JTAGX: length 12.6
  BOTTOM w0.076: 138.5,109.14 138.5,108.89 RC87.1 138.97,108.21 139.54,107.64 139.54,107.33 140.06,106.82 140.06,105.76 140.65,105.16 140.65,103.37 UC1.A59
  BOTTOM w0.102: v2(134.59,109.99) 134.64,109.94 136.14,109.94 RC328.1 137.07,109.98 137.92,109.98 CC305.1 138.5,110.28 138.5,109.14
XDP_OBS0: length 14.2
  BOTTOM w0.102: RC239.2 113.38,124.62 v2(113.39,124.61) 114.22,123.78 115.09,123.78 115.89,122.99 121.53,122.99 122.08,123.54 122.08,124.47 122.52,124.91 123.29,124.91 123.39,125.01 JXDP1.21
XDP_OBS0_R: length 64.3
  IN4 w0.076: v1(142.38,105.6) 141.54,106.43 141.54,108.03 142.49,108.98 142.49,110.43 143.78,111.72 143.78,112.53 144.27,113.02
  IN4 w0.084: v1(116.91,123.43) 117.35,123.43 119.52,125.6 119.52,127.85 121.28,129.61 122.46,129.61 123.69,128.39 123.69,127.52 125.05,126.16 126.78,126.16 128.5,124.45 128.5,123.58 131.59,120.49 133.01,120.49 135.06,118.45 137.49,118.45 137.76,118.71 142.36,118.71 143.22,119.57 144.78,119.57 145.4,118.94 145.4,117.93 146.04,117.3 146.04,115.26 145.09,114.32 145.09,113.85 144.27,113.02
  BOTTOM w0.076: UC1.C55 142.73,105.25 v1(142.38,105.6)
  BOTTOM w0.102: RC239.1 111.67,124.62 112.12,125.07 113.51,125.07 114.38,124.19 115.43,124.19 116.19,123.43 v1(116.91,123.43)
XDP_OBS1: length 19.7
  BOTTOM w0.102: JXDP1.23 123.89,124.89 123.51,124.51 122.69,124.51 122.49,124.3 122.49,123.38 121.7,122.58 115.72,122.58 114.92,123.38 113.75,123.38 113.15,123.99 111.4,123.99 110.4,124.99 109.69,124.99 RC240.2 v2(108.18,125.47)
XDP_OBS1_R: length 67.8
  IN4 w0.076: 144.55,112.75 144.04,112.24 144.04,111.72 142.65,110.33 142.65,108.91 141.75,108.01 141.75,107.2 v1(142.24,106.71)
  IN4 w0.084: 144.55,112.75 145.48,113.69 145.48,114.16 146.43,115.1 146.43,117.46 145.79,118.09 145.79,119.11 144.94,119.96 143.06,119.96 142.2,119.1 137.6,119.1 137.36,118.87 135.19,118.87 133.17,120.88 131.75,120.88 128.88,123.74 128.88,124.61 126.94,126.55 125.21,126.55 124.22,127.54 124.22,127.98 124.37,128.13 124.37,128.96 123.33,130 121.11,130 118.88,127.77 118.88,125.54 117.28,123.94 v1(117.29,123.94)
  BOTTOM w0.076: v1(142.24,106.71) 142.72,106.23 142.72,105.85 142.91,105.66 142.91,102.51 143.05,102.37 143.05,102.1 142.73,101.78 UC1.D55
  BOTTOM w0.102: v1(117.29,123.94) 116.29,123.94 115.63,124.6 114.66,124.6 113.78,125.47 111.95,125.47 111.63,125.15 110.92,125.15 110.6,125.47 RC240.1
XDP_OBS2_R: length 5.1
  BOTTOM w0.076: T10.1 143.14,106.76 143.14,105.93 143.24,105.83 143.24,104.8 143.58,104.46 143.58,102.85 UC1.B54
XDP_OBS3_R: length 4.7
  BOTTOM w0.076: UC1.C56 142.16,102.09 142.44,102.36 142.44,104.79 141.98,105.25 141.98,105.92 T11.1
XDP_PRSNT_PIN1: length 4.5
  BOTTOM w0.102: JXDP1.1 118.39,127.41 RC121.1 116.71,128.34 RC122.1 116.46,128.09 v2(115.59,128.09)
XDP_TMS: length 18.2
  TOP w0.102: v1(144.47,120.81) v2(145.02,120.81)
  IN3 w0.102: v1(132.39,119.01) 132.39,119.54 134.34,121.5 136.2,121.5 137.11,120.6 138.61,120.6 139.09,120.11 141.2,120.11 141.89,120.81 v1(144.47,120.81)
  BOTTOM w0.102: RC228.1 v1(144.47,120.81) 144.17,120.81 144.15,120.8 UC8.9 ; JXDP1.58 v1(132.39,119.01)
XTAL24_IN: length 14.7
  BOTTOM w0.076: 152.94,108.23 152.94,104.09 153.05,103.98 153.05,103.53 152.92,103.4 152.92,102.37 152.93,102.36 152.93,102.12 152.91,102.1 152.91,101.73 152.93,101.71 152.93,101.47 152.91,101.45 152.91,100.7 UC1.E37
  BOTTOM w0.102: YC1.3 153.77,113.19 153.77,111.29 CC21.1 152.7,110.22 RC46.2 152.67,109.16 v2(152.65,109.14) 152.94,108.85 152.94,108.23
XTAL24_OUT: length 11.1
  BOTTOM w0.076: v2(153.4,108.07) 153.16,107.83 153.16,104.2 153.3,104.06 153.3,103.54 153.48,103.36 153.48,102.99 153.5,102.97 153.5,101.18 154.04,100.64 UC1.E35
  BOTTOM w0.102: RC295.1 RC46.1 153.59,108.26 v2(153.4,108.07)
XTAL24_OUT_R: length 2.8
  BOTTOM w0.102: YC1.1 154.45,111.7 CC22.1 154.48,111.11 RC295.2
XTALI: length 6.9
  TOP w0.102: UL1.10 264.11,95.29 264.58,95.75 264.58,96.17 264.45,96.3 264.45,97.44 264.65,97.65 RL11.2 CL14.2 265.74,98.51 YL1.1
XTALO: length 5.3
  TOP w0.102: UL1.9 264.32,94.89 v2(264.97,95.54) 265.21,95.78 265.21,96.54 RL11.1 265.48,96.73 265.66,96.55 265.66,95.98 265.78,95.86 RL34.2
XTALO_R: length 2.4
  TOP w0.102: RL34.1 CL13.2 268.46,96.32 YL1.3
Z2805: length 3.2
  TOP w0.102: RL18.1 278.48,124.52 v1(278.44,124.56) 278.44,125.12 v2(278.32,125.24)
  BOTTOM w0.102: TL1.22 v1(278.44,124.56)
Z2806: length 3.6
  TOP w0.102: v1(270.82,124.6) 270.86,124.56 RL16.1 v2(271.92,123.55)
  BOTTOM w0.102: TL1.16 v1(270.82,124.6)
Z2807: length 3.1
  TOP w0.102: RL17.1 277.21,124.53 v1(277.17,124.57) 277.17,124.93 v2(276.97,125.13)
  BOTTOM w0.102: TL1.21 v1(277.17,124.57)
Z2808: length 3.1
  TOP w0.102: v2(269.55,125.15) v1(269.55,124.56) 269.59,124.52 RL15.1
  BOTTOM w0.102: TL1.15 v1(269.55,124.56)
N40459: length 3.2
  TOP w0.102: v2(85.06,116.26) QV2.1 85.38,114.84 86.51,114.84 RV5.2
N46665: length 4.5
  TOP w0.102: CA29.1 295.46,73 v2(295.94,73.47)
  TOP w0.203: CA29.1 294.38,72.77 293.44,72.77 292.52,71.84 UA1.35
N46669: length 3.6
  TOP w0.203: UA1.36 292.47,72.24 293.07,72.84 293.07,72.9 v2(293.39,73.22) 293.79,73.22 294.61,74.04 294.61,74.36 CA29.2
N46677: length 7.6
  TOP w0.102: CA25.1 296.39,70.72 297.01,70.09 298.17,70.09 v2(298.79,70.71)
  TOP w0.203: CA25.1 295.79,70.24 292.63,70.24 292.63,70.24 UA1.31
N46697: length 0.9
  TOP w0.254: CA27.1 RA12.1
N46705: length 0.9
  TOP w0.254: CA28.1 RA13.1
N46713: length 5.1
  TOP w0.102: RA21.2 299.91,73.44 299.91,73.12 v2(300.3,72.73)
  TOP w0.254: 297.97,74.33 298.48,74.33 298.88,73.93 299.42,73.93 RA21.2 ; 297.97,74.33 QA2.5 ; 297.97,74.33 297.66,74.33 297.32,74.67 QA2.6
N46735: length 2.4
  TOP w0.102: v2(282.46,72.64) 282.51,72.59 282.51,71.7 282.66,71.55 CA33.1 RA17.2
N70739: length 7.1
  TOP w0.102: JDEG1.1 277.21,11.87 277.01,12.07 277.01,13.22 v2(275.36,14.87) 274.06,16.16 RE71.2
N70745: length 28.1
  TOP w0.102: v1(254.3,70.4) 254.34,70.4 253.87,70.86 UE2.B61 ; RE64.1 257.46,78.25 257.46,79.43 258.65,80.62 v2(259.23,80.62) 260.35,80.62 v1(261.1,79.87)
  IN3 w0.102: v1(261.69,70.04) 261.69,70.37 261.1,70.96 258.87,70.96 258.22,71.61 256.1,71.61 255.78,71.29 255.78,70.13 255.49,69.85 254.85,69.85 v1(254.3,70.4)
  BOTTOM w0.102: v1(261.69,70.04) 261.76,70.1 261.76,72.94 261.41,73.29 261.41,76.09 261.9,76.58 261.9,79.07 v1(261.1,79.87)
N70747: length 2.1
  TOP w0.102: CE34.1 256.51,57.13 v2(256.51,57.95) 256.51,58.06 256.83,58.38 RE66.2
N70757: length 7.8
  TOP w0.102: UE2.A59 253.12,73.25 253,73.37 253,74.85 v2(253.48,75.33) 253.83,75.33 256.13,77.63 RE58.1 RE57.1
N75571: length 4.6
  TOP w0.102: QZ3.1 279.04,18.21 DZ3.2 DZ4.2 ; v2(277.91,20.17) 278.99,19.09 DZ4.2 ; DZ4.2 279.4,19.39 RZ24.2
N75591: length 6.3
  TOP w0.102: QZ4.1 281.84,20.26 v2(281.32,20.26) 280.82,20.76 280.82,22.82 280.52,23.12 279.55,23.12 RZ27.1
N75595: length 2.2
  TOP w0.102: QZ3.3 279.04,16.91 DZ3.1 278.37,16.24 v2(278.37,16)
N13388109: length 2.9
  TOP w0.254: PR916.2 92.05,75.78 v2(92.29,76.02) 93.92,76.02 PQ906.2
N13388133: length 7.3
  TOP w0.102: v2(97.1,75.6) 96.76,75.26 PQ906.1
  TOP w0.254: PQ906.1 95.93,73.82 96.64,73.11 PQ909.2 96.64,70.24 PR915.2
N13388149: length 20.9
  TOP w0.102: v2(81.46,73.31) 81.52,73.25 v1(82.7,73.25)
  TOP w0.254: PQ909.1 v1(98.45,73.59) ; PD901.2 82.71,72.47 82.71,73.23 82.7,73.25 v1(82.7,73.25)
  IN4 w0.254: v1(82.7,73.25) 83.35,73.25 86.28,76.18 95.68,76.18 98.27,73.59 v1(98.45,73.59)
N13388161: length 4.2
  TOP w0.102: v2(96.11,68.83) 96.15,68.83 PR915.1
  TOP w0.254: PR915.1 PR913.2 97.94,70.11 98.57,70.75 PQ909.3
N15438178: length 7.2
  TOP w0.102: v2(61.97,52.71) PR811.1
  TOP w0.508: PR811.1 60.55,52.99 59.73,53.81 PD803.1 PD801.1 PD802.1
N15438627: length 6.3
  TOP w0.203: v1(57.31,56.55) 57.03,56.26 PU801.6
  BOTTOM w0.102: PR812.1 57.76,57.62 57.76,58.58 v2(58.18,59.01)
  BOTTOM w0.254: PC815.1 PR813.1 56.88,56.55 v1(57.31,56.55) 57.58,56.55 PR812.1
N15439163: length 3.1
  TOP w0.203: PU801.5 57.52,55.86 v2(57.85,56.2) 58.07,56.42 PR815.2
N15439291: length 4.2
  TOP w0.203: PR816.2 v1(57.31,58.74) 57.13,58.56 v2(57.13,57.97) 57.13,57.32 56.47,56.66 PU801.7
  BOTTOM w0.254: PC823.2 v1(57.31,58.74)
N15439295: length 4.2
  TOP w0.203: PU801.8 55.26,57.92 55.34,58.01 56.11,58.01 56.42,58.33 v1(56.42,58.84)
  TOP w0.254: PR819.2 v1(56.42,58.84)
  BOTTOM w0.102: v2(56.89,59.17) 56.56,58.84 v1(56.42,58.84)
  BOTTOM w0.254: PC824.2 v1(56.42,58.84)
N15439512: length 3.6
  TOP w0.203: PU801.9 54.86,58.09 v1(55.53,58.77)
  TOP w0.254: PR820.2 v1(55.53,58.77)
  BOTTOM w0.102: v1(55.53,58.77) 55.43,58.77 v2(55.01,59.19)
  BOTTOM w0.254: PR822.2 v1(55.53,58.77)
N15440461: length 2
  TOP w0.203: PU801.10 v2(54.46,58.54) 54.46,59.27 PR818.2
N15440728: length 3.4
  TOP w0.203: v1(51.15,56.42) 51.31,56.26 PU801.16
  BOTTOM w0.102: v2(50.57,56.85) 51,56.42 v1(51.15,56.42)
  BOTTOM w0.254: PR827.2 PR829.1 51.47,56.8 51.15,56.49 v1(51.15,56.42)
N15441413: length 3.2
  TOP w0.102: PR825.1 50.66,54.83 49.79,53.97 v2(49.64,53.97)
  TOP w0.203: PR825.1 51.03,55.22 51.28,55.46 PU801.18
N15441884: length 2.5
  TOP w0.102: v2(48.45,58.8) 48.45,58.8 48.99,58.26 49.81,58.26 50.28,57.79 PC828.1
N15442134: length 25.3
  TOP w0.203: v1(50.85,53.11) 50.68,53.27 50.68,53.86 v2(50.95,54.12) 51.49,54.66 PU801.20
  IN3 w0.254: v1(50.85,53.11) 50.66,52.92 50.66,52.18 48.8,50.33 38.14,50.33 37.09,49.28 37.09,48.13 v1(37.31,47.91)
  BOTTOM w0.254: v1(50.85,53.11) 50.72,53.23 50.72,54.33 PC830.1 52.09,54.83 PC829.2 ; v1(37.31,47.91) 37.12,47.72 37.12,46.41 37.31,46.22 PR823.3
N15442185: length 27
  TOP w0.203: v1(50.15,53.11) 50.35,53.31 50.35,54.09 51.33,55.06 PU801.19
  IN3 w0.254: v1(36.55,47.91) 36.74,48.1 36.74,49.43 37.99,50.68 48.59,50.68 50.28,52.37 50.28,52.98 v1(50.15,53.11)
  BOTTOM w0.254: v1(50.15,53.11) 50.28,53.23 50.28,54.8 PC830.2 52.07,55.75 PC831.1 ; PR823.2 36.51,46.22 36.75,46.47 36.75,47.71 v1(36.55,47.91)
N15443707: length 2.8
  TOP w0.102: v2(53.86,48.75) 53.86,50.4 54.52,51.06 PR814.1
N17156946: length 17.9
  TOP w0.102: v2(81.48,99.92) PQ1.4
  TOP w0.254: v1(78.66,102) PR1.2 ; PR1.2 78.66,100.29 79.03,99.92 PQ1.4 ; PR1.2 78.67,101.24 PR15.1 PR14.1
  IN2 w0.254: v1(69,97.89) 70.84,99.73 75.85,99.73 78.13,102 v1(78.66,102)
N17156948: length 4.8
  TOP w0.102: PQ1.1 78.37,98.02 78.5,97.89 v2(78.5,96.76)
  TOP w0.254: PQ1.1 76.74,98.02 76.55,98.21 76.55,98.78 76.74,98.97 PQ1.2
N17252180: length 10.8
  IN1 w0.508: v1(6.64,45.44) 6.64,49.5 8.35,51.22 v1(10.77,51.22)
  BOTTOM w0.508: PQ904.4 11.71,50.46 10.96,51.22 v1(10.77,51.22)
N17252838: length 2.2
  TOP w0.102: v2(4.16,58.01) 4.43,57.74 PR919.2
  TOP w0.254: PQ911.5 5.22,57.7 PR919.2
N18325201: length 3.3
  TOP w0.102: v2(279.44,114.4) CL16.1 278.48,115.18 v1(278.44,115.22)
  BOTTOM w0.102: TL1.3 v1(278.44,115.22)
N18325205: length 2.9
  TOP w0.102: CL17.1 277.21,115.15 v1(277.17,115.18) v2(277.17,115.83)
  BOTTOM w0.102: TL1.4 v1(277.17,115.18)
N18325209: length 3.2
  TOP w0.102: v1(270.82,115.18) 270.86,115.15 CL20.1 v2(271.83,114.4)
  BOTTOM w0.102: TL1.9 v1(270.82,115.18)
N18325213: length 2.8
  TOP w0.102: CL21.1 269.59,115.2 v1(269.55,115.24) v2(269.55,115.72)
  BOTTOM w0.102: TL1.10 v1(269.55,115.24)
N18339814: length 11.5
  TOP w0.102: v1(298.04,68.53) 298.43,68.53 v2(298.6,68.36)
  TOP w0.254: RA25.2 v1(293.67,62.07) ; v1(298.04,68.53) DA5.1
  IN2 w0.254: v1(298.04,68.53) 298.04,66.32 293.8,62.07 v1(293.67,62.07)
N18339816: length 15.9
  TOP w0.102: v2(298.07,69.59) 297.96,69.69 v1(297.53,69.69)
  TOP w0.254: v1(297.53,69.69) 297.51,69.67 DA4.1 ; v1(289.84,61.31) 289.58,61.57 RA24.2
  BOTTOM w0.254: v1(289.84,61.31) 289.84,65.85 290.76,66.77 294.61,66.77 v1(297.53,69.69)
N18364501: length 3.1
  TOP w0.102: RV50.1 252.88,124.75 252.46,124.75 v2(251.98,124.27) 251.76,124.05 251.76,123.86 251.26,123.35 UV7.20
N18366912: length 5.7
  TOP w0.102: v1(251.59,122.15) 251.58,122.15 UV7.17 ; v1(252.45,125.23) 252.45,125.33 CV60.1
  IN4 w0.102: v1(252.45,125.23) 252.45,123.02 v1(251.59,122.15)
  BOTTOM w0.102: v1(252.45,125.23) v2(252.94,125.23)
N18431888: length 12.3
  TOP w0.102: v1(289.81,40.79) v2(290.31,40.79)
  TOP w0.254: RA1.2 284.72,41.64 285.75,42.67 286.85,42.67 287.3,42.22 287.3,41.08 287.59,40.79 DA2.2 v1(289.81,40.79)
  BOTTOM w0.254: v1(289.81,40.79) 290.31,41.28 292.22,41.28 293,42.06 JHP1.5
N18490882: length 3.9
  TOP w0.102: UI3.16 276.72,104.12 276.51,104.33 RI14.2 275.46,106.17 v3(274.77,106.17)
N18609334: length 6.3
  TOP w0.102: v2(108.33,114.71) RV6.2 107.03,114.31 QV7.1 106.36,113.72 104.77,115.3 104.35,115.3 QV8.2
N18754440: length 2.6
  TOP w0.102: v2(278.91,56.68) RA27.2 279.13,55.08 QA3.3
N18754442: length 2.5
  TOP w0.102: RA28.2 276.32,52.91 QA3.6 v2(277.23,51.78)
N18779977: length 2.1
  BOTTOM w0.102: v2(164.16,126.02) 164.27,125.9 164.91,125.9 C319.1 R273.2
N18779979: length 2.6
  BOTTOM w0.102: C43.1 R41.2 156.78,126.2 157.21,126.63 v2(158.25,126.63)
N18779981: length 1.9
  BOTTOM w0.102: R6.2 C42.1 v2(152.13,126.2)
N18894766: length 0.9
  TOP w0.254: PR646.2 88.67,93.51 PC640.1
N18894780: length 1.8
  TOP w0.102: v2(90.59,94.4) PC601.1
  TOP w0.254: PR652.2 89.57,94.32 PC601.1
N18894855: length 3.3
  TOP w0.203: PU602.28 86.12,91.26 v2(85.84,91.53)
  TOP w0.254: PR636.1 PC632.1 86.01,92.05 85.84,91.88 v2(85.84,91.53)
N18894856: length 2
  TOP w0.102: v2(87.01,94.56) 86.78,94.33 PR641.1
  TOP w0.254: PR641.1 86.01,94.32 PC632.2
N18894871: length 2.1
  BOTTOM w0.102: v2(137.46,118.03) 137.37,118.12 PH604.1
  BOTTOM w0.254: PH604.1 136.1,118.45 PR642.2
N19651849: length 1.9
  TOP w0.102: RE27.2 CE9.1 v2(230.6,76.95)
N19651850: length 6.5
  TOP w0.102: UE1.B19 236.67,70.94 v1(236.68,70.93) ; RE24.1 239.58,74.76 v1(238.97,74.15) 238.94,74.15 v2(238.48,73.69)
  BOTTOM w0.102: v1(238.97,74.15) 236.68,71.86 v1(236.68,70.93)
N19817114: length 2.2
  TOP w0.102: v1(15.03,42.53) v2(15.03,43.1)
  TOP w0.254: PC904.1 PR910.2 v1(15.03,42.53)
N19957038: length 6.1
  TOP w0.254: v1(13.31,41.5) 13.62,41.82 PR910.1 PC904.2 PR912.1 14.12,39.2 v2(13.75,38.83) 12.99,38.83 12.67,39.15 PD904.1
N20360585: length 4.9
  TOP w0.203: CA49.2 295.98,72.45 293.66,72.45 292.65,71.44 292.39,71.44 UA1.34
N20361305: length 2.8
  TOP w0.203: CA35.2 293.71,66.28 v2(293.14,66.85) 292.83,67.15 292.83,67.47 292.47,67.84 UA1.25
N20363962: length 11.2
  TOP w0.102: v2(294.42,59.55) CA51.1
  TOP w0.203: v1(290.93,65.19) 290.8,65.19 290.29,65.7 290.29,65.81 290.06,66.04 UA1.21
  TOP w0.254: RA44.1 294.66,61.11 CA51.1 293.39,60.87 v1(293.09,61.17)
  BOTTOM w0.254: v1(290.93,65.19) 291.27,64.84 291.27,63.19 293.09,61.38 v1(293.09,61.17)
N20363967: length 3.1
  TOP w0.203: CA52.1 291.05,75.09 290.66,74.7 290.66,73.81 290.46,73.61 UA1.39
N20363972: length 5.4
  TOP w0.102: CA53.1 281.53,69.66 281.94,69.25 282.79,69.25 282.97,69.43 283.96,69.43 284.48,69.95 v2(284.66,69.95) 284.93,69.95 285.04,69.84 UA1.7
N20880735: length 1.9
  TOP w0.102: v2(232.46,83.65) PC307.2
  TOP w0.254: PC307.2 PR308.1
N20899585: length 3.9
  TOP w0.102: RV600.1 227.86,114.08 228.4,114.08 v2(229.08,113.4) 229.08,113.3 229.47,112.91 229.88,112.91 229.98,112.81 UV26.20
N20899609: length 3.1
  TOP w0.102: CV605.1 229.29,114.51 231.18,112.62 UV26.17
N20987678: length 6.7
  TOP w0.102: v2(12.46,56.84) 12.46,55.49 PQ910.3
  TOP w0.254: PD905.1 9.12,57.33 PR911.2 9.61,56.63 11.14,55.1 PQ910.3
N20987955: length 3.6
  TOP w0.102: v2(67.27,68.6) 67.27,69.44 PR903.2
  TOP w0.254: PQ902.6 65.77,70.28 65.59,70.1 65.59,69.74 65.7,69.63 PQ902.5 66.57,69.63 66.65,69.55 PR903.2
N20987996: length 3.4
  TOP w0.102: PQ902.3 63.23,68.98 v2(63.21,69.01)
  TOP w0.254: PR904.1 PR902.2 64.67,68.78 64.46,68.98 PQ902.3
N20988471: length 3.6
  TOP w0.254: PQ907.6 100.59,72.54 100.53,72.6 PR909.1 v2(100.05,71.33) 100.46,70.92 PU903.1
N21009123: length 1.2
  BOTTOM w0.102: PR201.1 v2(81.84,77.38)
N21135665: length 3.8
  TOP w0.102: PR821.1 50.94,52.05 v2(50.39,52.6)
  TOP w0.203: PR821.1 51.28,53.88 51.66,54.26 PU801.21
N24606174: length 3.6
  TOP w0.102: PC313.1 230.45,81.21 v2(230.45,80.87)
  TOP w0.254: PC313.1 229.02,82.14 228.5,82.66 PU301.5
N25124064: length 25.6
  TOP w0.203: UA1.22 290.46,66.4 290.8,66.06 v1(290.8,65.82)
  TOP w0.254: v1(293.68,61.38) 293.43,61.63 292.87,61.63 291.91,60.66 290.19,60.66 289.35,59.83 289.35,58.2 286.67,55.51 283.45,55.51 283.21,55.75 v2(282.54,55.75) 281.99,55.19 RA45.1
  BOTTOM w0.254: v1(293.68,61.38) 293.59,61.38 291.63,63.34 291.63,65.25 291.06,65.82 v1(290.8,65.82)
N26452800: length 10.1
  TOP w0.102: PR5.1 v2(73.43,121.98)
  TOP w0.254: PR5.1 73.43,119.93 73.16,119.67 PQ3.1 72.6,118.46 72.31,118.17 72.31,116.82 v1(72.11,116.62) 71.85,116.37 PR8.2 ; PL4.1 v1(72.36,114.46)
  BOTTOM w0.254: v1(72.36,114.46) 72.36,116.37 v1(72.11,116.62)
N26505659: length 13.5
  TOP w0.102: PR618.1 81.29,87.16 v1(81.16,87.03)
  BOTTOM w0.102: PR601.2 v1(81.16,87.03) 80.81,86.68 80.81,83.66 80.68,83.54 80.38,83.54 80.26,83.66 80.26,84.93 80.13,85.06 79.77,85.06 79.65,84.93 79.65,83.64 79.55,83.54 79.1,83.54 78.97,83.66 v2(78.97,84.73) 78.97,85.63 PR606.2
N26505661: length 2.7
  TOP w0.102: PR625.1 81.29,88.05 v1(81.16,87.92) 81.16,87.71 80.91,87.45 v2(80.91,87.46)
  BOTTOM w0.102: PR607.2 v1(81.16,87.92) PR604.2
N26505677: length 3.8
  TOP w0.102: v2(80.9,89.51) 80.9,89.08 v1(81.18,88.81) 81.68,88.81 PR626.1
  BOTTOM w0.102: PR605.2 v1(81.18,88.81) 81.06,88.92 81.06,89.25 80.93,89.38 80.55,89.38 80.38,89.2 PR609.2
N26506003: length 5.7
  TOP w0.102: v2(81.43,82.18) 81.43,82.18 81.43,83.07 82.73,84.36 PR616.2
  TOP w0.203: PR616.2 83.09,84.36 84.05,85.31 84.05,85.89 84.21,86.05 PU602.40
N26506037: length 2.9
  TOP w0.203: PU602.39 84.11,86.45 83.8,86.14 PR612.2 PR614.2
N26506182: length 2.3
  TOP w0.102: PR626.2 82.78,88.93 83.66,88.05 PU602.35
N26506196: length 2.1
  TOP w0.102: PU602.36 83.12,87.65 PR625.2
N26506209: length 2
  TOP w0.102: PU602.37 83.86,87.25 83.76,87.16 PR618.2
N26506689: length 7.3
  TOP w0.102: v2(79.12,83.86) 79.12,83.94 PR678.2 80.46,85.28 80.46,86.06 80.97,86.57 83.46,86.57 83.74,86.85 PU602.38
N26508248: length 3
  TOP w0.203: v1(83.82,88.54) 83.9,88.45 PU602.34
  BOTTOM w0.254: PR602.1 84.24,89.25 84.68,88.81 PC603.1 83.87,88.49 v1(83.82,88.54)
N26508256: length 3.5
  TOP w0.203: v1(83.41,89.19) 83.61,88.98 84.07,88.98 84.21,88.85 PU602.33
  BOTTOM w0.254: PR603.1 81.58,89.76 PC604.1 82.84,89.76 v1(83.41,89.19)
N26509112: length 2.2
  TOP w0.203: 83.81,89.52 83.98,89.35 84.14,89.35 84.24,89.25 PU602.32
  TOP w0.254: PR608.1 83.5,89.82 83.81,89.52
N26509117: length 3.4
  TOP w0.102: PR611.1 82.73,91.6 v2(82.8,91.68)
  TOP w0.203: PU602.31 84.22,89.65 83.95,89.92
  TOP w0.254: 83.95,89.92 83.16,90.71 PR611.1
N26518420: length 4.2
  TOP w0.203: PU602.20 90.15,89.65 90.35,89.85
  TOP w0.254: 90.35,89.85 90.35,90.64 v2(90.78,91.07) 90.98,91.27 PC630.1 91.79,91.27 91.81,91.28 PR640.1
N26519264: length 2.8
  BOTTOM w0.102: v2(112.72,95.36) 112.81,95.45 PH605.1
  BOTTOM w0.254: PH605.1 112.16,96.29 111.8,95.92 PR657.2
N26522108: length 1.8
  TOP w0.102: PR645.1 94.52,87.73 v2(94.54,87.74)
  TOP w0.254: PR645.1 PC639.2
N26523008: length 1.9
  BOTTOM w0.102: v2(94.38,86.03) 94.38,86.84 PC647.2
  BOTTOM w0.254: PC647.2 94.26,86.97 PR650.2
N26523611: length 2.5
  BOTTOM w0.102: PC629.2 90.42,89.96 v2(90.68,89.96)
  BOTTOM w0.254: PC629.2 88.92,88.46 PR639.1
N26526626: length 0.9
  TOP w0.254: PR632.2 88.22,82.3 PC627.1
N26527807: length 2
  BOTTOM w0.102: PR628.2 v2(100.8,86.1)
  BOTTOM w0.254: PH602.1 PR628.2
N26528911: length 3.5
  TOP w0.203: PR638.2 PC627.2 88.24,83.47 88.68,83.92 v2(88.68,84.15) 88.68,84.3 88.12,84.86 PU602.8
N26532119: length 2.4
  TOP w0.102: PR623.1 85.57,80.46 v2(85.7,80.34)
  TOP w0.254: PR623.1 85.57,81.45 PC621.2
N26532121: length 4.1
  TOP w0.203: PU602.5 86.92,84.22 v2(86.86,84.17) 86.45,83.75 PR622.2 86.46,83.21 PR621.2 PR623.2
N26533060: length 3.2
  TOP w0.203: v1(86.33,84.49) 86.33,84.49 86.33,84.49 86.52,84.67 PU602.4
  BOTTOM w0.102: v2(85.79,84.27) 86.1,84.27 v1(86.33,84.49)
  BOTTOM w0.254: v1(86.33,84.49) 86.27,84.55 PC616.2 PR617.2
N26533062: length 0.9
  BOTTOM w0.254: PR617.1 PC614.2
N26533293: length 2.4
  TOP w0.203: PU602.3 86.12,84.91 85.58,84.37 v2(85.58,84.21) PR610.2
N26533871: length 5
  TOP w0.203: v1(85.15,83.99) 85.15,84.37 85.72,84.94 PU602.2
  BOTTOM w0.102: v2(83.59,84.36) 84.4,85.17 PR613.2
  BOTTOM w0.254: PR613.2 PC613.2 85.38,84.51 85.15,84.29 v1(85.15,83.99)
N26535263: length 7.6
  BOTTOM w0.254: PL603.3 112.81,101.51 113.2,101.12 113.2,99.23 112.05,98.08 112.05,97.51 PR661.1
N26554964: length 3
  TOP w0.102: v2(86.59,79.36) 86.46,79.49 PR621.1
  TOP w0.254: PC617.2 PR621.1
N26566701: length 0.9
  BOTTOM w0.254: PR630.2 PC631.1
N26570644: length 1.9
  TOP w0.102: PR644.1 v2(92.61,93.2)
  TOP w0.254: PR644.1 92.15,92.17 92.14,92.19 PC630.2
N26661962: length 6.7
  TOP w0.102: v2(289.46,11.54) 289.23,11.54 PR511.2
  TOP w0.254: PR511.2 PR507.2 PR509.1 PC510.1 289.97,14.41 PU502.8
N26661997: length 5.2
  TOP w0.102: v2(297.84,13.99) PR510.1
  TOP w0.254: PR510.1 298.68,15.86 PR508.2 PC509.2 297.51,15.68 PU502.2
N27447034: length 3.5
  TOP w0.102: RE70.2 261.75,56.53 v2(261.21,56.53) 260.75,56.53 259.99,55.77 QE4.2
N27829830: length 1.9
  TOP w0.102: RZ63.1 CZ77.1 v2(211.4,76.41)
N27958885: length 3.2
  TOP w0.102: v2(213.89,65.4) 213.89,65.79 214.25,66.15 RZ62.1 214.99,66.16 UZ12.27
N28424999: length 5.5
  BOTTOM w0.076: UC1.AW71 133.33,82.23 132.4,82.23 132.11,81.94 132.11,81.37 131.97,81.23 131.97,80.93 130.96,79.92 130.29,79.92 T113.1
N28425002: length 7.8
  BOTTOM w0.076: UC1.AW70 133.91,82.03 132.91,82.03 132.87,82.06 132.47,82.06 132.28,81.87 132.28,81.3 132.14,81.16 132.14,80.86 130.85,79.57 129.23,79.57 128.37,80.44
  BOTTOM w0.102: T114.1 128.37,80.44
N28489601: length 5.3
  BOTTOM w0.102: RC222.2 186.18,128.27 v2(187.15,128.27) 187.81,128.27 188.3,127.77 SW1.2
N28712229: length 1.2
  BOTTOM w0.203: v1(90.68,80.81) 90.82,80.66 PU605.7
  vias: v2(90.51,81.26)
N28712232: length 1.3
  BOTTOM w0.203: v1(90.68,80.09) 90.84,80.26 PU605.6
  vias: v2(90.52,79.43)
N28713556: length 3.3
  BOTTOM w0.102: PR671.1 v2(95.59,83.8)
  BOTTOM w0.203: PR671.1 95.87,82.38 95.87,81.23 95.7,81.06 PU605.1
N28714854: length 4.9
  TOP w0.102: v2(100.75,105.83) 100.87,105.7 PC655.2
  TOP w0.508: v1(101.75,103.59) 102.01,103.59 102.33,103.92 102.33,104.81 101.95,105.19 PC655.2
  BOTTOM w0.203: v1(101.75,103.59) 101.76,103.6 PU603.7
N28714856: length 7
  TOP w0.102: v2(100.85,101.09) 100.85,102.05 v1(101.76,102.97)
  TOP w0.508: PR660.2 103.16,105.19 102.97,105 102.97,103.6 102.33,102.97 v1(101.76,102.97)
  BOTTOM w0.203: PU603.6 101.99,103.2 v1(101.76,102.97)
N28714858: length 2.5
  TOP w0.102: v2(104.43,107.1) PR660.1
  TOP w0.508: PR660.1 PC655.1
N28714920: length 3.5
  TOP w0.102: v1(106.74,104.78) 106.56,104.78 v2(105.96,104.18)
  BOTTOM w0.203: PU603.1 106.6,104 106.74,104.13 v1(106.74,104.78) 106.74,105.02 107.15,105.43 PR659.1
N28718522: length 4.1
  TOP w0.254: v1(123.79,114.21) 124.49,114.21 v2(125.13,113.57) 125.96,113.57 126.21,113.83 PC611.2
  BOTTOM w0.254: PU606.2 123.9,114.33 v1(123.79,114.21)
N28718526: length 2.5
  TOP w0.102: v2(129.68,115.11) 129.19,114.63 PR619.1
  TOP w0.254: PR619.1 PC611.1
N28742882: length 3.3
  TOP w0.102: v2(51.95,59.25) 52.16,59.46 PR835.2
  TOP w0.203: PR835.2 52.87,59.03 53.66,58.24 PU801.12
N28742885: length 2.1
  TOP w0.203: PR836.2 53.76,59.01 54.06,58.71 PU801.11
N28769860: length 3.2
  TOP w0.254: PR422.1 PR421.2 234.8,45.37 v2(234.99,45.56) 235.28,45.86 PU401.5
N28771761: length 3.3
  TOP w0.254: PU401.14 v2(240.5,44.86) 241.47,44.86 PR425.2 PR404.2
N28771835: length 4
  TOP w0.102: v2(240.78,95.79) 241.36,95.21 PR426.2
  TOP w0.254: PU402.14 241.95,94.54 241.72,94.78 PR426.2 PR410.2
N28810563: length 4.2
  TOP w0.102: UZ2.10 283.84,110.92 283.73,111.03 CZ23.1 282.69,110.59 281.34,110.59 v2(281.02,110.27)
N28856399: length 7.6
  BOTTOM w0.076: UC1.BA70 134.24,81.05 134.24,80.43 134.07,80.27 132.03,80.27 132.01,80.25 131.99,80.25 130.59,78.85 128.61,78.85 128.37,79.09
  BOTTOM w0.102: T16.1 128.37,79.09
N28856402: length 6.3
  BOTTOM w0.076: T17.1 130.66,79.16 132.3,80.79 132.3,81.09 132.51,81.3 133.06,81.3 133.14,81.38 133.71,81.38 133.85,81.52 134.42,81.52 UC1.BA68
N28857231: length 6.7
  BOTTOM w0.076: UC1.BB68 134.99,80.58 134.34,79.94 132.16,79.94 130.04,77.81 T12.1
N28857234: length 7.5
  BOTTOM w0.076: 128.37,77.87 128.89,78.39 130.39,78.39 132.09,80.1 134.27,80.1 134.55,80.39 UC1.BB69
  BOTTOM w0.102: T13.1 128.37,77.87
N28857237: length 1.3
  TOP w0.102: v1(167.15,88.37) 166.94,88.59 T14.1
  BOTTOM w0.076: v1(167.15,88.37) 166.79,88.01 UC1.AK13
N28857240: length 1.2
  TOP w0.102: T15.1 167.84,88.32 v1(167.79,88.37)
  BOTTOM w0.076: v1(167.79,88.37) 167.44,88.03 UC1.AK12
N28861827: length 8.8
  BOTTOM w0.076: RC120.1 133.19,107.38 133.46,107.38 134.07,106.76 134.59,106.76 134.59,106.77 v2(134.91,106.77) 134.91,106.76 135.01,106.66 135.49,106.66 136.35,105.8 136.35,105.35 137.68,104.02 137.68,102.51 137.77,102.42 UC1.C64
N28891648: length 29.1
  TOP w0.102: RC245.2 189.24,76.6 189.24,75.78 189.86,75.16 v2(190.01,75.16) v1(190.66,75.16)
  BOTTOM w0.076: 171.22,76.83 169.8,78.24 169.37,78.24 167.95,79.66 UC1.BB11
  BOTTOM w0.102: 171.22,76.83 172.85,75.19 176.74,75.19 177.63,74.3 189.19,74.3 190.05,75.16 v1(190.66,75.16)
N28938912: length 1.9
  BOTTOM w0.102: v2(184.43,100.95) CC8.2 RC29.1
N28938914: length 2
  BOTTOM w0.102: RC28.1 CC7.2 186.19,89.24 v2(185.6,88.64)
N29198215: length 3.7
  BOTTOM w0.102: v2(171.35,116.62) RZ83.1 RZ82.1 170.9,118.97 170.19,118.97 170.05,118.83 UZ20.4
N29207759: length 12.5
  TOP w0.102: v1(91.41,84.87) 90.92,84.87 v2(90.85,84.93)
  TOP w0.203: PR610.1 84.66,83.23
  TOP w0.254: v1(84.67,84.35) PR610.1 ; 84.66,83.23 PR631.2
  IN2 w0.254: v1(84.67,84.35) 85.38,85.06 91.22,85.06 v1(91.41,84.87)
  BOTTOM w0.254: v1(91.41,84.87) 92.34,83.94 PH601.2
N29263363: length 3.7
  TOP w0.102: v2(240.33,86.84) PR424.1
  TOP w0.254: PU402.5 240.95,89.82 240.33,89.2 PR423.1 PR424.1
N29270847: length 26.6
  TOP w0.102: v1(92.19,86.36) 92.19,85.99 v2(92.33,85.85)
  IN2 w0.254: v1(107.63,97.8) 105.88,96.05 101.71,96.05 97.48,91.82 93.19,91.82 92.19,90.81 v1(92.19,86.36)
  BOTTOM w0.254: v1(92.19,86.36) 92.12,86.42 92.12,87.04 92.48,87.4 PR647.2 91.62,87.85 PR635.1 ; PH603.2 v1(107.63,97.8)
N29708559: length 13.4
  BOTTOM w0.076: 178.51,80.49 174.18,80.49 173.76,80.91 172.64,80.91 172.47,81.07 172.47,81.41 UC1.AY4
  BOTTOM w0.102: 178.51,80.49 180.73,80.49 181.81,79.41 182.2,79.41 183.21,78.39 T126.1
N29708561: length 13.5
  BOTTOM w0.076: 178.49,79.73 177.98,79.73 177.44,80.27 173.28,80.27 UC1.BB3
  BOTTOM w0.102: T127.1 184.24,78.39 183.93,78.09 183.23,78.09 182.16,79.16 181.77,79.16 181.2,79.73 178.49,79.73
N29708599: length 7.3
  BOTTOM w0.076: T128.1 176.22,84.59 175.43,85.38 173.92,85.38 173.76,85.23 173.76,85.03 173.48,84.75 172.01,84.75 171.83,84.57 171.83,84.12 UC1.AU5
N29708601: length 6.2
  BOTTOM w0.076: T129.1 175.81,86.09 173.63,86.09 173.44,85.89 173.44,85.65 173.23,85.45 172.04,85.45 171.83,85.24 171.83,84.88 171.41,84.46 UC1.AT5
N29708639: length 7
  BOTTOM w0.076: UC1.BB5 171.89,80.24 172,80.24 172.52,79.73 176.08,79.73 177.42,78.39 T130.1
N30342894: length 2.6
  TOP w0.102: v2(240.64,126.35) 240.19,126.8 QV4.2 241.33,127.53 RV19.2
N30404696: length 1.7
  TOP w0.102: CZ90.1 279.15,69.27 UZ5.12
N30404698: length 1.7
  TOP w0.102: CZ91.1 279.06,68.47 UZ5.10
N31877076: length 2.8
  TOP w0.102: v2(94.68,110.92) 94.68,110.44 v1(94.78,110.33) 95.1,110.65 95.26,110.65 LV1.1
  BOTTOM w0.102: JEDP1.21 v1(94.78,110.33)
N32011565: length 5.7
  IN2 w0.508: v1(130.66,115.79) 130.66,115.48 130.08,114.91 128.12,114.91 127.23,115.79 v1(126.65,115.79)
  BOTTOM w0.102: v1(130.66,115.79) 130.85,115.79 v2(131.24,116.19)
N32011581: length 7.4
  TOP w0.102: v1(124.5,113.32) v2(123.8,113.32)
  IN4 w0.508: v1(124.5,113.32) 129.13,113.32 v1(130.59,111.86)
N32015249: length 3.6
  TOP w0.102: v2(126.25,116.43) 126.58,116.43 127.24,115.77 PR679.1
  TOP w0.254: v1(127.48,114.33) 127.24,114.57 PR679.1
  BOTTOM w0.254: PU606.7 v1(127.48,114.33)
N32114561: length 1.1
  TOP w0.102: PC821.2 v2(55.79,48.76)
N32198964: length 4.9
  TOP w0.102: PC1504.1 252.87,46.2 v2(252.31,46.75)
  TOP w0.254: PR1500.2 252.61,43.93 252.87,44.18 PR1502.1 PC1504.1 253.16,45.33 253.59,44.9 PU1500.8
N32198997: length 9.3
  TOP w0.102: v2(250.47,43.18) 251.25,43.18 252.16,42.27 252.16,41.94 PR1503.1
  TOP w0.254: PU1500.2 255.33,38.81 255.04,38.52 253.35,38.52 PC1502.2 PR1501.2 252.89,40.14 252.64,40.39 PR1503.1
N32427314: length 1.7
  TOP w0.102: CZ46.1 244.92,47.01 UZ3.12
N32427416: length 3.9
  TOP w0.102: v2(243.02,48.16) 243.27,48.4 244.41,48.4 CZ37.1 245.01,47.81 UZ3.10
N32452041: length 3.6
  BOTTOM w0.102: v2(81.35,119.78) 81.68,119.45 82.1,119.45 82.78,118.78 CZ45.1 82.87,118.8 UZ4.12
N32452300: length 6.4
  TOP w0.102: v2(279.16,110.13) 279.97,110.13 280.88,109.22 282.36,109.22 283.13,109.98 CZ38.1 283.24,110.12 UZ2.12
N32454707: length 10.3
  TOP w0.102: UZ3.5 249.31,47.81 v1(249.39,47.89)
  BOTTOM w0.102: v1(249.39,47.89) 248.68,47.17 248.68,46.38 248.52,46.22 247.04,46.22 246.9,46.08 246.9,44.22 246.05,43.37 RZ70.2 RZ71.2 246.05,41.37 v2(246.58,40.84)
N32495700: length 4.2
  TOP w0.102: v2(73.58,44.53) PC4.1
  TOP w0.254: PC4.1 PR4.2 71.35,43.67 71.15,43.87 PQ2.2
N32497274: length 4.9
  TOP w0.508: PR105.1 PR104.1 213.98,85.85 214.03,85.8 PC111.1 215.07,85.8 215.57,86.29 v2(215.57,87.32) v1(215.57,87.94)
N32507374: length 3.6
  TOP w0.203: PR620.2 v2(83.8,84.26) 84.41,84.87 85.19,84.87 85.32,85 PU602.1
N32519648: length 11.6
  BOTTOM w0.102: v2(16.29,56.11) PR804.2
  BOTTOM w0.254: PC802.2 15.73,55.1 PR804.2 16.29,54.73 16.57,54.45 18.26,54.45 18.49,54.22 PQ801.2 17.63,53.47 17.43,53.28 17.43,49.75 17.7,49.49 PQ803.2
N32519741: length 40.8
  TOP w0.203: PU801.2 57.26,54.66 v1(57.3,54.62)
  IN1 w0.254: v1(22.71,50.64) 22.9,50.45 23.21,50.45 25.68,52.92 42.93,52.92 43.38,52.47 44.24,52.47 44.51,52.21 47.57,52.21 49.44,54.07 55.93,54.07 56.4,54.54 57.22,54.54 v1(57.3,54.62)
  BOTTOM w0.254: PC808.2 55.62,54.53 PC809.1 56.47,54.62 v1(57.3,54.62) ; PR806.2 v1(22.71,50.64)
N32519935: length 41.2
  TOP w0.203: v1(57.3,54.03) 57.16,54.03 56.93,54.26 PU801.1
  IN1 w0.254: v1(22.71,49.75) 23.02,50.07 23.46,50.07 25.95,52.56 42.78,52.56 43.23,52.12 44.07,52.12 44.33,51.85 47.72,51.85 49.59,53.72 56.08,53.72 56.55,54.19 57.15,54.19 v1(57.3,54.03)
  BOTTOM w0.254: PC810.1 55.8,53.62 PC809.2 56.79,54.03 v1(57.3,54.03) ; PR807.2 v1(22.71,49.75)
N32604731: length 1.3
  TOP w0.102: UZ8.6 199.04,82.66 CZ42.1
N32630676: length 3.5
  BOTTOM w0.102: UZ4.10 82.96,118 CZ69.1 81.93,116.96 v2(81.47,116.96)
N32631320: length 4.8
  TOP w0.102: UZ22.6 195.67,82.77 195.31,83.13 195.31,83.73 CZ41.1 195.5,84.5 195.5,85.19 195.83,85.52 v2(195.83,86.24)
N32631640: length 4.5
  TOP w0.102: UZ22.3 195.67,79.3 195.9,79.08 195.9,78.33 195.59,78.02 RZ64.2 RZ65.2 193.8,78.02 v2(193.3,78.52)
N33047472: length 3.9
  BOTTOM w0.102: UZ19.4 160.84,119.49 160.55,119.78 UC13.4 159.11,119.78 RC320.2 v2(158.06,119.78)
N33199734: length 1.9
  TOP w0.102: v1(125.47,40.43) 125.47,40.01 T50.1
  BOTTOM w0.102: JDIMM1.162 125.63,40.59 v1(125.47,40.43)
N33199744: length 3.5
  TOP w0.102: v1(127.74,48.03) T51.1
  BOTTOM w0.102: v1(127.74,48.03) 127.43,48.03 126.37,49.09 JDIMM1.165
N33290988: length 2.2
  TOP w0.102: RD25.1 211.21,40.53 v2(211.21,40.09)
  TOP w0.508: RD25.1 CD54.2
N33298469: length 2.6
  TOP w0.102: T54.1 205.61,39.63 v1(206.25,40.27)
  BOTTOM w0.102: v1(206.25,40.27) 206.23,40.29 JDIMM2.162
N33298471: length 1.8
  TOP w0.102: T55.1 v1(207.07,48.6)
  BOTTOM w0.102: JDIMM2.165 206.97,48.69 v1(207.07,48.6)
N33612393: length 2.1
  TOP w0.102: RD21.1 130.67,43 v2(130.48,43.19)
  TOP w0.508: RD21.1 CD36.2
N34495988: length 5.8
  BOTTOM w0.102: RC340.1 RC339.1 180.92,87.24 179.99,87.24 179.66,87.58 178.98,87.58 178.51,87.11 QC3.2 177.95,86.54 v2(177.95,85.97)
N34678942: length 5.8
  TOP w0.102: v2(216.8,63.29) 217.37,63.86 217.37,65.73 RZ112.2 RZ90.2 215.99,66.19 UZ12.29
N35256471: length 2.6
  TOP w0.102: QZ9.2 218.83,75.36 RZ113.2
N36256403: length 9.1
  TOP w0.102: v2(268.95,53.25) 268.56,53.63 QE11.3
  TOP w0.508: QE11.3 266.16,52.02 265.22,52.02 264.93,52.31 264.93,53.18 264.11,54.01 263.81,54.01 263.34,54.48 RE90.2 263.1,54.9 RE70.1
N36518352: length 105.7
  TOP w0.102: v1(107.33,73.9) 112.53,73.9 RZ120.2 113.54,73.86 113.54,73.34 113.32,73.12 UZ26.4 ; v1(78.8,120.2) 79.35,120.75 82.69,120.75 v2(82.86,120.58) 83.45,120 85.67,120 86.11,119.56 UC14.4
  IN2 w0.102: v1(107.33,73.9) 107.33,73.33 107.01,73.01 104.77,73.01 103.45,74.33 101.06,74.33 99.11,72.37 97.66,72.37 95.6,70.32 94.57,70.32 94.12,70.77 91.14,70.77 89.86,72.06 86.94,72.06 84.71,74.29 84.71,81.34 83.55,82.5 81.39,82.5 79.89,83.99 79.89,90.88 81.9,92.88 82.76,92.88 87.02,97.14 87.02,106.8 88.06,107.84 88.06,110.54 88.58,111.06 88.58,113.39 86.12,115.86 84.68,115.86 84.11,116.43 78.79,116.43 77.68,117.53 77.68,119.08 v1(78.8,120.2)
N36519029: length 3.9
  BOTTOM w0.102: UV29.1 219.29,104.84 219.16,104.97 219.16,106.98 RV661.2 219.28,107.87 v2(219.5,108.1)
N36519054: length 4.6
  BOTTOM w0.127: RV662.1 213.56,106.49 v2(213.26,106.79)
  BOTTOM w0.254: UV29.10 216.18,104.84 215.72,105.3 214.92,105.3 CV619.2
  BOTTOM w0.508: CV619.2 RV662.1
N39381354: length 1.8
  TOP w0.102: v2(218.54,91.91) 219.03,91.91 219.56,91.39 219.56,90.8
N39381542: length 1.9
  BOTTOM w0.102: PC119.1 206.64,89.54 v2(205.41,90.78)
N39381565: length 1.2
  BOTTOM w0.102: v2(214.68,88.03) 214.46,88.25 PC114.1
N39381572: length 0.9
  BOTTOM w0.254: PR108.1 PC113.2
N39381889: length 0.9
  BOTTOM w0.254: PR117.1 204.78,86.75 204.77,86.74 PC127.2
N39382318: length 6.6
  TOP w0.102: v2(204.4,80.74) 204.4,79.6 204.78,79.22 PR101.1
  TOP w0.254: PU101.4 207.31,82.09 207.07,81.85 206.33,81.85 205.51,81.02 205.51,79.96 205.03,79.47 PR101.1
N48705653: length 3.4
  TOP w0.102: PR7.1 75.21,121.93 v2(75.22,121.94)
  TOP w0.254: PQ3.3 75.24,120.9 PR7.1 PR5.2
N48705663: length 3.2
  TOP w0.102: v2(69.33,117.78) PQ4.2
  TOP w0.254: PR10.2 PR8.1 70.08,116.37 69.76,116.68 PQ4.2
N48705665: length 8.2
  TOP w0.254: PQ3.2 73.11,117.5 72.74,117.13 72.74,116.37 v2(72.34,115.97) 71.8,115.43 PR9.2 PR11.1 69.14,115.43 68.68,114.97 PQ4.1
N48708347: length 1.2
  BOTTOM w0.102: PC205.1 v2(78.08,69.96)
N48708367: length 2.8
  BOTTOM w0.102: PR210.2 v2(75.26,79.46)
  BOTTOM w0.203: PR210.2 76.17,79.35 75.67,78.84 PU201.7
N48708425: length 3.9
  BOTTOM w0.102: v2(78.94,79.92) 78.48,79.46 PR207.2
  BOTTOM w0.203: PR207.2 77.95,79 77.37,78.42 76.63,78.42 76.47,78.26 PU201.9
N48716673: length 4.8
  TOP w0.102: v2(81.26,71.81) 83.3,71.81 83.96,71.15 PR933.1
  TOP w0.203: PU901.28 84.13,71.14 PR933.1
N48716693: length 2.4
  TOP w0.254: PR930.1 86.53,73.94 v2(86.53,73.23) 87.19,72.57 PU901.26
N49522215: length 8.8
  TOP w0.254: PQ804.2 21.49,45.43 v2(22.01,45.94) 22.01,47.14 PR810.1 21.08,47.2 PR808.2 PR809.2 19.86,48.09 19.25,48.7 PQ805.2
N49522729: length 5.6
  BOTTOM w0.254: PR802.2 14.01,50.64 14.18,50.82 v2(15.55,50.82) 16.23,50.82 16.41,50.64 PQ803.1
N49522731: length 4.6
  BOTTOM w0.254: PQ801.1 16.41,51.39 16.24,51.23 14.18,51.23 14.01,51.41 PR802.3
N49522780: length 6
  BOTTOM w0.102: PR803.1 5.78,56.73 v2(5.36,57.15)
  BOTTOM w0.508: 7.97,52.64 7.97,54.64 6.45,56.17 PR803.1
N78957489: length 2.9
  TOP w0.102: PR912.2 15.03,39.15 v2(15,39.11)
  TOP w0.254: PR912.2 15.65,40.04 15.85,40.23 PQ908.1
N78967043: length 117.2
  TOP w0.102: PQ908.2 20.54,42.13 23.53,45.12 v2(24.8,45.12) 36.99,45.12 v1(39.41,42.71)
  TOP w0.254: PU903.4 v1(102.3,69.62)
  IN2 w0.102: v1(39.41,42.71) 39.41,39.78 40.41,38.77 55.19,38.77 56.47,40.06 63.33,40.06 67.32,44.05 80.06,44.05 v1(80.43,44.42)
  IN4 w0.102: v1(80.43,44.42) 80.85,44 80.85,43.25 81.5,42.59 92.93,42.59 93.26,42.92 93.26,58.46 92.68,59.04 92.68,60.93 101.37,69.62 v1(102.3,69.62)
N78985854: length 4.3
  TOP w0.102: v2(65.52,74.82) 65.38,74.68 65.38,73.75
  TOP w0.254: PR905.2 PR907.2 65.58,73.11 65.38,73.31 65.38,73.75
N79002827: length 4
  TOP w0.102: v2(63.21,70.3) 63.88,69.63 PQ902.2
  TOP w0.254: PU902.4 64.73,69.76 64.6,69.63 PQ902.2
N79023703: length 4.7
  TOP w0.102: v2(91.01,76.27) 90.71,75.98 90.71,74.74 91.16,74.29 PR927.1
  TOP w0.254: PR927.1 91.16,73.31 90.69,72.84 PU901.19
N79030038: length 4.4
  TOP w0.102: v2(6.32,59.47) PR917.2
  TOP w0.254: PR917.2 7.39,58.66 7.69,58.35 PQ911.3 8.58,58.35 8.74,58.2 8.74,57.82 8.62,57.7 PQ911.2
N79030087: length 3.1
  TOP w0.102: PR936.2 7.13,55.1 v2(7.53,54.71)
  TOP w0.254: PR936.2 7.13,56.63 6.71,57.05 PQ911.6
N79030091: length 7.8
  TOP w0.102: v2(13.99,52.8) 13.62,53.17 PQ910.2
  TOP w0.254: PR936.1 9.07,55.66 PR911.1 9.89,55.71 11.08,54.52 11.08,53.37 11.29,53.17 PQ910.2
N79030745: length 19.6
  TOP w0.254: PD904.2 12.67,43.21 12.52,43.36 7.57,43.36 6.07,44.87 v2(6.07,48.48) 6.07,49.91 7.34,51.18 7.34,52.48 8.99,54.14 PQ910.1
N79114801: length 4.3
  TOP w0.102: v2(71.66,38.96) 71.66,40.28 PD4.2
  TOP w0.254: PQ2.1 70.18,41.77 PD4.2

## Copper pours and planes (outline as drawn)
1.2V_B+ on TOP (solid shape): 72.11,68.11 72.11,63.03 72.49,62.65 74.9,62.65 75.16,62.39 75.16,61.88 74.9,61.63 69.57,61.63 69.54,61.67 69.22,61.67 69.18,61.63 67.92,61.63 67.79,61.76 67.79,61.76 67.72,61.83 67.72,62.37 68.24,62.37 68.24,62.88 67.72,62.88 67.72,63.17 68.24,63.17 68.24,63.68 67.72,63.68 67.72,65.98 67.89,66.16 67.89,67.7 68.83,67.7 68.83,67.3 69.02,67.11 70.63,67.11 70.75,67.24 70.75,67.39 70.76,67.42 70.76,67.46 70.76,67.51 70.76,67.56 70.75,67.59 70.75,67.7 70.56,67.89 69.02,67.89 68.83,67.7 67.89,67.7 67.89,67.82 68.3,68.23 71.98,68.23
1.5VSP on TOP (solid shape): 297.51,20.95 297.51,20.4 296.95,20.4 296.95,19.92 297.51,19.92 297.51,19.48 299.14,17.84 299.14,16.69 298.96,16.52 295.26,16.52 294.98,16.8 294.98,20.75 295.34,21.1 297.36,21.1
2.5VSP on TOP (solid shape): 252.3,40.14 252.3,38.67 252.17,38.54 248.62,38.54 248.43,38.73 248.43,39.43 248.98,39.43 248.98,39.86 248.43,39.86 248.43,40.28 248.68,40.52 251.91,40.52
2.5VSP on TOP (solid shape): 258.93,40.63 258.93,40.09 259.47,39.55 259.47,38.7 259.31,38.54 256.42,38.54 256.18,38.79 256.18,40.28 256.44,40.54 258.15,40.54 258.38,40.77 258.78,40.77
2.5VSP on IN3 (solid shape): 250.82,40.72 251.09,40.56 251.37,40.7 251.39,40.72 251.45,40.72 251.47,40.7 251.75,40.56 252.02,40.72 252.89,40.72 252.9,40.69 253.22,40.44 253.54,40.69 253.55,40.72 254.26,40.72 254.33,40.69 254.37,40.63 254.7,40.31 255.03,40.63 255.06,40.7 255.13,40.72 258.75,40.72 258.93,40.55 258.93,38.95 258.74,38.76 250.47,38.76 250.34,38.88 250.34,40.48 250.59,40.72
3V_SN on TOP (solid shape): 218.04,87.46 218.04,84.59 217.82,84.37 216.92,84.37 216.77,84.52 216.77,85.4 216.19,85.99 216.19,86.13 217.03,86.13 217.03,86.08 217.04,86.02 217.05,85.98 217.08,85.93 217.11,85.89 217.14,85.85 217.18,85.82 217.23,85.8 217.28,85.78 217.33,85.77 217.38,85.77 217.44,85.78 217.48,85.8 217.53,85.82 217.57,85.85 217.61,85.89 217.64,85.93 217.66,85.98 217.68,86.02 217.69,86.08 217.69,86.13 217.68,86.18 217.66,86.23 217.64,86.27 217.61,86.32 217.57,86.35 217.53,86.38 217.48,86.41 217.44,86.42 217.38,86.43 217.33,86.43 217.28,86.42 217.23,86.41 217.18,86.38 217.14,86.35 217.11,86.32 217.08,86.27 217.05,86.23 217.04,86.18 217.03,86.13 216.19,86.13 216.19,87.48 216.32,87.61 217.9,87.61
3V_VIN on TOP (solid shape): 219.03,82.46 219.03,81.26 218.85,81.07 217.7,81.07 217.61,81.16 217.61,82.59 217.68,82.66 218.83,82.66
3V_VIN on BOTTOM (solid shape): 221.15,86.45 221.15,82.1 221.8,81.45 221.8,80.08 221.62,79.89 221.27,79.89 221.27,80.44 220.7,80.44 220.7,79.89 220.46,79.89 220.46,80.46 219.9,80.46 219.9,79.89 219.41,79.89 218.97,79.46 218.97,78.65 218.8,78.48 217.98,78.48 217.88,78.57 217.88,78.58 217.8,78.65 217.8,80.28 217.62,80.47 217.62,82.61 218.52,83.52 218.52,85.03 218.46,85.09 218.46,86.6 218.54,86.69 220.91,86.69
5V_SN on TOP (solid shape): 212.72,88.71 212.72,86.89 211.72,85.89 209.67,85.89 209.59,85.97 209.59,86.75 209.66,86.83 210.9,86.83 211.4,87.33 211.4,88.69 211.55,88.83 212.6,88.83
5V_VIN on TOP (solid shape): 212,83.57 212,82.55 211.79,82.34 210.64,82.34 210.48,82.5 210.48,83.79 210.57,83.88 211.69,83.88
5V_VIN on BOTTOM (solid shape): 211.95,86.06 211.95,83.75 213.17,82.53 213.17,80.4 213.06,80.28 212.62,80.28 212.62,80.84 212.06,80.84 212.06,80.28 211.83,80.28 211.83,80.84 211.27,80.84 211.27,80.28 209.47,80.28 209.28,80.47 209.28,82.02 209.38,82.11 210.26,82.11 210.51,82.36 210.51,85.12 210.14,85.5 210.14,86.95 210.22,87.03 210.99,87.03
+0.6V_DDR_VTT on TOP (solid shape): 150.21,46.69 150.21,43.09 150.2,43 150.21,42.92 150.21,41.29 150.01,41.09 148.69,41.09 148.61,41.17 148.61,43.66 148.77,43.82 148.77,46.6 149.03,46.86 150.05,46.86
+0.6V_DDR_VTT on TOP (solid shape): 230.41,46.92 230.41,46.36 230.9,45.87 230.9,45.33 231.14,45.09 231.14,44.23 230.85,43.94 230.85,42.59 230.69,42.43 228.49,42.43 228.41,42.51 228.41,43.33 228.78,43.71 229.06,43.71 229.21,43.85 229.21,46.9 229.36,47.06 230.27,47.06
+0.6V_DDR_VTT on BOTTOM (solid shape): 150.13,43.22 150.13,43.02 149.78,42.67 149.78,40.84 149.72,40.78 149.53,40.78 149.47,40.83 149.47,42.59 149.32,42.74 149.06,42.74 149.06,43.33 150.01,43.33
+0.6V_DDR_VTT on BOTTOM (solid shape): 72.01,75.38 72.01,74.94 72.56,74.94 72.56,74.75 72.01,74.75 72.01,74.04 71.79,73.82 71.03,73.82 70.84,74.01 70.84,75.35 71.03,75.54 71.85,75.54
+0.6V_DDR_VTT on BOTTOM (solid shape): 230.74,43.17 230.74,42.8 230.38,42.44 230.38,40.82 230.33,40.77 230.11,40.77 230.06,40.81 230.06,42.49 229.92,42.64 229.73,42.64 229.66,42.71 229.66,43.23 229.75,43.32 230.59,43.32
+0.6V_DDR_VTT on IN1 (solid shape): 72.17,75.35 72.17,73.16 71.32,72.31 71.32,70.99 68.76,68.42 68.76,61.3 73.12,56.93 78.39,56.93 80.05,55.28 80.05,51.53 79.92,51.41 78.52,51.41 78.39,51.53 78.39,54.52 77.51,55.41 71.86,55.41 70.89,56.37 70.9,56.4 70.82,56.72 70.49,56.8 70.47,56.8 67.23,60.03 67.23,60.99 67.24,61.03 67.28,61.05 67.59,61.38 67.28,61.7 67.24,61.72 67.23,61.76 67.23,69.05 67.68,69.51 67.71,69.5 68.02,69.59 68.11,69.9 68.1,69.93 69.63,71.45 69.63,72.78 70.65,73.8 70.65,75.35 70.97,75.66 71.85,75.66
+0.6V_DDR_VTT on IN2 (solid shape): 230.88,42.98 230.88,41.67 230.43,41.22 229.38,41.22 229.22,41.39 229.22,42.94 229.51,43.23 230.63,43.23
+0.6V_DDR_VTT on IN2 (solid shape): 150.28,44.4 152.27,44.4 152.38,44.28 152.38,42.96 152.24,42.82 151.57,42.82 151.49,42.85 151.47,42.93 151.29,43.28 150.91,43.22 150.84,43.2 150.77,43.23 150.38,43.29 150.21,42.94 150.18,42.85 150.11,42.82 148.7,42.82 148.61,42.91 148.61,44.1 149.11,44.6 150.08,44.6
+0.6V_DDR_VTT on IN3 (solid shape): 150.12,43.19 150.12,41.6 149.6,41.08 146.94,41.08 146.7,41.32 146.7,42.68 147.01,43 147.8,43 148.12,43.32 149.99,43.32
+0.6V_DDR_VTT on IN3 (solid shape): 81.51,52.1 81.51,49.18 81.44,49.12 80.11,49.12 79.86,49.37 79.86,50.83 79.54,51.15 78.78,51.15 78.33,51.6 78.33,52.49 78.59,52.74 80.87,52.74
+0.6V_P on BOTTOM (solid shape): 73.28,75.92 73.53,75.81 73.78,75.92 74.91,75.92 74.97,75.87 74.97,75.76 74.9,75.7 74.11,75.7 73.81,75.4 73.58,74.78 74.18,75.05 74.18,75.07 74.21,75.1 75.32,75.1 75.37,75.05 75.37,74.26 73.53,72.42 72.81,72.42 72.74,72.49 72.74,73.63 72.17,74.2 72.17,74.58 72.74,74.58 72.74,75.09 72.17,75.09 72.17,75.66 72.43,75.92
+0.9V_LAN on TOP (solid shape): 258.11,91.38 258.11,90.36 257.73,89.98 257.26,89.98 256.55,89.28 256.55,88.75 256.38,88.57 255.74,88.57 255.58,88.73 255.58,90.17 256.23,90.82 257.28,90.82 257.9,91.44 258.05,91.44
+0.9V_LAN on TOP (solid shape): 269.76,94.97 269.76,94.31 269.64,94.2 267.38,94.2 267.19,94.38 262.71,94.38 262.65,94.45 262.65,94.52 262.72,94.6 264.51,94.6 265.03,95.12 269.61,95.12
+0.9V_LAN on TOP (solid shape): 262.1,91.37 262.1,90.36 262.66,89.8 263.19,89.8 263.88,89.1 263.88,88.5 263.73,88.35 262.2,88.35 262.09,88.46 262.09,89.16 262.1,89.56 261.7,89.67 261.63,89.67 261.58,89.71 261.55,89.75 261.53,89.78 261.49,89.81 261.49,90.13 261.55,90.18 261.55,90.91 261.53,91.01 261.49,91.1 261.49,91.39 261.55,91.45 262.02,91.45
+0.9V_LAN on BOTTOM (solid shape): outline of 139 points within 252.52,89.09 265.66,99.58
+1.0V_APLL on IN1 (solid shape): outline of 588 points within 165.96,92.92 178.09,96.29
+1.0V_APLLEBB on IN3 (solid shape): outline of 282 points within 163.4,95.47 166.09,102.1
+1.0V_CLK2 on TOP (solid shape): 164.41,101.14 164.41,101.01 164.23,100.76 164.33,100.47 164.36,100.4 164.33,100.32 164.22,100.07 164.35,99.82 164.38,99.76 164.37,99.68 164.31,99.46 164.41,99.26 164.41,99.09 164.23,98.79 164.41,98.5 164.41,98.35 163.96,97.91 163.96,97.35 163.97,97.3 163.98,97.25 163.99,97.22 163.9,97.14 163.46,97.14 163.33,97.26 163.33,97.99 163.89,98.56 163.99,98.81 163.89,99.06 163.86,99.13 163.89,99.2 163.97,99.44 163.85,99.67 163.81,99.75 163.85,99.82 163.97,100.07 163.86,100.32 163.83,100.4 163.86,100.47 163.97,100.75 163.8,101 163.77,101.02 163.77,101.26 163.84,101.33 164.22,101.33
+1.0V_CLK3 on IN3 (solid shape): 164.6,104.09 164.6,102.84 163.81,102.04 163.78,102.04 163.64,102 163.52,101.9 163.46,101.74 163.49,101.56 163.5,101.55 163.5,101.04 163.47,101.03 163.28,100.75 163.43,100.45 163.45,100.42 163.45,100.38 163.28,100.1 163.43,99.81 163.45,99.75 163.42,99.69 163.33,99.57 163.31,99.43 163.34,99.27 163.45,99.15 163.44,99.1 163.42,99.05 163.33,98.93 163.31,98.78 163.33,98.68 163.39,98.59 163.41,98.53 163.38,98.46 162.87,97.95 162.87,97.6 162.63,97.37 162.63,97.01 162.53,96.91 162.21,96.91 162.1,97.02 162.1,97.54 162.62,98.07 162.62,98.5 162.66,98.52 162.7,98.52 163.02,98.71 162.97,99.08 162.94,99.15 162.97,99.22 163.02,99.59 162.7,99.77 162.66,99.78 162.62,99.8 162.62,102.09 164.15,103.61 164.15,104.08 164.24,104.17 164.52,104.17
+1.0V_CLK4 on IN2 (solid shape): outline of 401 points within 161.98,95.36 165.43,109.89
+1.0V_CLK5 on IN3 (solid shape): 165.24,102.85 165.24,102.34 164.98,102.08 164.95,102.08 164.3,101.43 164.3,100.92 164.22,100.71 164.3,100.5 164.3,100.29 164.22,100.08 164.3,99.87 164.3,99.65 164.22,99.44 164.3,99.23 164.3,99.02 164.22,98.85 164.26,98.66 164.27,98.63 164.3,98.59 164.3,98.21 163.76,97.68 163.73,97.68 163.48,97.63 163.34,97.41 163.35,97.27 163.42,97.14 163.42,96.72 163.38,96.65 163.36,96.58 163.35,96.33 163.29,96.27 162.85,96.27 162.76,96.37 162.76,97.34 163.01,97.6 163.01,97.8 163.69,98.48 163.7,98.48 163.96,98.72 163.86,99.05 163.83,99.1 163.83,99.15 163.94,99.27 163.97,99.43 163.94,99.57 163.86,99.69 163.83,99.76 163.86,99.83 163.97,100.08 163.86,100.32 163.83,100.4 163.86,100.47 163.96,100.77 163.77,101.02 163.7,101.05 163.7,101.27 163.71,101.33 163.73,101.36 163.77,101.38 164.08,101.56 164.04,101.92 164.03,101.96 164.04,101.99 164.97,102.92 165.16,102.92
+1.0V_MPHYAON on TOP (solid shape): outline of 904 points within 165.26,97.19 169.71,115.42
+1.0V_MPHYAON on BOTTOM (solid shape): 167.61,115.86 167.61,114.4 167.31,114.1 166.2,114.1 165.68,114.61 165.68,116.07 165.91,116.3 167.17,116.3
+1.0V_MPHYGT on TOP (solid shape): 166.52,96.77 166.52,96.07 166.47,95.99 166.37,95.99 165.98,95.93 165.92,95.54 165.92,95.44 165.83,95.39 165.51,95.39 165.38,95.27 165.38,94.76 165.25,94.63 164.74,94.63 164.68,94.69 164.68,95.85 164.93,96.1 165.14,96.1 165.35,96.32 165.35,96.71 165.52,96.88 166.41,96.88
+1.0V_MPHYGT on TOP (solid shape): outline of 119 points within 169.52,112.28 177.45,119.5

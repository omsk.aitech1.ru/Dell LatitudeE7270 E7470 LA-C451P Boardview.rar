# Allegro board LAC451PR10-0923B.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR_B_DQS#6: length 91.6
  IN4 w0.076: v1(159.07,84.64) 158.82,84.64 158.69,84.51 158.69,83 158.47,82.78 158.34,82.65 158.34,81.89 159.5,80.73 159.5,79.71 160.77,78.44 160.77,78.08 164.01,74.84 164.28,74.84 166.63,72.49 167.59,72.49 168.34,71.75 168.35,71.75
  IN4 w0.091: v1(220.96,46.82) 220.96,46.53 220.85,46.43 220.41,46.43 220.32,46.51 220.32,47.89 220.45,48.01 220.82,48.01 221.05,48.24 221.05,48.65 220.82,48.87 220.46,48.87 220.33,49 220.33,49.26 220.46,49.39 220.72,49.39 220.95,49.61 220.95,49.96 220.72,50.19 220.45,50.19 220.32,50.31 220.32,51.98 215.94,56.35 215.35,56.35 207.14,64.56 205.95,64.56 201.22,69.3 200.07,69.3 198.75,70.62 195.32,70.62 194.65,71.29 182.19,71.29 182.03,71.45 170.7,71.45 170.4,71.75 168.35,71.75
  BOTTOM w0.076: UC1.AR25 v1(159.07,84.64)
  BOTTOM w0.102: v1(220.96,46.82) 221.25,46.53 221.34,46.53 221.43,46.61 221.43,47.85 220.48,48.8 JDIMM2.219
DDR_B_DQS#7: length 93.9
  IN4 w0.076: v1(161.81,84.64) 161.57,84.88 161.5,84.88 161.43,84.8 161.43,83.12 161.76,82.79 161.76,81.62 162.96,80.42 162.96,79.29 163.38,78.87 165,78.87 167,76.87 167.49,76.87 167.5,76.88 167.68,76.88
  IN4 w0.091: v1(226.38,45.3) 226.38,45.01 226.25,44.89 226.02,44.89 225.74,45.17 225.74,49.21 225.08,49.87 225.08,52.21 209.28,68.01 207.38,68.01 202.65,72.75 201.5,72.75 199.67,74.58 196.34,74.58 195.33,75.58 194.17,75.58 193.92,75.82 193.3,75.82 193.06,75.58 191.48,75.58 191.27,75.79 189.09,75.79 188.78,75.48 183.18,75.48 182.92,75.22 179.94,75.22 179.88,75.28 178.81,75.28 178.32,75.78 173.27,75.78 171.86,77.19 168.21,77.19 167.9,76.88 167.68,76.88
  BOTTOM w0.076: UC1.AR22 161.45,85 v1(161.81,84.64)
  BOTTOM w0.102: v1(226.38,45.3) 226.08,45 225.95,45 225.74,44.79 225.74,42.52 225.72,42.51 JDIMM2.240
DDR_B_MA0: length 96.1
  IN4 w0.076: 148,68.94 148,70.02 147.63,70.39 147.63,76.41 148.24,77.02 v1(148.24,77.35)
  IN4 w0.132: 148,68.94 148,67.18 156.83,58.35 158.8,58.35 158.97,58.18 160.17,58.18 161.09,57.26 163.22,57.26 163.72,56.75 177.61,56.75 177.74,56.62 177.74,55.53 177.87,55.4 195.09,55.4 199.17,51.33 199.17,50.78 201.08,48.87 201.08,46.16 200.95,46.03 200.01,46.03 199.88,45.91 199.88,45.56 200.01,45.44 200.95,45.44 201.08,45.31 201.08,43.16 200.95,43.04 200.38,43.04 200.25,42.91 200.25,42.72 200.38,42.59 200.95,42.59 201.08,42.46 201.08,42.25 200.95,42.12 200.4,42.12 200.28,41.99 200.28,41.72 200.4,41.59 200.95,41.59 201.08,41.46 201.08,41.25 200.95,41.12 199.99,41.12 199.86,41.25 199.86,44.08 199.99,44.21 v1(200.26,44.21)
  BOTTOM w0.076: v1(148.24,77.35) 148.46,77.57 148.46,79.47 148.56,79.57 148.56,80.79 148.29,81.06 UC1.BA46
  BOTTOM w0.17: JDIMM2.144 199.73,42.52 199.81,42.6 199.81,43.76 v1(200.26,44.21)
DDR_B_MA1: length 96.5
  IN4 w0.076: v1(145.93,73.75) 145.26,73.08 145.26,69.74 145.03,69.52 145.03,68.94
  IN4 w0.132: v1(197.45,47.24) 197.19,47.24 197.06,47.37 197.06,48.76 193.32,52.5 171.07,52.5 169.79,53.78 169.49,53.78 169.36,53.66 169.36,52.64 169.24,52.51 169.01,52.51 168.88,52.64 168.88,53.66 168.76,53.78 168.54,53.78 168.41,53.66 168.41,52.63 168.29,52.5 167.98,52.5 167.85,52.63 167.85,53.66 167.73,53.78 167.49,53.78 167.36,53.66 167.36,52.63 167.23,52.5 167.02,52.5 166.89,52.63 166.89,53.66 166.76,53.78 166.49,53.78 166.37,53.66 166.37,52.63 166.24,52.5 166.01,52.5 165.88,52.63 165.88,53.66 165.76,53.78 165.55,53.78 165.43,53.66 165.43,52.63 165.3,52.5 165.06,52.5 164.93,52.63 164.93,53.66 164.81,53.78 164.59,53.78 164.46,53.66 164.46,52.63 164.34,52.5 164.11,52.5 163.98,52.63 163.98,53.66 163.85,53.78 163.65,53.78 163.53,53.66 163.53,52.63 163.4,52.5 158.48,52.5 145.03,65.95 145.03,68.94
  BOTTOM w0.076: UC1.AY46 148.19,81.63 148.09,81.53 148.02,81.31 148.02,81.18 148.08,80.95 148.08,80.81 148.03,80.69 148.03,80.43 148.23,80.23 148.23,79.74 148.13,79.64 148.13,78.91 147.93,78.71 v2(147.93,78.44) 147.93,78.05 147.59,77.71 147.59,75.41 v1(145.93,73.75)
  BOTTOM w0.17: v1(197.45,47.24) 197.45,47.27 196.97,47.75 JDIMM2.133
DDR_B_MA2: length 96.3
  IN4 w0.076: v1(145.93,74.31) 145.04,73.42 145.04,70.66 144.59,70.2 144.59,68.94
  IN4 w0.132: v1(197.45,44.19) 197.18,44.19 197.05,44.06 197.05,41.96 197.18,41.84 199.17,41.84 199.3,41.71 199.3,41.45 199.17,41.32 196.77,41.32 196.65,41.45 196.65,48.58 193.14,52.09 170.42,52.09 170.29,52.21 170.29,52.66 170.16,52.79 169.92,52.79 169.8,52.66 169.8,52.21 169.67,52.09 158.31,52.09 144.59,65.81 144.59,68.94
  BOTTOM w0.076: v1(145.93,74.31) 147.34,75.72 147.34,77.77 147.58,78.01 147.58,78.73 147.97,79.12 147.97,79.72 148.07,79.81 148.07,80.16 147.86,80.36 147.86,80.73 147.88,80.76 147.91,80.84 147.91,80.95 147.84,81.17 147.84,81.32 147.9,81.47 147.9,81.9 UC1.AY47
  BOTTOM w0.17: JDIMM2.132 196.73,43.46 v1(197.45,44.19)
DDR_B_MA3: length 95.1
  IN4 w0.076: v1(145.74,72.45) 145.74,69.55 145.46,69.27 145.46,68.94
  IN4 w0.132: v1(197.45,45.71) 197.86,46.12 197.86,48.53 195.41,50.99 195.41,51.17 195.47,51.24 195.47,51.42 195.28,51.62 195.09,51.62 195.03,51.56 194.84,51.56 194.65,51.75 194.65,51.94 194.71,52 194.71,52.18 194.52,52.38 194.33,52.38 194.27,52.32 194.08,52.32 193.49,52.91 171.24,52.91 169.96,54.19 163.24,54.19 163.12,54.07 163.12,53.04 162.99,52.92 162.71,52.92 162.58,53.04 162.58,54.07 162.46,54.19 162.23,54.19 162.1,54.07 162.1,53.04 161.97,52.92 161.74,52.92 161.62,53.04 161.62,54.07 161.49,54.19 161.24,54.19 161.11,54.07 161.11,53.04 160.98,52.91 160.73,52.91 160.6,53.04 160.6,54.07 160.47,54.19 160.2,54.19 160.07,54.07 160.07,53.04 159.94,52.91 159.66,52.91 159.53,53.04 159.53,54.07 159.41,54.19 159.17,54.19 159.04,54.07 159.04,53.06 158.91,52.93 158.63,52.93 158.5,53.06 158.5,54.07 158.38,54.19 157.39,54.19 145.46,66.12 145.46,68.94
  BOTTOM w0.076: v1(145.74,72.45) 145.93,72.45 147.81,74.33 147.81,77.62 148.3,78.1 148.3,79.56 148.4,79.66 148.4,80.48 UC1.BB46
  BOTTOM w0.17: JDIMM2.131 196.48,46.73 197.45,45.75 v1(197.45,45.71)
DDR_B_MA4: length 95.4
  IN4 w0.076: v1(145.74,75.11) 144.83,74.2 144.83,70.68 144.18,70.02 144.18,68.94
  IN4 w0.132: 144.18,68.94 144.18,65.64 158.14,51.68 192.07,51.68 192.85,50.89 193.76,50.89 196.24,48.41 196.24,41.44 196.11,41.31 194.16,41.31 194.03,41.44 194.03,41.66 194.16,41.79 195.64,41.79 195.77,41.92 195.77,42.21 195.64,42.34 195.55,42.34 195.43,42.46 195.43,44.08 195.55,44.21 v1(195.84,44.21)
  BOTTOM w0.076: v1(145.74,75.11) 146.29,75.11 146.74,75.56 146.74,75.72 146.66,75.81 146.45,75.81 146.34,75.92 146.34,76.09 146.46,76.21 146.99,76.21 147.1,76.32 147.1,76.58 147.04,76.64 146.68,76.64 146.53,76.79 146.53,77.22 147.28,77.97 147.28,80.19 147.4,80.31 147.4,80.72 147.4,80.72 147.36,80.81 147.36,81.01 147.4,81.09 147.4,81.1 147.4,81.1 147.41,81.11 147.41,81.34 UC1.BA47
  BOTTOM w0.17: JDIMM2.128 195.73,42.93 195.4,43.26 195.4,43.74 195.86,44.21 v1(195.84,44.21)
DDR_B_MA5: length 97
  IN4 w0.076: 142.94,68.94 142.94,69.78 144.3,71.14 144.3,76.02 v1(145.93,77.65)
  IN4 w0.132: 142.94,68.94 142.94,65.13 157.63,50.44 159.67,50.44 159.88,50.24 159.88,49.36 160.25,48.99 162.31,48.99 163.38,50.06 185.88,50.06 186,49.93 186,47.39 186.13,47.27 187.18,47.27 187.3,47.39 187.3,49.93 187.43,50.06 191.94,50.06 192.34,49.66 193.24,49.66 194.61,48.29 194.61,44.48 195.01,44.08 195.01,42.33 194.89,42.2 194.08,42.2 193.95,42.33 193.95,42.58 194.08,42.71 194.49,42.71 194.61,42.83 194.61,43.81 v1(194.21,44.21)
  BOTTOM w0.076: UC1.AY48 146.7,81.62 146.7,81.4 146.49,81.19 146.49,80.12 146.78,79.83 146.78,78.5 v1(145.93,77.65)
  BOTTOM w0.17: v1(194.21,44.21) 194.47,44.21 194.94,43.74 194.94,42.96 195.22,42.67 JDIMM2.126
DDR_B_MA6: length 94.4
  IN4 w0.076: 143.76,68.94 143.76,69.94 144.65,70.83 144.65,75.07 v1(145.93,76.35)
  IN4 w0.132: 143.76,68.94 143.76,65.47 157.97,51.26 160.58,51.26 160.7,51.14 160.7,49.94 160.83,49.81 161.01,49.81 161.14,49.94 161.14,51.14 161.26,51.26 161.47,51.26 161.59,51.14 161.59,49.95 161.72,49.82 161.97,49.82 162.1,49.95 162.1,51.14 162.23,51.26 162.41,51.26 162.53,51.14 162.53,50.88 162.66,50.76 162.91,50.76 163.04,50.88 163.04,51.14 163.16,51.26 163.4,51.26 163.52,51.14 163.52,51.01 163.65,50.88 163.94,50.88 164.07,51.01 164.07,51.14 164.2,51.26 164.4,51.26 164.53,51.14 164.53,51.01 164.65,50.88 164.87,50.88 165,51.01 165,51.14 165.12,51.26 165.34,51.26 165.47,51.14 165.47,51.01 165.59,50.88 166.33,50.88 166.46,51.02 166.46,51.14 166.59,51.26 166.87,51.26 167,51.14 167,51.01 167.13,50.88 167.41,50.88 167.54,51.01 167.54,51.14 167.66,51.26 167.95,51.26 168.08,51.14 168.08,51.02 168.21,50.88 168.98,50.88 169.11,51.02 169.11,51.14 169.24,51.26 169.53,51.26 169.65,51.14 169.65,51.02 169.79,50.88 170.82,50.88 170.95,51.02 170.95,51.12 171.08,51.25 171.36,51.25 171.49,51.12 171.49,51.02 171.62,50.88 172.26,50.88 172.4,51.02 172.4,51.12 172.53,51.25 172.8,51.25 172.93,51.12 172.93,51.02 173.07,50.88 173.91,50.88 174.05,51.02 174.05,51.1 174.18,51.23 174.45,51.23 174.58,51.1 174.58,51.02 174.72,50.88 174.99,50.88 175.12,51.02 175.12,51.1 175.25,51.23 175.53,51.23 175.66,51.1 175.66,51.02 175.79,50.88 176.78,50.88 176.92,51.02 176.92,51.11 177.05,51.24 177.32,51.24 177.46,51.11 177.46,51.02 177.59,50.88 177.86,50.88 177.99,51.02 177.99,51.11 178.13,51.24 178.4,51.24 178.53,51.11 178.53,51.02 178.66,50.88 179.32,50.88 179.45,51.02 179.45,51.11 179.58,51.24 179.86,51.24 179.99,51.11 179.99,51.02 180.12,50.88 180.39,50.88 180.53,51.02 180.53,51.11 180.66,51.24 180.93,51.24 181.06,51.11 181.06,51.02 181.2,50.88 182.88,50.88 183.02,51.02 183.02,51.11 183.15,51.24 183.42,51.24 183.55,51.11 183.55,51.02 183.69,50.88 184.5,50.88 184.64,51.02 184.64,51.12 184.77,51.25 185.04,51.25 185.17,51.12 185.17,51.02 185.31,50.88 186.26,50.88 186.39,51.02 186.39,51.12 186.52,51.25 186.8,51.25 186.93,51.12 186.93,51.02 187.06,50.88 187.33,50.88 187.47,51.02 187.47,51.12 187.6,51.25 187.87,51.25 188,51.12 188,51.02 188.14,50.88 188.41,50.88 188.54,51.02 188.54,51.12 188.68,51.25 188.95,51.25 189.08,51.12 189.08,51.02 189.21,50.88 189.85,50.88 189.98,51.02 189.98,51.11 190.11,51.24 190.38,51.24 190.52,51.11 190.52,51.02 190.65,50.88 192.28,50.88 192.68,50.48 193.59,50.48 195.44,48.62 195.44,47.65 v1(195.84,47.26)
  BOTTOM w0.076: UC1.BA48 146.97,81.01 147.2,80.78 147.23,80.69 147.23,80.38 147.11,80.26 147.11,78.04 146.33,77.25 146.33,76.75 v1(145.93,76.35)
  BOTTOM w0.17: JDIMM2.127 195.48,48.67 195.35,48.55 195.35,47.77 195.86,47.26 v1(195.84,47.26)
DDR_B_MA7: length 97.7
  IN4 w0.076: v1(146.26,85.27) 145.88,84.89 145.88,82.92 145.53,82.56 145.53,81.99 144.49,80.95 144.49,78.9 143.35,77.77 143.35,70.66 142.12,69.43 142.12,68.94
  IN4 w0.132: 142.12,68.94 142.12,64.78 157.28,49.62 157.96,49.62 158.09,49.49 158.09,48.82 158.21,48.69 158.44,48.69 158.57,48.82 158.57,49.49 158.7,49.62 158.93,49.62 159.06,49.49 159.06,48.29 159.18,48.17 162.65,48.17 163.72,49.24 185.05,49.24 185.18,49.11 185.18,46.57 185.31,46.44 188,46.44 188.13,46.57 188.13,49.11 188.25,49.24 191.59,49.24 192,48.83 192.9,48.83 193.39,48.35 193.39,46.9 193.51,46.77 193.69,46.77 193.82,46.64 193.82,46.38 193.69,46.25 193.51,46.25 193.39,46.12 193.39,45.86 193.51,45.73 v1(194.21,45.73)
  BOTTOM w0.076: UC1.AP48 v1(146.26,85.27)
  BOTTOM w0.17: JDIMM2.122 194.22,42.72 193.74,43.21 193.74,45.25 v1(194.21,45.73)
DDR_B_MA8: length 92.8
  IN4 w0.076: 143.35,68.94 143.35,69.86 144.47,70.98 144.47,75.54 v1(145.93,77)
  IN4 w0.132: v1(195.84,45.73) 195.71,45.86 195.55,45.86 195.43,45.73 195.43,44.66 195.31,44.54 195.14,44.54 195.02,44.66 195.02,48.46 193.42,50.07 192.51,50.07 192.11,50.47 187.02,50.47 186.89,50.34 186.89,47.81 186.76,47.68 186.54,47.68 186.41,47.81 186.41,50.34 186.29,50.47 163.2,50.47 162.14,49.4 160.42,49.4 160.29,49.53 160.29,50.73 160.16,50.85 157.8,50.85 143.35,65.3 143.35,68.94
  BOTTOM w0.076: UC1.BB48 146.95,80.56 146.95,78.11 146.16,77.33 146.16,77.23 v1(145.93,77)
  BOTTOM w0.17: v1(195.84,45.73) 195.86,45.73 194.85,46.74 194.85,48.94 194.97,49.06 JDIMM2.125
DDR_B_MA9: length 92.5
  IN4 w0.076: v1(146.3,85.92) 146.72,85.5 146.72,83.27 145.89,82.43 145.89,81.79 144.79,80.69 144.79,78.77 143.52,77.5 143.52,70.59 142.53,69.6 142.53,68.94
  IN4 w0.132: v1(194.21,47.26) 193.8,47.67 193.8,48.52 193.07,49.24 192.17,49.24 191.77,49.65 187.84,49.65 187.71,49.52 187.71,46.98 187.59,46.86 185.72,46.86 185.59,46.98 185.59,49.52 185.46,49.65 163.55,49.65 162.48,48.58 160.08,48.58 159.47,49.19 159.47,49.87 159.31,50.03 157.46,50.03 142.53,64.95 142.53,68.94
  BOTTOM w0.076: v1(146.3,85.92) 146.03,85.65 UC1.AP50
  BOTTOM w0.17: JDIMM2.121 193.97,48.77 193.69,48.48 193.69,47.78 v1(194.21,47.26)
DDR_B_MA10: length 95.4
  IN4 w0.076: 148.45,68.94 148.45,70.17 147.88,70.73 147.88,74.4 v1(148.6,75.12)
  IN4 w0.132: 148.45,68.94 148.45,67.33 157.02,58.76 158.97,58.76 159.14,58.59 160.34,58.59 161.26,57.67 163.39,57.67 163.89,57.16 178.02,57.16 178.15,57.03 178.15,55.94 178.28,55.82 195.27,55.82 199.64,51.44 199.64,50.9 201.49,49.04 201.49,41.28 201.62,41.16 203.26,41.16 203.36,41.26 203.36,41.59 203.26,41.69 202,41.69 201.88,41.82 201.88,42.21 202,42.34 202.18,42.34 202.3,42.46 202.3,43.7 202.18,43.82 202.03,43.82 201.91,43.95 v1(201.91,44.21)
  BOTTOM w0.076: v1(148.6,75.12) 148.2,75.53 148.2,76.59 148.63,77.02 148.63,79.4 148.73,79.5 148.73,81.22 148.49,81.46 148.49,81.95 148.38,82.16 148.19,82.35 UC1.AW46
  BOTTOM w0.17: v1(201.91,44.21) 202.5,43.61 202.5,43.15 202.23,42.87 JDIMM2.146
DDR_B_MA11: length 98.3
  IN4 w0.076: 141.71,68.94 141.71,69.72 143.09,71.1 143.09,78.16 144.21,79.28 144.21,81.1 145.31,82.2 145.31,82.73 145.72,83.14 145.72,86.03 v1(146.25,86.56)
  IN4 w0.132: 141.71,68.94 141.71,64.61 158.56,47.76 162.82,47.76 163.89,48.83 184.64,48.83 184.77,48.7 184.77,46.16 184.89,46.03 188.41,46.03 188.54,46.16 188.54,48.7 188.66,48.83 191.42,48.83 191.83,48.42 192.73,48.42 192.97,48.18 192.97,45.24 193.1,45.11 193.63,45.11 193.76,44.98 193.76,43.85 193.63,43.72 193.24,43.72 193.11,43.85 193.11,44.08 192.99,44.21 v1(192.56,44.21)
  BOTTOM w0.076: UC1.AN48 146.51,86.3 v1(146.25,86.56)
  BOTTOM w0.17: JDIMM2.120 193.73,42.52 193.19,43.05 193.19,43.71 192.69,44.21 v1(192.56,44.21)
DDR_B_MA12: length 97.2
  IN4 w0.076: 142.23,76.83 142.23,77.84 143.89,79.5 143.89,81.19 144.98,82.28 144.98,85.58 v1(145.34,85.94)
  IN4 w0.132: v1(192.56,47.26) 192.41,47.26 191.25,48.41 189.08,48.41 188.95,48.29 188.95,45.75 188.82,45.62 186.12,45.62 185.99,45.49 185.99,44.79 185.86,44.66 185.58,44.66 185.46,44.79 185.46,45.49 185.33,45.62 185.04,45.62 184.91,45.49 184.91,43.77 184.78,43.65 184.48,43.65 184.36,43.77 184.36,48.29 184.23,48.41 164.43,48.41 164.22,48.21 164.22,47.89 163.68,47.34 158.39,47.34 141.3,64.44 141.3,70.51 142.23,71.44 142.23,76.83
  BOTTOM w0.076: v1(145.34,85.94) 145.7,86.3 UC1.AN50
  BOTTOM w0.17: JDIMM2.119 193.48,48.9 193.24,48.67 193.24,47.56 192.94,47.26 v1(192.56,47.26)
DDR_B_MA13: length 94
  IN4 w0.076: 150.52,68.94 150.52,69.59 149.64,70.47 149.64,72.22 149.39,72.47 149.39,74.21 149.79,74.61 v1(150.18,74.61)
  IN4 w0.132: 150.52,68.94 150.52,68.17 157.12,61.57 157.58,61.57 157.71,61.45 157.71,61.01 157.83,60.88 157.97,60.88 158.1,61.01 158.1,61.45 158.23,61.57 158.42,61.57 158.54,61.45 158.54,60.95 158.67,60.82 158.84,60.82 158.96,60.95 158.96,61.45 159.09,61.57 159.27,61.57 159.4,61.45 159.4,60.95 159.52,60.82 159.83,60.82 159.99,60.65 161.19,60.65 162.12,59.73 169.12,59.73 169.25,59.6 169.25,59.35 169.38,59.22 169.59,59.22 169.72,59.35 169.72,59.6 169.85,59.73 170.12,59.73 170.24,59.6 170.24,59.35 170.37,59.22 190.36,59.22 190.84,58.74 194.55,58.74 195.42,57.87 196.19,57.87 201.69,52.37 201.69,51.75 204.42,49.03 204.42,45.67 204.54,45.54 204.95,45.54 205.08,45.41 205.08,45.29 204.95,45.17 204.07,45.17 203.95,45.04 203.95,44.89 204.07,44.76 204.2,44.76 204.33,44.64 204.33,44.33 204.45,44.2 204.58,44.2 204.71,44.33 204.71,44.58 204.83,44.7 204.99,44.7 205.11,44.58 205.11,44.35 205.24,44.22 v1(205.32,44.22)
  BOTTOM w0.076: v1(150.18,74.61) 149.77,75.02 149.77,77.36 149.62,77.52 149.62,78.9 150.09,79.37 150.09,79.44 150.36,79.7 150.36,80.2 150.22,80.33 150.22,80.46 150.22,80.47 150.22,80.72 150.27,80.85 150.27,80.96 150.23,81.06 150.22,81.09 150.22,81.33 UC1.BA43
  BOTTOM w0.17: JDIMM2.158 205.23,42.73 205.35,42.86 206.11,42.86 206.23,42.99 206.23,44.57 206.11,44.7 205.84,44.7 205.71,44.57 205.71,44.35 205.59,44.22 v1(205.32,44.22)
DDR_B_MA14: length 96.9
  IN4 w0.076: 149.7,68.94 149.7,69.91 149.24,70.38 149.24,71.72 v1(148.61,72.34)
  IN4 w0.132: v1(203.55,47.26) 203.55,47 203.42,46.87 203.25,46.87 203.13,47 203.13,49.16 200.87,51.41 200.87,52.03 195.85,57.05 190.61,57.05 190.48,57.18 190.48,57.88 190.36,58.01 190.15,58.01 190.03,57.89 190.03,57.18 189.9,57.05 189.7,57.05 189.57,57.18 189.57,58.27 189.44,58.4 189.24,58.4 189.11,58.27 189.11,57.18 188.99,57.05 188.8,57.05 188.67,57.18 188.67,58.27 188.54,58.4 188.38,58.4 188.25,58.27 188.25,57.18 188.12,57.05 187.94,57.05 187.82,57.18 187.82,58.27 187.69,58.4 187.51,58.4 187.39,58.27 187.39,57.18 187.26,57.05 187.07,57.05 186.94,57.18 186.94,58.27 186.81,58.4 186.61,58.4 186.48,58.27 186.48,57.18 186.36,57.05 186.14,57.05 186.01,57.18 186.01,58.27 185.89,58.4 185.68,58.4 185.56,58.27 185.56,57.18 185.43,57.05 185.25,57.05 185.12,57.18 185.12,58.27 185,58.4 164.41,58.4 163.9,58.9 161.77,58.9 160.85,59.83 159.65,59.83 159.48,60 157.54,60 149.7,67.83 149.7,68.94
  BOTTOM w0.076: UC1.AY44 149.42,81.64 149.52,81.54 149.52,81.53 149.6,81.31 149.6,81.18 149.53,80.95 149.53,80.81 149.59,80.69 149.59,80.42 149.39,80.22 149.39,79.17 149.29,79.07 149.29,77.27 149.39,77.16 149.39,72.93 148.81,72.34 v1(148.61,72.34)
  BOTTOM w0.17: JDIMM2.151 203.48,48.78 203.97,48.28 203.97,47.67 203.56,47.26 v1(203.55,47.26)
DDR_B_MA15: length 96.7
  IN4 w0.076: v1(150.18,73.96) 149.81,73.59 149.81,70.7 150.93,69.57 150.93,68.94
  IN4 w0.132: v1(205.32,45.74) 204.86,46.21 204.86,49.18 202.11,51.94 202.11,52.54 196.36,58.28 195.59,58.28 194.72,59.15 194.55,59.15 194.42,59.27 194.42,59.45 194.3,59.57 194.13,59.57 194,59.45 194,59.27 193.88,59.15 193.69,59.15 193.56,59.27 193.56,59.5 193.43,59.63 193.24,59.63 193.11,59.5 193.11,59.27 192.99,59.15 192.8,59.15 192.67,59.27 192.67,59.5 192.54,59.63 192.35,59.63 192.22,59.5 192.22,59.27 192.1,59.15 191.92,59.15 191.79,59.27 191.79,59.5 191.67,59.62 191.49,59.62 191.36,59.5 191.36,59.27 191.23,59.15 191.04,59.15 190.92,59.27 190.92,59.5 190.79,59.63 170.8,59.63 170.29,60.14 162.29,60.14 162.16,60.27 162.16,60.49 162.29,60.61 163.51,60.61 163.63,60.74 163.63,60.94 163.51,61.06 160.8,61.06 160.68,61.19 160.68,61.43 160.8,61.55 162.59,61.55 162.71,61.68 162.71,61.86 162.59,61.98 160.39,61.98 160.26,61.86 160.26,61.33 160.13,61.2 159.97,61.2 159.84,61.33 159.84,61.86 159.72,61.98 157.29,61.98 150.93,68.35 150.93,68.94
  BOTTOM w0.076: v1(150.18,73.96) 149.58,74.56 149.58,77.28 149.45,77.41 149.45,78.97 149.57,79.08 149.57,80.17 149.75,80.35 149.75,80.72 149.71,80.84 149.71,80.95 149.77,81.17 149.77,81.32 149.72,81.47 149.72,81.66 149.79,81.81 149.79,81.92 UC1.AY43
  BOTTOM w0.17: v1(205.32,45.74) 205.32,45.59 204.73,44.99 JDIMM2.156
DDR_B_MA16: length 95.4
  IN4 w0.076: v1(148.6,76.42) 149.12,75.9 149.12,72.34 149.48,71.98 149.48,70.4 150.11,69.76 150.11,68.94
  IN4 w0.132: v1(203.55,45.73) 203.67,45.6 203.87,45.6 204,45.73 204,48.87 201.28,51.58 201.28,52.2 196.02,57.46 194.71,57.46 194.59,57.59 194.59,58.12 194.46,58.25 194.23,58.25 194.1,58.12 194.1,57.59 193.98,57.46 193.79,57.46 193.66,57.59 193.66,58.2 193.53,58.32 193.33,58.32 193.2,58.2 193.2,57.59 193.08,57.46 192.85,57.46 192.72,57.59 192.72,58.2 192.59,58.32 192.39,58.32 192.26,58.2 192.26,57.59 192.14,57.46 191.95,57.46 191.82,57.59 191.82,58.2 191.69,58.32 191.48,58.32 191.35,58.2 191.35,57.59 191.22,57.46 191.02,57.46 190.9,57.59 190.9,58.1 190.19,58.81 169,58.81 168.87,58.93 168.87,59.19 168.74,59.32 168.53,59.32 168.4,59.19 168.4,58.93 168.27,58.81 168.08,58.81 167.95,58.93 167.95,59.19 167.83,59.32 167.64,59.32 167.51,59.19 167.51,58.93 167.38,58.81 167.18,58.81 167.05,58.93 167.05,59.19 166.93,59.32 166.74,59.32 166.61,59.19 166.61,58.93 166.48,58.81 166.32,58.81 166.19,58.93 166.19,59.19 166.06,59.32 165.86,59.32 165.73,59.19 165.73,58.93 165.61,58.81 165.41,58.81 165.29,58.93 165.29,59.19 165.16,59.32 165.01,59.32 164.88,59.19 164.88,58.93 164.76,58.81 164.58,58.81 164.45,58.93 164.45,59.19 164.32,59.32 161.94,59.32 161.02,60.24 159.82,60.24 159.66,60.41 157.71,60.41 150.11,68 150.11,68.94
  BOTTOM w0.076: UC1.AW44 149.42,82.37 149.26,82.21 149.15,81.99 149.13,81.93 149.13,81.46 148.89,81.22 148.89,79.41 148.79,79.31 148.79,76.61 v1(148.6,76.42)
  BOTTOM w0.17: JDIMM2.152 203.73,42.79 204.06,43.13 204.06,45.23 203.56,45.73 v1(203.55,45.73)
DDR_B_ODT0: length 92
  IN4 w0.076: v1(150.01,78.65) 149.44,78.08 149.44,76.01 149.81,75.64 150.34,75.64 150.57,75.4 150.57,70.93 151.57,69.92 151.57,68.94
  IN4 w0.132: 151.57,68.94 151.57,68.61 157.54,62.65 162.83,62.65 164.7,60.78 170.55,60.78 171.06,60.27 194.51,60.27 195.85,58.92 196.64,58.92 203,52.57 203,51.96 205.5,49.46 205.5,49.27 205.63,49.14 206.02,49.14 206.14,49.02 206.14,48.85 206.02,48.73 205.63,48.73 205.5,48.6 205.5,48.43 205.63,48.31 206.11,48.31 206.24,48.18 206.24,48.01 206.11,47.89 205.86,47.89 205.74,47.76 205.74,47.62 205.86,47.49 206.11,47.49 206.24,47.37 206.24,43.79 206.11,43.66 205.88,43.66 205.75,43.79 205.75,47.14 205.62,47.27 v1(205.32,47.27)
  BOTTOM w0.076: UC1.BA42 150.65,81.02 150.42,80.79 150.38,80.69 150.38,80.48 150.38,80.48 150.38,80.4 150.52,80.26 150.52,79.63 150.38,79.5 150.38,79.27 150.26,79.15 150.26,78.89 v1(150.01,78.65)
  BOTTOM w0.17: v1(205.32,47.27) 205.32,47.4 204.48,48.24 JDIMM2.155
DDR_B_ODT1: length 93.9
  IN4 w0.076: 152.41,68.94 152.41,69.74 151.47,70.68 151.47,75.78 151.02,76.23 v1(150.15,76.23)
  IN4 w0.132: v1(207.08,47.26) 207.08,47.04 207.2,46.91 207.45,46.91 207.57,47.04 207.57,47.37 207.39,47.56 207.39,47.77 207.57,47.96 207.57,48.98 207.45,49.11 207.18,49.11 207.06,49.23 207.06,49.39 207.18,49.51 207.45,49.51 207.57,49.64 207.57,49.82 207.45,49.95 206.46,49.95 206.35,50.06 206.35,50.22 206.46,50.34 207.45,50.34 207.57,50.47 207.57,50.66 207.45,50.78 206.76,50.78 206.64,50.91 206.64,51.47 206.51,51.6 205.94,51.6 205.81,51.47 205.81,50.74 205.69,50.61 205.52,50.61 205.39,50.74 205.39,51.34 205.21,51.52 205.03,51.52 204.91,51.4 204.73,51.4 204.53,51.6 204.53,51.78 204.65,51.9 204.65,52.08 204.5,52.23 204.32,52.23 204.21,52.12 204.02,52.12 203.83,52.31 203.83,52.5 203.94,52.61 203.94,52.79 196.98,59.75 196.19,59.75 194.85,61.09 171.4,61.09 170.89,61.6 165.04,61.6 163.17,63.47 157.88,63.47 152.41,68.94
  BOTTOM w0.076: UC1.AW42 150.92,82.26 150.92,79.57 150.76,79.4 150.76,76.83 v1(150.15,76.23)
  BOTTOM w0.17: v1(207.08,47.26) 206.78,47.26 206.65,47.13 206.65,46.43 206.53,46.31 206.36,46.31 206.25,46.43 206.25,48.57 205.97,48.84 JDIMM2.161
DDR_B_PARITY: length 99.2
  IN4 w0.076: 147.58,68.94 147.58,70.12 147.38,70.32 147.38,77.2 149.38,79.2 149.38,85.16 149.26,85.27 v1(149.01,85.27)
  IN4 w0.132: 147.58,68.94 147.58,67 156.64,57.94 158.63,57.94 158.8,57.77 160,57.77 160.92,56.85 163.05,56.85 163.55,56.34 171.16,56.34 171.28,56.21 171.28,55.82 171.41,55.69 171.7,55.69 171.83,55.82 171.83,56.21 171.96,56.34 172.2,56.34 172.32,56.21 172.32,55.12 172.45,54.99 172.68,54.99 172.81,55.12 172.81,56.21 172.93,56.34 173.16,56.34 173.29,56.21 173.29,55.12 173.42,54.99 173.64,54.99 173.77,55.12 173.77,56.21 173.9,56.34 174.13,56.34 174.25,56.21 174.25,55.12 174.38,54.99 174.65,54.99 174.77,55.12 174.77,56.21 174.9,56.34 175.14,56.34 175.27,56.21 175.27,55.12 175.4,54.99 175.65,54.99 175.78,55.12 175.78,56.21 175.91,56.34 176.18,56.34 176.31,56.21 176.31,55.12 176.44,54.99 176.68,54.99 176.81,55.12 176.81,56.21 176.93,56.34 177.2,56.34 177.33,56.21 177.33,55.12 177.45,54.99 194.92,54.99 198.63,51.28 198.63,50.74 200.67,48.7 200.67,47.67 v1(200.26,47.26)
  BOTTOM w0.076: UC1.AP43 v1(149.01,85.27)
  BOTTOM w0.17: v1(200.26,47.26) 199.67,47.85 199.67,48.98 199.48,49.17 JDIMM2.143
DDR_DRAMRST#: length 172
  TOP w0.102: RD29.2 RD2.2 107.5,42.12 106.8,42.82 v1(106.8,43.01)
  IN1 w0.084: v1(106.8,43.01) 106.15,42.35 84.38,42.35 83.56,43.17 83.56,46.17 82.66,47.07 82.66,48.68 84.48,50.49 84.48,51.71 87.99,55.22 87.99,56.81 92.02,60.84 v1(94,60.84)
  IN2 w0.122: v1(94,60.84) 94.26,60.58 167.74,60.58 175.54,68.38 182,68.38 183.91,70.29 183.91,74.06 183.36,74.61 183.36,75.56 183,75.92 v1(183,77.45)
  IN4 w0.076: v1(166.38,84) 166.75,83.63 166.75,82.82 169.42,80.15 172.3,80.15 172.38,80.07 176.19,80.07
  IN4 w0.084: 176.19,80.07 179.85,80.07 181.97,77.95 182.51,77.95 v1(183,77.45)
  BOTTOM w0.076: v1(166.38,84) 166.73,84.35 UC1.AT13
DDR_DRAMRST#_R: length 97
  TOP w0.102: CD6.1 RD29.1 108.46,43.9 v1(108.77,44.21) ; CD35.1 190.84,40.36 v1(190.74,40.26)
  IN2 w0.122: v1(190.74,40.26) 190.12,39.64 168.07,39.64 167.87,39.85 167.87,40.45 167.55,40.76 161.92,40.76 159,43.68 155.15,43.68 153.09,41.62 140.71,41.62 139.92,40.84 139.43,40.84 139.11,40.52 139.11,40.03 138.6,39.52 111.17,39.52 110.13,40.56 110.13,42.85 v1(108.77,44.21)
  BOTTOM w0.102: v1(108.77,44.21) 109.17,43.8 109.17,43.29 110.13,42.34 JDIMM1.108 ; JDIMM2.108 190.73,40.27 v1(190.74,40.26)
DDR_VTT_CTRL: length 89.2
  TOP w0.102: v1(81.67,44.33) 82.79,44.33 v2(82.85,44.27) 83.35,43.77 UD1.2
  IN1 w0.102: v1(81.67,44.33) 81.16,44.84 81.16,49.98 84.64,53.46 84.64,65.87 84.48,66.04 84.48,71.41 v1(85.13,72.06)
  BOTTOM w0.076: UC1.AW67 135.42,82.53 135.32,82.63 134.69,82.63 134.63,82.69 133.36,82.69 133.06,82.39 132.33,82.39 131.95,82.01 131.95,81.44 131.81,81.3 131.81,81 131.23,80.43 130.64,80.43 130.22,80.84 128.37,80.84
  BOTTOM w0.102: v1(85.13,72.06) 85.47,71.71 88.91,71.71 92.4,75.21 121.94,75.21 127.58,80.84 128.37,80.84
DDR_XDP_WAN_SMBCLK: length 344.4
  TOP w0.102: v1(179.3,97.4) 179.33,97.44 179.6,97.44 179.84,97.2 179.84,96.34 179.37,95.87 178.52,95.87 178.44,95.95 QC2.1
  IN1 w0.076: 178.45,99.46 178.45,99.44 178.45,99.44 178.45,99.37 178.45,99.37 178.45,97.81 178.5,97.75
  IN1 w0.084: 178.45,99.46 178.45,102 177.26,103.19 177.26,107.16 172.8,111.61 168.7,111.61 166.81,113.51 165.48,113.51 160.66,118.33 160.66,119.64 160.36,119.95 160.36,122.86 159.95,123.27 159.71,123.27 v1(159.52,123.46) ; v1(179.3,97.4) 179.26,97.44 178.81,97.44 178.5,97.75
  IN4 w0.084: v1(159.52,123.46) 159.35,123.3 157.95,123.3 155.53,125.72 149,125.72 145.87,122.59 145.87,122.07 145.53,121.73 139.85,121.73 139.51,121.38 138.64,121.38 138.31,121.05 136.78,121.05 135.8,122.03 132.98,122.03 131.24,123.76 131.24,124.4 v1(131.44,124.6) 131.25,124.79 131.25,125.05 130.65,125.65 129.56,125.65 127.99,127.22 125.77,127.22 125.49,127.5 125.49,128.79 123.61,130.68 120.83,130.68 118.11,127.95 118.11,126.98 116.13,125 116.13,122.84 113.3,120.01 113.3,112.38 118.65,107.03 118.65,95.62 119.97,94.31 119.97,87.71 117.29,85.04 117.29,79.43 121.74,74.98 121.74,52.32 122.46,51.61 122.46,50.66 124.07,49.04 124.07,43.57 125.03,42.61 147.93,42.61 149.56,44.25 152.3,44.25 152.54,44.49 152.54,44.71 v1(152.73,44.9) 152.55,45.08 152.55,46.22 151.81,46.97 150.72,46.97 150.49,46.73 148.97,46.73 148.82,46.88 148.82,47.17 v1(148.97,47.32)
  BOTTOM w0.102: JDIMM2.253 228.98,48.93 229.05,48.85 229.05,44.99 229.23,44.81 232.49,44.81 233.12,44.19 233.12,40.34 231.63,38.85 195.46,38.85 194.86,39.44 193.25,39.44 192.65,38.85 166.81,38.85 165.78,39.87 163.83,39.87 162.48,41.22 162.48,43.17 161.59,44.06 161.19,44.47 161.19,53.24 160.94,53.49 152.75,53.49 152.23,52.97 152.23,46.58 152.55,46.26 152.55,45.08 v1(152.73,44.9) ; RC319.2 158.41,123.16 158.67,123.41 159.47,123.41 v1(159.52,123.46) ; v1(131.44,124.6) 131.26,124.77 131.26,124.91 131.39,125.04 JXDP1.53 ; v1(148.97,47.32) 148.38,47.91 JDIMM1.253
DDR_XDP_WAN_SMBDAT: length 343.1
  TOP w0.102: QC2.4 175.91,97.57 v1(175.9,97.57)
  IN1 w0.076: 178.24,99.46 178.24,97.3 177.9,96.96 177.01,96.96 176.4,97.57 v1(175.9,97.57)
  IN1 w0.084: 178.24,99.46 178.24,101.91 177.05,103.11 177.05,107.07 172.71,111.4 168.61,111.4 166.72,113.3 165.39,113.3 160.45,118.24 160.45,119.56 160.14,119.86 160.14,122.77 159.86,123.06 159.7,123.06 v1(159.52,122.88)
  IN4 w0.084: v1(159.52,122.88) 159.31,123.08 157.87,123.08 155.44,125.5 149.09,125.5 146.09,122.5 146.09,121.99 145.61,121.51 139.94,121.51 139.59,121.17 138.73,121.17 138.4,120.84 136.69,120.84 135.72,121.81 132.9,121.81 131.03,123.68 131.03,124.42 v1(130.86,124.6) 131.04,124.78 131.04,124.96 130.56,125.44 129.48,125.44 127.9,127.01 125.68,127.01 125.28,127.41 125.28,128.7 123.52,130.46 120.92,130.46 118.32,127.87 118.32,126.89 116.34,124.91 116.34,122.75 113.51,119.92 113.51,112.47 118.86,107.11 118.86,95.71 120.18,94.4 120.18,87.63 117.51,84.95 117.51,79.52 121.96,75.07 121.96,52.41 122.67,51.7 122.67,50.75 124.28,49.13 124.28,43.66 125.12,42.82 147.84,42.82 149.48,44.46 152.21,44.46 152.33,44.58 152.33,44.71 v1(152.15,44.9) 152.34,45.09 152.34,46.14 151.72,46.76 150.81,46.76 150.57,46.52 148.88,46.52 148.61,46.79 148.61,47.11 v1(148.41,47.32)
  BOTTOM w0.102: JXDP1.51 130.89,125.04 131.04,124.89 131.04,124.77 v1(130.86,124.6) ; v1(159.52,122.88) 159.21,123.19 158.76,123.19 RC318.2 ; v1(148.41,47.32) 148.63,47.1 JDIMM1.254 ; v1(152.15,44.9) 152.32,45.07 152.32,46.17 152,46.48 152,53.06 152.66,53.72 161.03,53.72 161.41,53.34 161.41,44.57 161.5,44.48 161.75,44.23 162.71,43.27 162.71,41.32 163.93,40.1 165.88,40.1 166.91,39.07 192.55,39.07 193.15,39.67 194.96,39.67 195.55,39.07 231.53,39.07 232.89,40.43 232.89,44.09 232.39,44.59 229.39,44.59 229.23,44.42 JDIMM2.254
DH_1.2V: length 7.7
  IN1 w1.016: 70.65,67.79 71.03,67.79 76.2,72.96
  vias: v1(69.19,67.53) v1(69.76,67.53) v1(76.62,73.82) v1(77.06,73.38)
DIMM1_SA0: length 14.3
  TOP w0.102: RD62.2 154.99,45.5 153.48,45.5 RD66.1 152.65,46.33 152.38,46.33 152.26,46.2 152.26,45.8 152.5,45.56 152.96,45.56 153.36,45.16 153.36,44.47 152.4,43.51 v2(151.87,43.51) 151.67,43.51 v1(151.14,42.99)
  BOTTOM w0.102: v1(151.14,42.99) 151.1,42.95 151.1,41.08 150.61,40.59 149.34,40.59 149.12,40.8 JDIMM1.256
DIMM1_SA1: length 11.6
  TOP w0.102: v1(150.53,43) 150.57,43 151.44,43.87 152.47,43.87 153.16,44.56 153.16,45.07 152.87,45.36 152.38,45.36 152.03,45.72 152.03,46.27 RD67.1 153.38,47.62 154.19,47.62 v2(154.71,47.1) RD63.2
  BOTTOM w0.102: JDIMM1.260 150.12,42.59 v1(150.53,43)
DIMM1_SA2: length 8.5
  TOP w0.102: RD64.2 132.27,39.02 v2(128.88,39.02) 127.33,39.02 RD68.1 126.81,39.54 v1(126.81,40.43)
  BOTTOM w0.102: v1(126.81,40.43) 126.63,40.61 JDIMM1.166
DIMM2_SA0: length 9.3
  TOP w0.102: RD69.2 RD72.1 228.25,42.25 227.1,42.25 226.82,41.97 v2(226.82,40.95) 226.82,40 227.06,39.76 228.09,39.76 v1(228.56,40.23)
  BOTTOM w0.102: JDIMM2.256 229.72,40.89 229.45,40.61 229.22,40.61 228.84,40.23 v1(228.56,40.23)
DIMM2_SA1: length 5
  TOP w0.102: v1(230.27,40.22) 230.22,40.22 RD70.2 RD73.1 228.74,40.64 228.94,40.43 228.94,39.92 v2(228.56,39.54)
  BOTTOM w0.102: JDIMM2.260 230.72,40.67 v1(230.27,40.22)
DIMM2_SA2: length 9.4
  TOP w0.102: v1(207.67,40.28) 207.66,40.27 RD74.1 208.15,39.02 211.6,39.02 212.11,39.53 212.18,39.53 212.7,39.01 v2(214.08,39.01)
  BOTTOM w0.102: JDIMM2.166 207.23,40.72 v1(207.67,40.28)
DIMM_TYPE: length 33.8
  TOP w0.102: v3(178,102.27) 177.48,101.75 v1(177.14,101.75) ; RC342.2 190.52,106.22 RC341.1 191.06,104.83 191.06,102.08 v1(191.66,101.47)
  IN1 w0.076: v1(171.63,95.82) 172.39,95.82 174.08,97.51 174.08,97.93 174.43,98.28 175.08,98.28 175.35,98.55 176.26,98.55 177.17,99.46
  IN1 w0.102: 177.17,99.46 177.34,99.63 177.34,101.55 v1(177.14,101.75)
  IN3 w0.102: v1(191.66,101.47) 190.98,100.78 182.19,100.78 181.23,101.75 v1(177.14,101.75)
  BOTTOM w0.076: UC1.P2 173.11,96.03 171.84,96.03 v1(171.63,95.82)
DIS_BAT_PROCHOT#: length 231.7
  TOP w0.102: v1(77.38,45.31) 78.29,45.31 80.83,42.77 80.83,40.51 82.76,38.59 138.26,38.59 139.25,39.58 140.41,39.58 141.4,40.57 150.02,40.57 151.08,41.63 151.08,42.29 151.28,42.49 152.21,42.49 154.48,44.77 159.72,44.77 164.32,40.17 165.87,40.17 167.47,38.57 222.16,38.57 222.63,39.04 222.63,51.53 221.1,53.06 221.1,57.08 221.68,57.65 224.15,57.65 224.47,57.97 224.47,61.06 224.94,61.53 225.98,61.53 227.37,62.92 228.04,62.92 228.1,62.98 UE1.B51
  TOP w0.254: v1(65.21,64.37) 65.02,64.56 65.02,65.08 65.78,65.85 66.75,65.85 67.31,66.4 67.31,68.06 68.15,68.9 68.15,69.23 69.44,70.52 69.44,72.42 67.84,74.02 PR907.1
  IN1 w0.102: v1(65.21,64.37) 63.12,64.37 62.48,63.74 62.48,57.5 63.16,56.83 64.67,56.83 66.29,55.2 66.29,53.38 67.88,51.79 69.7,51.79 70.27,51.22 70.27,47.41 72.68,44.99 77.06,44.99 v1(77.38,45.31)
DISP_ON: length 5
  TOP w0.102: DV2.1 94.32,109.13 94.46,109.13 RV2.1 94.32,110.14 v1(94.21,110.14) 93.77,110.14 v2(93.58,109.95)
  BOTTOM w0.102: JEDP1.22 v1(94.21,110.14)
DK_AC_OFF: length 5.4
  TOP w0.102: v2(85.16,73.24) 84.8,72.87 v1(84.68,72.87)
  TOP w0.254: PD901.3 84.41,72.87 v1(84.68,72.87) ; PU901.25 87.69,72.67 87.35,73 v1(87.35,73.06)
  IN4 w0.254: v1(87.35,73.06) 87.16,72.87 v1(84.68,72.87)
DK_AC_OFF_EN: length 2.4
  TOP w0.254: PU901.22 89.19,73.3 88.49,74 PR938.1
DK_CSS_GC: length 114.3
  TOP w0.102: v2(22.9,47.79) 22.57,48.12 PR810.2
  TOP w0.254: PU901.11 v1(92.56,67.64) ; PR810.2 v1(21.94,48.8)
  IN3 w0.254: v1(21.94,48.8) 21.94,38 24.67,35.28 25.87,35.28 26.73,36.14 26.73,37.83 28.18,39.28 29.17,39.28 33.11,43.21 36.04,43.21 40.04,39.21 55.11,39.21 56.39,40.49 59.65,40.49 60.81,39.33 66.58,39.33 70.72,43.47 70.72,50.59 70.46,50.85 70.46,52.8 72.18,54.52 74.63,54.52 75.1,54.05 77.85,54.05 78.66,54.86 84.74,54.86 85.65,55.77 86.7,55.77 93.06,62.14 93.06,67.34 92.77,67.64 v1(92.56,67.64)
DK_PWRBAR: length 4.7
  TOP w0.102: v2(81.62,69.83) 83.27,69.83 PR924.1
  TOP w0.203: PU901.33 84.97,68.64 84.62,69 PR924.1
DL_1.2V: length 7.8
  TOP w0.102: v1(77.25,67.53) 77.25,68.16 v2(77.26,68.17)
  IN1 w1.016: 78.84,74.2 79.86,73.19 79.86,70.71 77.57,68.42
  vias: v1(76.68,67.53) v1(77.89,74.96) v1(78.46,74.96)
DMIC0: length 258
  TOP w0.102: UA1.47 287.26,73.56 286.29,74.53 286.08,74.53 285.15,75.46 285.15,76.87 284.2,77.82 282.17,77.82 v1(281.51,77.15) ; CA6.1 100.04,115.36 v1(100.61,114.79)
  IN1 w0.102: v1(248.46,109.5) 248.46,106.96 257.64,97.78 257.64,89.29 258.79,88.15 258.79,86.6 257.92,85.74 257.92,81.4 259.27,80.05 259.27,79.37 260.94,77.69 261.25,77.69 262.43,76.51 263.56,76.51 264.67,77.62 267.5,77.62 269.97,80.09 269.97,82.44 270.87,83.33 272.05,83.33 272.39,83.68 274.87,83.68 279.03,79.51 279.03,76.21 279.32,75.92 280.13,75.92 281.37,77.15 v1(281.51,77.15)
  IN2 w0.102: v1(248.46,109.5) 246.78,111.17 226.6,111.17 226.3,111.47 222.69,111.47 221.39,110.17 220.14,110.17 219.51,109.54 215.83,109.54 215.09,108.8 198.77,108.8 197.03,107.06 197.03,103.45 v1(196.54,102.97)
  IN4 w0.102: v1(114.7,125.67) 112.46,123.42 112.46,122.99 110.77,121.29 110.33,121.29 104.4,115.36 101.18,115.36 v1(100.61,114.79)
  BOTTOM w0.102: v1(196.54,102.97) 195.55,103.96 190.35,103.96 180.95,113.36 180.95,114.25 179.38,115.82 178.58,115.82 172.92,121.47 172.16,121.47 170.48,123.15 162.78,123.15 161.31,124.62 158.13,124.62 157.72,124.21 145.31,124.21 143.95,122.86 140.18,122.86 140.06,122.73 136.81,122.73 134.42,125.12 134.42,127.9 133.58,128.75 130.43,128.75 129.66,129.51 123.96,129.51 122.84,130.63 116.56,130.63 115.26,129.33 115.26,127.59 114.7,127.03 v1(114.7,125.67) ; JEDP1.7 v1(100.61,114.79)
DMIC_CLK0: length 287.6
  TOP w0.102: v1(100.06,114.09) 100.06,114.31 CA5.1 ; v1(281.54,76.59) 280.68,75.73 280.68,75.04 v2(280.77,74.95) CA54.1 283.47,73.94 RA14.2
  IN1 w0.084: v1(281.54,76.59) 279.59,74.63 v1(276.28,74.63) ; v1(270.77,54.39) 270.48,54.39 267.12,51.02 266.28,51.02 263.06,47.8 263.06,46.88 261.12,44.95 258.3,44.95 255.15,41.8 243.23,41.8 242.48,41.04 239.73,41.04 239.01,41.77 234.18,41.77 232.24,39.83 220.17,39.83 219.26,40.73 173.85,40.73 173.27,41.3 161.77,41.3 159.08,43.99 154.76,43.99 154.04,43.28 151.98,43.28 150.74,42.04 v1(150.64,42.04)
  IN2 w0.122: v1(276.28,74.63) 274.78,74.63 274.41,74.26 274.41,73.86 272.68,72.13 272.68,69.22 271.9,68.45 271.9,67.88 272.68,67.1 272.68,61.31 271.39,60.03 271.39,59.56 270.74,58.91 270.74,54.42 v1(270.77,54.39)
  IN4 w0.084: v1(150.64,42.04) 123.54,42.04 122.63,42.96 122.63,49.36 120.86,51.13 120.86,75.21 116.76,79.3 116.76,85.17 119.5,87.91 119.5,92.98 117.87,94.61 107.49,94.61 104.9,97.2 100.81,97.2 99.17,98.84 99.17,105.3 100.19,106.32 100.19,113.97 v1(100.06,114.09)
  BOTTOM w0.102: v1(100.06,114.09) 99.79,114.16 JEDP1.9
DMIC_CLK_CODEC: length 3.3
  TOP w0.102: UA1.2 285.11,71.84 v2(284.91,72.04) 284.91,73.44 RA14.1
DOCK_AC_OFF: length 193.8
  TOP w0.102: v2(82.28,74.99) 82.91,74.37 83.28,74.37
  TOP w0.254: 83.28,74.37 PD901.1 83.73,74.37 84.05,74.68 PR925.1 84.94,74.67 84.94,73.85 v1(84.69,73.61)
  IN1 w0.102: v1(71.47,51.02) 73.25,49.25 79.86,49.25 84.24,53.63 84.24,65.71 84.07,65.87 84.07,72.98 v1(84.69,73.61)
  IN2 w0.102: v1(83.03,107.65) 82.69,107.31 82.69,99.55 79.26,96.12 78.27,96.12 76.34,94.19 76.34,83.65 69.23,76.53 69.23,74.29 67.03,72.1 67.03,70.87 67.51,70.39 v1(67.79,70.39)
  IN3 w0.102: v1(83.03,107.65) 82.22,108.47 82.22,114.89 84.39,117.06 85.55,117.06 86.59,118.11 88.15,118.11 89.53,119.49 115.53,119.49 118.42,122.38 118.42,125.09 119.82,126.49 133.51,126.49 135.46,128.44 137.65,128.44 138.03,128.82 138.03,136.27 v1(134.36,139.94)
  IN4 w0.102: v1(71.47,51.02) 71.22,51.28 71.22,55.22 68.16,58.28 68.16,59.67 67.03,60.79 66.3,60.79 65.73,61.36 65.16,61.36 65.01,61.51 65.01,63.56 66.19,64.74 66.19,69.05 67.54,70.39 v1(67.79,70.39)
  BOTTOM w0.102: v1(134.36,139.94) 134,139.57 JDOCK1.2
DOCK_AC_OFF_EC: length 193.4
  TOP w0.102: UE1.A63 236.42,61.09 v1(236.07,60.74) ; v1(88.49,75.66) 88.49,76.06 v2(88.31,76.23)
  TOP w0.254: v1(88.49,75.66) PR938.2 PR929.1
  IN1 w0.102: v1(88.49,75.66) 87.21,74.38 87.21,73.47 86.52,72.78 86.52,57.62 87.35,56.79 87.35,55.43 84.26,52.35 83.22,51.3 v1(83.22,51.13)
  IN2 w0.102: v1(83.22,51.13) 83.22,50.92 83.73,50.41 86.47,50.41 88.99,52.93 223.73,52.93 229.97,59.17 229.97,61.59 232.67,64.3 234.16,64.3 234.53,63.92 234.53,63.53 234.89,63.18 234.89,62.45 236.07,61.27 v1(236.07,60.74)
DOCK_DCIN_IS+: length 232.7
  TOP w0.254: PQ804.1 17.17,47.89 16.92,48.14 16.17,48.14 15.49,48.82 15.49,53.98 v2(16.3,54.79) 17.16,55.65 17.16,58.73 v1(17.12,58.77)
  IN4 w0.254: v1(168.96,140.3) 169,140.26 169,139.19 167.23,137.42 139.36,137.42 137.57,139.21 134.02,139.21 132.96,140.27 125.54,140.27 124.94,139.67 124.94,135.02 122.47,132.55 118.68,132.55 111.53,125.4 108.65,125.4 108.28,125.76 79.17,125.76 76.88,123.47 76.88,116.71 80.58,113.02 80.58,102.04 73.97,95.43 73.97,85.88 65.95,77.86 65.95,75.49 53.39,62.92 50.66,62.92 48.62,60.89 29.45,60.89 28.53,59.98 17.87,59.98 17.17,59.28 17.17,58.82 v1(17.12,58.77)
  BOTTOM w0.254: v1(168.96,140.3) 169,140.26 JDOCK1.134
DOCK_DCIN_IS-: length 231.9
  TOP w0.254: PQ805.1 17.17,48.91 16.92,48.65 16.38,48.65 16,49.03 v2(16,53.29) 16,53.77 17.67,55.43 17.67,58.73 v1(17.7,58.77)
  IN4 w0.254: v1(169.54,140.3) 169.5,140.26 169.5,138.98 167.44,136.91 139.15,136.91 137.36,138.71 133.8,138.71 132.75,139.76 125.75,139.76 125.45,139.45 125.45,134.81 122.68,132.04 118.89,132.04 111.74,124.89 108.44,124.89 108.07,125.26 79.39,125.26 77.39,123.26 77.39,116.92 81.09,113.23 81.09,101.83 74.48,95.22 74.48,85.67 66.46,77.65 66.46,75.28 53.6,62.42 50.87,62.42 48.83,60.38 29.66,60.38 28.74,59.47 18.08,59.47 17.68,59.07 17.68,58.8 v1(17.7,58.77)
  BOTTOM w0.254: v1(169.54,140.3) 169.5,140.26 JDOCK1.136
DOCK_DET#: length 384
  TOP w0.102: v1(5.18,59.34) 5.06,59.34 v2(4.72,59.69) ; v1(229.83,67.48) 229.33,67.98 UE1.B41
  TOP w0.254: PQ907.2 v1(102.4,73.19) ; PR919.1 v1(5.18,59.34)
  IN1 w0.102: v1(229.83,67.48) 228.99,68.31 223.5,68.31 220.88,70.94 v1(220.56,70.94)
  IN2 w0.102: v1(90.64,57.94) 91.13,57.45 209.97,57.45 214.86,62.34 214.86,64.85 215.66,65.66 217.32,65.66 219.6,67.94 219.6,69.98 v1(220.56,70.94)
  IN3 w0.102: v1(179.55,117.86) 181.07,116.34 188.13,116.34 195.13,109.34 195.13,100.85 196.56,99.42 196.56,97.04 197.74,95.86 197.74,93.76 199.57,91.92 199.57,89.47 198.21,88.1 198.21,86.11 198.43,85.88 198.43,82.06 199.59,80.89 199.59,79.47 199.32,79.21 199.32,76.72 201.03,75.01 205.08,75.01 205.64,74.46 209.07,74.46 209.2,74.33 216.41,74.33 218.65,72.09 220.1,72.09 220.56,71.64 v1(220.56,70.94) ; v1(90.64,57.94) 90.64,56.92 87.73,54.01 78.71,54.01 78.12,53.41 73.22,53.41 71.94,52.13 71.94,50.91 71.36,50.33 71.36,43.15 66.9,38.69 60.55,38.69 59.39,39.85 56.66,39.85 55.37,38.57 39.78,38.57 35.77,42.58 33.37,42.58 29.44,38.64 28.45,38.64 27.37,37.56 27.37,35.87 26.13,34.64 24.41,34.64 19.9,39.15 13.11,39.15 12.47,39.8 10.5,39.8 8.19,42.11 6.47,42.11 5.31,43.28 5.31,50.07 6,50.77 6,58.52 v1(5.18,59.34)
  IN4 w0.102: v1(102.4,73.19) 91.79,62.58 91.79,59.6 90.64,58.45 v1(90.64,57.94)
  BOTTOM w0.102: R272.1 176.54,121.89 D19.2 179.55,119.67 v1(179.55,117.86)
DOCK_DET_R#: length 27.5
  TOP w0.102: v1(173.53,138.97) 171.23,138.97 v2(169.84,137.58) 169.27,137.01 169.27,134.12 173.47,129.92 v1(174.14,129.92)
  BOTTOM w0.102: 171.45,139.67 171.1,139.67 171,139.57 JDOCK1.142 ; 171.45,139.67 172.83,139.67 v1(173.53,138.97) ; 171.45,139.67 171.5,139.62 JDOCK1.144 ; v1(174.14,129.92) 175.22,128.84 175.22,127.78 177.33,125.67 D19.1
DOCK_HP_DET: length 53.6
  TOP w0.102: UE1.A7 v1(239.34,66.23) ; v2(279.84,52.31) 280.07,52.53 RA29.2 279.82,53.56 QA3.2 278.61,53.56 278.42,53.76 278.42,60.79 v1(277.16,62.05)
  IN3 w0.102: v1(239.34,66.23) 239.81,65.76 241.84,65.76 242.68,64.92 246.14,64.92 246.4,65.19 247.29,65.19 247.79,64.69 249.03,64.69 250.26,65.92 251.54,65.92 251.8,65.67 256.4,65.67 256.91,65.16 259.47,65.16 260.13,64.5 262.18,64.5 262.57,64.89 274.32,64.89 v1(277.16,62.05)
DOCK_MIC_DET: length 54.2
  TOP w0.102: QA3.5 276.58,53.56 276.51,53.5 RA26.2 276.02,54.25 276.35,54.58 v2(276.35,57.82) 276.35,60.61 v1(277.1,61.36) ; UE1.B8 237.31,66.48 237.15,66.32 v1(237.15,65.8)
  IN3 w0.102: v1(237.15,65.8) 238.23,64.72 239.71,64.72 240.41,65.41 241.9,65.41 242.99,64.32 247.58,64.32 247.85,64.04 250.72,64.04 251.55,64.87 256.81,64.87 256.89,64.95 259.39,64.95 260.21,64.13 262.26,64.13 262.96,63.43 269.98,63.43 270.86,62.55 273.06,62.55 273.4,62.9 275.68,62.9 277.1,61.48 v1(277.1,61.36)
DOCK_POR_RST#: length 181.8
  TOP w0.102: UE2.A21 252.62,60.67 v1(252.26,60.31) 252.26,60.07 251.91,59.72 251.91,58.86 RE277.2
  IN1 w0.102: v1(181.92,123.74) 182.31,124.13 184.67,124.13 185.42,123.38 185.42,120.42 192.23,113.6 204.16,113.6 204.88,112.89 208.24,112.89 209.16,111.97 209.16,109.88 210.51,108.53 215.08,108.53 215.52,108.09 219.27,108.09 221.15,109.97 225.98,109.97 226.91,109.04 226.91,108.12 227.4,107.63 228.23,107.63 230.01,109.4 238.3,109.4 239.31,108.39 241.38,108.39 250.82,98.95 252.12,98.95 253.06,98.01 253.06,92.74 254.4,91.39 254.4,88.3 253.72,87.61 253.72,85.45 254.89,84.29 254.89,82.76 257.76,79.89 257.76,79.36 261.58,75.54 262.83,75.54 263.25,75.95 263.9,75.95 264.38,75.48 264.81,75.48 v1(265.06,75.73)
  IN2 w0.102: v1(265.58,64.49) 265.38,64.69 265.38,66.58 266.04,67.25 266.04,74.74 v1(265.06,75.73)
  IN4 w0.102: v1(265.58,64.49) 265.58,64.36 264.94,63.72 264.79,63.72 262.96,61.9 262.96,61.55 262.33,60.92 261.67,60.92 260.88,61.71 259.48,61.71 259.26,61.48 257.48,61.48 257.08,61.08 257.08,60.18 256.63,59.72 253.87,59.72 253.28,60.31 v1(252.26,60.31)
  BOTTOM w0.102: JDOCK1.140 170.5,139.51 171.04,140.05 179.11,140.05 180.06,139.1 180.06,130.16 177.66,127.76 177.66,126.32 180.24,123.74 v1(181.92,123.74)
DOCK_PSID: length 117.1
  TOP w0.102: PU1.1 76.77,114.57 v2(77.65,113.7) 78.79,112.56 78.79,111.08 78.31,110.6 PD7.3 PD7.2 80.24,112.19 v1(77.21,115.21)
  IN2 w0.102: v1(85.77,115.46) 85.63,115.6 84.55,115.6 84.02,116.14 78.14,116.14 v1(77.21,115.21)
  IN3 w0.102: v1(169.48,128.51) 169.27,128.3 167.62,128.3 166.01,126.69 163.54,126.69 162.8,127.43 135.89,127.43 133.93,125.47 127.28,125.47 125.5,123.69 121.17,123.69 115.95,118.47 90.02,118.47 88.64,117.09 87.08,117.09 85.77,115.78 v1(85.77,115.46)
  BOTTOM w0.102: JDOCK1.135 169.5,128.53 v1(169.48,128.51)
DOCK_PWR_BTN#: length 143.7
  TOP w0.102: v2(257.76,81.36) 257.76,81.21 v1(257.37,80.82) ; v1(242.87,77.53) 243.25,77.15 CE44.1 244.18,76.81 RE42.2
  IN1 w0.102: v1(257.37,80.82) 257.37,82.16 256.47,83.05 256.47,83.64 255.05,85.06 255.05,86.2 255.75,86.9 255.75,91.96 254.22,93.49 254.22,98.49 252.04,100.67 250.73,100.67 248.5,102.9 240.21,111.2 229.85,111.2 229.4,110.75 226.94,110.75 226.19,111.5 221.05,111.5 219.23,109.68 211.1,109.68 210.45,110.33 210.45,113.97 209.45,114.97 192.79,114.97 186.95,120.8 186.95,124.04 185.31,125.68 172.01,125.68 171.15,126.54 v1(171,126.54)
  IN3 w0.102: v1(242.87,77.53) 245.17,79.83 250.14,79.83 251.63,81.32 255.06,81.32 255.7,80.68 257.22,80.68 v1(257.37,80.82)
  BOTTOM w0.102: v1(171,126.54) 171.36,126.89 171.36,128.39 170.5,129.25 JDOCK1.139
DOCK_PWR_SW#: length 9.6
  TOP w0.102: UE2.A63 251.12,72.75 250.64,73.22 250.64,73.43 v2(250.2,73.87) 249.89,74.19 248.64,74.19 248.41,74.42 247.63,74.42 246.71,75.35 245.86,75.35 245.28,75.92 CE45.1 244.21,75.92 RE42.1 243.27,75.9 RE62.2
DOCK_SMB_ALERT#: length 340
  TOP w0.102: UE1.A51 v1(230.42,60.42) 230.42,59.66 RE9.2 ; v1(225.26,68.73) 225.26,68.72 224.85,68.31 223.98,68.31 222.6,69.69 v2(222.6,70.05) 222.6,70.48 222.27,70.81 222.27,72.6 v1(221.84,73.03)
  TOP w0.254: PQ2.3 69.22,44.07 v1(68.55,43.4)
  IN1 w0.102: v1(235.07,78.49) 235.47,78.89 240.94,78.89 241.55,79.5 241.55,81.86 244.59,84.9 244.59,85.9 245.42,86.74 245.88,86.74 247.64,88.5 247.64,95.06 241.92,100.78 229.94,100.78 229.44,100.28 210.51,100.28 203.73,107.05 191.69,107.05 189.59,109.15 187.7,109.15 183.29,113.56 183.29,113.9 180.3,116.89 179.36,116.89 v1(178.39,117.86)
  IN2 w0.102: v1(230.42,60.42) 230.42,59.26 223.89,52.73 91.55,52.73 v1(91.12,52.3) ; v1(235.07,78.49) 234.31,78.49 232.12,76.31 224.54,76.31 221.84,73.61 v1(221.84,73.03)
  IN4 w0.102: v1(68.55,43.4) 68.55,40.56 69.9,39.21 73.08,39.21 73.53,39.66 73.53,43.75 77.53,47.75 79.24,47.75 80.62,49.13 89.8,49.13 90.97,50.3 90.97,52.14 v1(91.12,52.3)
  BOTTOM w0.102: v1(230.42,60.42) 230.42,60.98 230.11,61.29 226.04,61.29 224.24,63.08 224.24,64.78 224.8,65.34 224.8,68.27 v1(225.26,68.73) ; JDOCK1.133 169,128.41 170.52,126.88 170.52,125.28 172.96,122.84 173.54,122.84 178.39,117.99 v1(178.39,117.86)
DOCK_SMB_CLK: length 149.8
  TOP w0.102: UE2.B4 250.41,69.54 v1(250.42,69.53) ; v1(247.37,69.78) 247.17,69.58 RPE3.2
  IN1 w0.084: v1(250.42,69.53) 249.77,70.18 247.91,70.18 247.52,69.78 v1(247.37,69.78) ; v1(254.1,87.19) 254.27,87.02 254.66,87.02 254.93,87.29 254.93,91.54 253.53,92.94 253.53,98.21 252.32,99.42 251.01,99.42 240.56,109.88 229.03,109.88 228.28,109.13 227.49,109.13 225.82,110.8 221.31,110.8 219.51,109 210.7,109 209.63,110.07 209.63,113.4 208.74,114.28 192.51,114.28 186.22,120.57 186.22,123.73 184.96,125 171.72,125 170.37,126.35 170.37,126.98 169.44,127.9 167.98,127.9 167.64,128.23 167.64,128.51 v1(167.46,128.7)
  BOTTOM w0.102: v1(247.37,69.78) 247.55,69.96 247.55,70.25 247.95,70.65 247.95,72.27 247.3,72.92 247.3,73.92 245.18,76.04 245.18,79.34 245.67,79.83 248.95,79.83 249.07,79.95 249.07,80.35 250.96,82.24 251.22,82.24 253.2,84.22 253.2,86.65 253.51,86.97 253.87,86.97 v1(254.1,87.19) ; v1(167.46,128.7) 167.64,128.88 167.64,129.39 167.5,129.53 JDOCK1.127
DOCK_SMB_DAT: length 147.4
  TOP w0.102: RPE3.1 246.66,69.08 246.93,69.36 247.5,69.36 247.93,69.79 v1(248.06,69.79) UE2.A3
  IN1 w0.084: v1(168.04,128.7) 167.86,128.51 167.86,128.32 168.06,128.11 169.53,128.11 170.58,127.06 170.58,126.44 171.81,125.21 185.05,125.21 186.43,123.82 186.43,120.66 192.6,114.49 208.83,114.49 209.84,113.48 209.84,110.16 210.79,109.21 219.43,109.21 221.22,111.01 225.91,111.01 227.58,109.34 228.19,109.34 228.94,110.09 240.65,110.09 251.1,99.63 252.41,99.63 253.74,98.3 253.74,93.02 255.14,91.63 255.14,87.2 254.75,86.81 254.3,86.81 v1(254.1,86.61)
  BOTTOM w0.102: v1(254.1,86.61) 253.97,86.74 253.6,86.74 253.43,86.56 253.43,84.12 251.32,82.01 251.06,82.01 249.3,80.25 249.3,79.85 249.04,79.6 245.77,79.6 245.41,79.24 245.41,76.13 247.53,74.01 247.53,73.01 248.18,72.37 248.18,70.56 247.77,70.15 247.77,70.07 v1(248.06,69.79) ; v1(168.04,128.7) 167.86,128.88 167.86,129.39 168,129.53 JDOCK1.129
DOCKED: length 75.5
  TOP w0.102: v1(226.42,68.73) 226.92,68.23 UE1.A38 ; UL4.13 v1(263.47,106.16)
  IN2 w0.102: v1(237.91,84.13) 238.16,83.88 238.16,79.38 236.68,77.9 234.92,77.9 234.55,77.53 234.55,74.22 234.27,73.94 231.16,73.94 230.13,74.96 228.84,74.96 228.42,74.54 228.42,73.87 229.27,73.02 229.27,71.94 230.85,70.36 230.85,69.82 229.99,68.97 228.72,68.97 228.5,69.2 226.89,69.2 v1(226.42,68.73)
  IN3 w0.102: v1(237.91,84.13) 238.27,83.77 239.15,83.77 240.83,85.44 246.75,85.44 248.07,86.76 248.07,95.75 249.79,97.48 249.79,102.07 251.03,103.3 260.61,103.3 v1(263.47,106.16)
DP_OCB#: length 2.3
  BOTTOM w0.102: v2(222.98,126.22) RV622.2 221.82,126.07 UV27.3
EC5048_TX: length 6.7
  TOP w0.102: UE1.B2 v1(237.11,63.48) ; v2(238.41,60.58) 237.67,61.33 v1(237.67,62.41) 238.51,61.56 239.72,61.56 RE305.1
  IN2 w0.102: v1(237.11,63.48) 237.11,62.96 v1(237.67,62.41)
EC5048_TX_R: length 106.1
  TOP w0.102: RE306.2 RE305.2 240.26,60.82 240.45,61.01 240.45,62 240.27,62.18 239.7,62.18 239.1,62.77 239.1,62.79 v1(239.1,62.79) ; v1(281.89,6.74) 281.49,7.13 280.2,7.13 RE74.2 279.27,8.06 278.71,8.06 278.52,7.87 JDEG1.9
  IN1 w0.102: v1(263.64,59.84) 261.85,59.84 261,60.69 259.14,60.69 258.24,59.79 254.3,59.79 252.64,61.45 249.36,61.45 248.45,60.54 246.73,60.54 243.72,63.54 239.84,63.54 v1(239.1,62.79) ; v1(281.89,6.74) 282.34,7.19 283.36,7.19 284.82,8.65 284.82,9.64 284.67,9.79 284.67,11.79 286.74,13.86 286.74,15.48 285.89,16.33 285.89,17.51 277.15,26.25 v1(276.93,26.25)
  BOTTOM w0.102: v1(263.64,59.84) 264.1,59.84 264.83,59.11 265.36,59.11 266.19,58.29 267.34,58.29 268.12,57.51 268.12,56.29 269.18,55.23 v2(269.2,55.23) 271.73,52.7 275.56,52.7 276.29,51.97 276.29,26.89 v1(276.93,26.25)
EC_32KHZ_ECE5048: length 28.6
  TOP w0.102: UE2.B2 250.17,70.54 v1(250.38,70.75) ; UE1.B35 228.2,70.98 228.08,71.1 v1(228.08,71.76) v2(228.08,73.46)
  IN3 w0.102: v1(228.08,71.76) 228.08,72 228.64,72.56 229.16,72.56 229.96,71.76 241.36,71.76 242.12,71 244.62,71 246.42,72.79 247.13,72.79 249.17,70.75 v1(250.38,70.75)
EC_FPM_EN: length 94.7
  TOP w0.102: v1(253.4,70.98) 253.37,71.01 UE2.B62 ; v1(286.4,9.36) v2(286.4,8.73)
  IN2 w0.102: v1(286.4,9.36) 285.66,8.62 281.73,8.62 279.02,11.33 279.02,12.35 275.1,16.28 275.1,37.54 268.54,44.1 268.54,51.97 269.92,53.36 269.92,54.35 270.05,54.47 270.05,57.62 270.05,57.63 270.05,59.2 270.67,59.83 270.67,63.51 271.21,64.04 271.21,66.15 270.66,66.7 270.66,68.28 v1(269.72,69.22)
  IN3 w0.102: v1(269.72,69.22) 269.31,68.82 265.52,68.82 265.12,69.22 263.13,69.22 262.74,69.6 260.53,69.6 259.37,70.76 258.79,70.76 258.14,71.41 256.18,71.41 255.98,71.2 255.98,70.05 255.57,69.64 254.39,69.64 253.87,70.16 253.87,70.51 v1(253.4,70.98)
  BOTTOM w0.102: JUSH1.22 v1(286.4,9.36)

# Allegro board LAC451PR10-0923B.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
GNDA: length 39.3
  TOP w0.102: v3(293.66,40.38) 293.65,40.37 RA36.1 ; v3(283.12,49.31) 283.49,48.94 CA1.2 ; v3(299.21,63.52) 299.22,63.53 RA35.1
  TOP w0.203: CA9.2 293.63,66.9 293.18,67.36 293.18,67.56 292.5,68.24 UA1.26
  TOP w0.508: CA25.2 298.1,70.84 v1(298.49,71.22) ; v1(299.61,75.43) 299.61,74.58 299.13,74.58 QA2.4 ; CA3.2 v1(282.85,54.26) ; CA26.2 292.68,63.2 v1(292.8,63.09) ; CA4.2 283.41,51.01 v1(282.85,51.01) ; v1(300.5,62.78) RA35.1 ; CA1.2 282.88,48.17 v1(282.85,48.19) 282.55,48.19 282.14,47.78 282.14,46.49 282.5,46.14 CA2.2 ; v1(296.58,73.19) QA2.1 ; RA37.1 v1(283.96,56) ; CA35.1 294.62,66.82 CA9.2 ; CA51.2 295.58,61.11 RA44.2 v1(296.31,62.01) ; v1(291.36,40.37) RA36.1 ; v1(295.6,75.69) CA18.2
  GND1 w0.203: 294.6,52.52 JHP1.7 ; JHP1.7 294.6,53.16 ; JHP1.7 296.7,52.52 ; JHP1.7 295.65,53.16 ; JHP1.7 296.7,53.16
  GND2 w0.203: JHP1.7 295.65,53.16 ; JHP1.7 296.7,52.52 ; JHP1.7 294.6,52.52 ; JHP1.7 294.6,53.16 ; JHP1.7 296.7,53.16
  GND3 w0.203: JHP1.7 296.7,52.52 ; JHP1.7 295.65,53.16 ; JHP1.7 294.6,53.16 ; JHP1.7 294.6,52.52 ; JHP1.7 296.7,53.16
  vias: v1(291.75,76.04) v1(291.8,75.41) v1(292.81,73.93) v1(293.84,73.92) v1(296.14,66.12) v1(296.38,65.58) v1(296.57,75.98) v1(297.2,75.98) v1(297.84,75.98) v1(299.12,75.98)
VCC_GT_SENSE: length 65
  TOP w0.127: PC617.1 87.36,82.36
  TOP w0.203: v1(87.28,83.83) 87.36,83.75 PR622.1 87.36,82.36
  TOP w0.254: RC161.2 131.71,98.12 v1(131.71,97.35)
  IN1 w0.254: v1(131.71,97.35) 131,96.64 123.46,96.64 116.77,89.95 105.76,89.95 105.39,89.57 101.82,89.57 99.79,91.6 90.84,91.6 89.19,89.95 89.19,86.46 88.49,85.76 87.6,85.76 86.78,84.94 86.78,84.69 86.78,84.68 86.78,84.33 v1(87.28,83.83)
  BOTTOM w0.076: 132.99,98.19 133.12,98.06 133.55,98.06 133.8,98.18 133.8,98.19 133.8,98.19 133.94,98.33 UC1.J70
  BOTTOM w0.127: 132.99,98.19 132.44,98.19 131.71,97.46 v1(131.71,97.35)
  BOTTOM w0.254: PC618.2 84.6,82.46 PC620.1 86.65,82.44 v2(87.04,82.83) 87.28,83.08 v1(87.28,83.83)
VCCIO_SENSE: length 103.4
  TOP w0.127: v1(159.98,86.56) 159.61,86.19 v2(159.56,86.19)
  TOP w0.254: v1(231.89,43.62) 231.89,43.71 232.66,44.48 PR422.2 ; RC165.2 159.57,87.11 159.57,86.97 v1(159.98,86.56)
  IN1 w0.254: v1(159.98,86.56) 160.44,86.1 160.44,83.45 160.07,83.08 160.07,80.88 160.46,80.49 160.46,79.06 160.71,78.8 164.79,74.72 164.79,74.09 164.79,73.3 165.34,72.75 165.34,70.98 166.56,69.76 166.56,69.27 168.62,67.21 168.62,66.74 172.02,63.33 173.59,63.33 174.18,62.73 175.16,62.73 185.03,52.86 186.19,52.86 189.19,49.86 229.43,49.86 230.79,48.49 230.79,46.94 230.31,46.46 230.31,45.09 231.25,44.15 231.78,44.15 231.92,44.01 231.92,43.66 v1(231.89,43.62)
  BOTTOM w0.254: v1(159.98,86.56) UC1.AM23
VCCSA_B+: length 0.6
  TOP w0.102: v1(129,111.86) v3(128.42,111.86)
  vias: v1(129,111.29)
VCCSENSE: length 153.3
  TOP w0.254: v1(91.12,88.74) 91.23,88.63 PR648.1 91.81,88.62 PC639.1 92.67,89.44 PC651.2 92.59,89.49 PC653.1
  IN2 w0.254: v1(80.44,120.18) 80.44,119.8 80.64,119.59 84.41,119.59 85,120.18 88.36,120.18 89.19,119.35 103.1,119.35 103.4,119.66 116.61,119.66 119.52,122.56 123.96,122.56 124.48,123.08 130.66,123.08 131.85,124.28 134.45,124.28 136.35,126.18 146.78,126.18 148.19,124.77 148.19,121.58 149.15,120.63 149.15,117.3 150.9,115.54 156.33,115.54 157.4,114.47 157.4,108.54 156.36,107.5 156.36,105.39 156.63,105.13 156.63,104.61 v1(156.66,104.58)
  BOTTOM w0.076: UC1.E32 155.39,100.97 155.39,101.45 155.41,101.47 155.41,101.77 155.39,101.79 155.39,102.03 155.41,102.05 155.41,103.43 155.75,103.77 156.17,103.77 156.53,104.13 156.53,104.45 v1(156.66,104.58) 156.54,104.7 156.54,105.23 RC140.2
  BOTTOM w0.254: v1(91.12,88.74) 91.15,88.77 93.06,88.77 94.08,89.78 94.08,91.06 94.76,91.75 94.76,93.91 93.83,94.84 91.52,94.84 90.1,96.26 90.1,100.7 87.94,102.87 87.37,102.87 86.8,103.44 83.38,103.44 81.38,105.44 81.38,114.99 80.39,115.98 80.39,120.13 v1(80.44,120.18)
VCCST_PWRGD: length 9.7
  TOP w0.102: v1(133.33,106.91) v3(132.79,106.91)
  BOTTOM w0.076: UC1.B65 137.51,102.87 137.51,103.95 136.19,105.28 136.19,105.73 135.47,106.45 133.79,106.45 v1(133.33,106.91) 133.33,106.9 132.78,106.9 RC78.2
VCCST_PWRGD_EC: length 3.8
  TOP w0.102: UE2.A44 260.17,68.79 260.45,69.06 260.9,69.06 260.94,69.02 262.86,69.02 RE308.2
VDD_1.2V: length 3.8
  IN1 w0.254: v1(78.33,77.38) 79.47,76.23 v1(80.81,76.23)
  BOTTOM w0.203: v1(78.33,77.38) 77.96,77.01 PU201.11
VIN_1.8VALW:
  vias: v2(292.85,5.47)
VIN_1V_PRIM:
  vias: v2(244.45,91.49)
VIN_1VS_VCCIO:
  vias: v1(238.27,42.15) v1(238.91,42.15) v2(238.69,41.6)
VSS_GT_SENSE: length 63.3
  TOP w0.203: PU602.6 87.32,84.58 v1(87.35,84.55)
  TOP w0.254: v1(132.28,97.38) 132.29,97.39 132.29,97.95 RC163.1
  IN1 w0.254: v1(87.35,84.55) 87.35,84.74 87.86,85.25 88.7,85.25 89.7,86.25 89.7,89.74 91.05,91.09 99.49,91.09 101.52,89.06 105.6,89.06 105.97,89.44 116.98,89.44 123.67,96.13 131.21,96.13 131.22,96.12 131.24,96.12 132.28,97.16 v1(132.28,97.38)
  BOTTOM w0.076: 132.85,97.9 133.58,97.9 133.99,98.06 134.27,98.06 134.54,98.33 UC1.J69
  BOTTOM w0.127: v1(132.28,97.38) 132.8,97.9 132.85,97.9
  BOTTOM w0.254: PC619.2 84.6,83.35 PC620.2 85,82.98 v2(85.75,82.98) 85.94,82.98 86.76,83.8 86.76,83.97 v1(87.35,84.55)
VSSIO_SENSE: length 102.6
  TOP w0.127: v1(160.9,86.56) 160.91,86.56 v2(161.33,86.14)
  TOP w0.254: PR412.2 232.5,43.6 v1(232.47,43.62) ; v1(160.9,86.56) 160.87,86.56 RC167.1
  IN1 w0.254: v1(160.9,86.56) 161.14,86.56 161.35,86.35 161.35,83.16 160.58,82.38 160.58,81.09 160.96,80.7 160.96,79.27 165.3,74.93 165.3,74.09 165.3,73.51 165.85,72.96 165.85,71.19 167.07,69.97 167.07,69.48 169.12,67.42 169.12,66.95 172.23,63.84 173.8,63.84 174.39,63.24 175.37,63.24 185.24,53.37 186.4,53.37 189.41,50.36 229.64,50.36 231.3,48.7 231.3,46.72 230.82,46.24 230.82,45.3 231.46,44.66 231.99,44.66 232.43,44.22 232.43,43.66 v1(232.47,43.62)
  BOTTOM w0.254: v1(160.9,86.56) UC1.AM22
VSSSENSE: length 153
  TOP w0.203: PC653.2 91.12,89.8 v1(91.12,89.32) 90.99,89.32 90.53,88.85 PU602.18
  TOP w0.254: PC654.2 91.74,90.39 PC653.2
  IN2 w0.254: v1(79.86,120.18) 79.93,120.1 79.93,119.58 80.43,119.08 84.62,119.08 85.21,119.67 88.15,119.67 88.98,118.84 103.31,118.84 103.61,119.15 116.82,119.15 119.73,122.06 124.17,122.06 124.69,122.58 130.87,122.58 132.06,123.77 134.66,123.77 136.56,125.67 146.57,125.67 147.69,124.56 147.69,121.37 148.64,120.42 148.64,117.08 150.69,115.03 156.12,115.03 156.89,114.26 156.89,108.75 155.85,107.71 155.85,105.18 156.12,104.92 156.12,104.63 156.08,104.6 v1(156.08,104.58)
  BOTTOM w0.076: RC141.1 156.21,105.24 156.21,104.71 v1(156.08,104.58) 156.2,104.46 156.2,104.27 156.03,104.1 155.61,104.1 155.08,103.56 155.08,102.7 154.82,102.44 154.82,102.12 154.88,102.06 154.88,101.77 154.82,101.71 154.82,101.42 154.95,101.29 UC1.E33
  BOTTOM w0.254: v1(91.12,89.32) 91.16,89.28 92.85,89.28 93.57,90 93.57,91.27 94.26,91.96 94.26,93.7 93.62,94.33 91.31,94.33 v2(90.29,95.35) 89.6,96.05 89.6,100.49 87.73,102.36 87.16,102.36 86.59,102.93 83.17,102.93 80.87,105.23 80.87,114.78 79.88,115.77 79.88,120.15 v1(79.86,120.18)
3301_ACAV_IN_NB: length 2.3
  TOP w0.254: PR922.1 87.6,73.51 v2(87.89,73.23) 88.19,72.93 PU901.24
3301_PWRSRC: length 1.9
  TOP w0.254: PR939.1 92.81,69.88 92.69,69.77 92.31,69.77 92.18,69.64 PU901.15
+BL_PWR_SRC: length 4.5
  TOP w0.127: v3(91.98,116.17) 91.39,116.17 90.97,115.74 QV1.1 ; QV1.2 90.02,115.42 v3(90.31,115.71)
  vias: v1(93.19,111.03) v1(93.57,111.54) v1(93.83,111.03) v1(94.21,111.54) v3(92.34,111.04)
+CAP_LDO: length 8.6
  TOP w0.102: v2(222.74,64.09) 222.92,64.27 v1(225.46,64.27)
  TOP w0.305: UE1.B46 v1(229.23,65.48)
  TOP w0.508: CE7.1 v1(225.46,64.27)
  BOTTOM w0.508: v1(229.23,65.48) 228.03,64.27 v1(225.46,64.27)
+COINCELL: length 5.7
  BOTTOM w0.508: JRTC1.1 277.38,16.98 277.95,16.4 v3(279.51,16.4) 280.95,16.4 PR2.1
+DC_IN: length 73.9
  TOP w0.508: v1(63.04,61.34) 62.28,60.58 PR830.1 ; 72.55,96.68 76.34,92.89 v3(76.34,89.91) 76.34,82.87 v3(74.2,80.72) 70.9,77.43 v3(68.44,77.43) 67.26,77.43 63.98,74.15 63.98,73.47 62.09,71.57 62.09,67.86 62.95,67 v1(63.98,67) ; PR921.1 v1(83.37,63.05)
  IN2 w0.508: v1(63.98,67) 63.98,66.29 61.97,64.28 61.2,64.28 60.94,64.03 60.94,62.9 61.45,62.39 62.25,62.39 63.04,61.6 v1(63.04,61.34)
  IN3 w0.508: v1(63.04,61.34) 63.45,60.93 65.81,60.93 66.49,60.24 72.41,60.24 72.92,59.74 74.85,59.74 75.51,60.4 80.12,60.4 82.78,63.05 v1(83.37,63.05)
+DC_IN_SS: length 51.9
  TOP w0.508: v1(71.79,59.09) 71.54,59.34 69.63,59.34 v3(68.81,58.52) 68.23,57.95 68.23,57.91 66.95,56.63 63.74,56.63 63.54,56.42 PD801.2 61.38,56.42 v1(60.68,57.12) ; v1(12.67,58.45) 12.19,58.45 12.1,58.37 11.39,58.37 PD905.3 ; PR935.1 v1(82.01,67.73)
  TOP w2.54: 69.57,80.3 71.47,80.3 74.65,83.47 74.65,91.47
  IN1 w0.508: v1(59.73,63.15) 60.22,62.66 60.22,57.58 v1(60.68,57.12) ; v1(71.79,59.09) 74.15,59.09 75.37,60.32 78.96,60.32 82.01,63.37 v1(82.01,67.73)
  vias: v1(12.67,59.09) v1(12.67,57.84) v1(13.31,59.09) v1(13.31,58.45) v1(13.31,57.84) v1(13.88,58.76) v1(13.88,58.12) v1(14.51,58.76) v1(14.51,58.12) v1(67.41,80.81) v1(67.66,81.31) v1(67.66,80.3) v1(68.04,80.81) v1(68.3,81.31) v1(69.44,92.87) v1(70.08,92.87) v1(70.71,92.87) v1(71.35,92.87) v1(71.35,92.24) v1(71.92,92.87) v1(71.92,92.24) v1(72.49,92.87) v1(72.49,92.24) v1(72.49,91.6)
+DCIN: length 1.6
  TOP w0.102: v2(58.33,49.31) 57.92,49.72 PC814.1
+DCIN_JACK:
  vias: v1(73.7,101.25) v1(73.7,100.62) v1(74.33,101.38) v1(74.33,100.75) v1(74.97,101.51) v1(74.97,100.87) v1(75.6,101.63) v1(75.6,101) v1(76.24,101.76) v1(76.24,101.13) v3(75.07,102.15) v3(75.13,103.92) v3(76.06,100.59)
+DCPRTC: length 11.6
  BOTTOM w0.381: 169.21,79.79 169.42,79.59 169.53,79.59 171.96,77.16 v2(173.53,77.16) 174.3,77.16 175.19,76.27 175.19,75.9 175.54,75.56 177.2,75.56 177.76,76.12 CC214.1
+DDR_VREF_A_CA: length 6.2
  TOP w0.102: RD20.1 127.85,42.98 v2(127.67,43.16)
  TOP w0.508: v1(126.07,40.42) 126.24,40.59 RD18.2 126.59,41.25 127.51,42.16 RD20.1 RD19.1
  BOTTOM w0.305: v1(126.07,40.42) 126.07,40.48 126.12,40.53 JDIMM1.164
+DDR_VREF_A_DQ: length 14
  TOP w0.508: v1(135.25,81.11) 135.25,80.72 133.57,79.04 132.15,79.04 128.35,75.24 125.44,75.24 T132.1
  BOTTOM w0.254: v1(135.25,81.11) 135.22,81.15 UC1.AY68
+DDR_VREF_B_CA: length 5.6
  TOP w0.102: v1(206.88,40.27) 206.88,39.79 v2(206.7,39.61)
  TOP w0.508: v1(206.88,40.27) 206.87,40.28 206.87,40.53 206.69,40.71 RD22.2 206.83,41.11 207.74,42.02 RD75.1 RD24.1
  BOTTOM w0.305: JDIMM2.164 206.73,40.64 206.88,40.48 v1(206.88,40.27)
+DDR_VREF_B_DQ: length 122.9
  TOP w0.508: RD75.2 CD54.1 209.1,40.83 v1(209.1,40.36)
  IN3 w0.508: v1(122.4,73.39) 124.56,71.23 139.38,71.23 157.97,52.64 157.97,46.62 162.62,41.97 170.02,41.97 170.89,41.11 208.46,41.11 209.1,40.46 v1(209.1,40.36)
  BOTTOM w0.152: 135.51,80.37 135.54,80.39 135.54,80.74 135.86,81.06 UC1.BA67
  BOTTOM w0.203: 130.72,77.77 130.72,77.99 132.42,79.68 134.41,79.68 134.95,80.23 135.37,80.23 135.51,80.37
  BOTTOM w0.508: v1(122.4,73.39) 126.34,73.39 130.72,77.77
+DDR_VREF_CA: length 85
  TOP w0.508: v1(143.8,51.79) 143.42,51.79 142.85,51.22 v2(142.85,50.24) 142.85,43.46 141.4,42.01 137.01,42.01 136.24,41.25 CD36.1 RD19.2
  IN3 w0.508: v1(143.8,51.79) 143.8,65.38 139.25,69.92 124.43,69.92 121.24,73.11 v1(121.24,73.36)
  BOTTOM w0.203: UC1.AY67 135.97,81.88 136.21,81.65 136.21,80.73 136.22,80.72 136.22,79.85 135.76,79.39 132.89,79.39 132.79,79.29 132.56,79.29
  BOTTOM w0.381: 131.1,77.3 131.1,77.35 131.39,77.64 131.39,78.12 132.56,79.29
  BOTTOM w0.508: 131.1,77.3 131.1,76.72 126.76,72.37 121.98,72.37 121.24,73.11 v1(121.24,73.36)
+DOCK_PWR_BAR: length 29.8
  TOP w0.508: v1(60.81,58.9) 61.5,58.2 PD802.2 62.37,58.44 63.21,58.44 64.5,59.74 65.38,59.74 66.08,60.44 68.53,60.44 v1(69.38,61.29) ; PR924.2 v1(81.95,69)
  IN1 w0.508: v1(69.38,61.29) 69.73,60.93 78.71,60.93 81.32,63.53 81.32,68.36 v1(81.95,69)
  vias: v1(7.97,46.39) v1(7.97,45.75) v1(8.61,46.39) v1(8.61,45.75) v1(9.24,46.39) v1(9.24,45.75) v1(9.88,46.39) v1(9.88,45.75) v1(76.79,127.8) v1(76.79,127.21) v1(77.38,127.8) v1(77.38,127.21) v1(77.95,127.8) v1(77.95,127.21) v1(78.53,127.8) v1(78.53,127.21) v1(130.99,130.17) v1(131.25,129.66) v1(131.47,130.74) v1(131.57,130.15) v1(131.89,129.66) v1(132.2,130.15) v1(132.52,129.66) v1(132.84,130.15) v1(133.16,129.66) v1(133.47,130.72) v1(133.47,130.15) v3(9.61,44.14)
+EDP_VDD: length 0.9
  TOP w0.102: v2(87.04,110.33) 87.5,109.88 87.5,109.66
+LCDVDD: length 0.9
  TOP w0.102: 89.46,107.63 89.46,106.89 v3(89.35,106.79)
  vias: v1(91.87,108.21) v1(91.88,107.65) v1(92.49,107.73) v3(90.97,107.46) v3(92.5,108.31)
+LOM_VCT: length 36.7
  TOP w0.508: v1(164.75,139.84) v2(164.75,137.92) 164.75,135.58 163.61,134.44 v1(161.48,134.44)
  IN2 w0.508: v1(161.48,134.44) 161.48,130.7 162.33,129.85 162.33,127.1 163.66,125.77 163.66,124.49 165.15,123.01 175.94,123.01 176.6,123.67 v1(176.6,124.01)
  BOTTOM w0.254: JDOCK1.116 164.5,139.58 v1(164.75,139.84) 165,139.59 JDOCK1.118
  BOTTOM w0.508: v1(176.6,124.01) 176.6,124.65 C316.1
+MIC1_VREF_OUT: length 4.7
  TOP w0.203: DA4.2 v2(294.62,69.67) 294.36,69.93 292.68,69.93 292.58,69.84 UA1.30
  TOP w0.381: DA4.2 DA5.2
+NBDOCK_DC_IN_SS: length 284.2
  TOP w0.508: PD905.2 10.95,57.05 10.45,57.55 10.45,58.52 v3(11.66,59.72) v1(16.1,59.72) ; PR927.2 v1(91.16,75.66)
  IN2 w0.508: v1(68.36,70.71) 68.46,70.61 68.9,70.61 72.11,73.81 72.11,77.49 77.76,83.15 77.76,91.56 80.03,93.84 80.03,94.38 84.97,99.32 84.97,110.39 v1(84.64,110.73) ; v1(71.8,48.28) 71.8,47.67 68.59,44.46 66.18,44.46 64.49,42.77 64.49,41.79 63.16,40.46 56.3,40.46 55.02,39.18 40.58,39.18 40.04,39.72 40.04,42.9 38.76,44.18 16.24,44.18 v1(16.23,44.17)
  IN3 w0.508: v1(84.64,110.73) 84.64,115.82 85.28,116.45 85.8,116.45 86.84,117.5 88.47,117.5 89.85,118.88 115.79,118.88 119.03,122.13 119.03,124.84 120.07,125.88 133.76,125.88 135.72,127.83 143.33,127.83 143.95,128.45 v1(143.95,129.28) ; v1(71.8,48.28) 71.8,49.97 72.62,50.78 72.62,51.6 73.7,52.68 v1(76.74,52.68)
  IN4 w0.508: v1(83.73,75.22) 82.01,73.5 82.01,72.11 82.65,71.47 82.65,54.9 81.26,53.51 77.26,53.51 76.74,52.99 v1(76.74,52.68) ; v1(16.23,44.17) 17.35,45.28 17.35,52.55 16.1,53.79 v1(16.1,59.72) ; v1(68.36,70.71) 68.04,71.03 67.41,71.03 65.44,69.06 65.44,65.95 64.51,65.02 64.51,61.25 64.81,60.96 65.55,60.96 66.15,60.36 66.89,60.36 67.75,59.5 67.75,58.11 70.71,55.15 70.71,49.06 71.49,48.28 v1(71.8,48.28)
  BOTTOM w0.254: v1(143.95,129.28) 144,129.33 JDOCK1.41
  BOTTOM w0.508: v1(91.16,75.66) 91.16,75.41 90.52,74.77 84.17,74.77 v1(83.73,75.22)
+PBATT: length 64.1
  TOP w0.508: v1(64.42,53.63) 64.17,53.37 v3(63.71,53.37) 62.71,53.37 62.13,53.95 PD803.2 ; PR933.2 v1(81.95,71.15) ; v1(49.57,56.33) PR826.2
  IN1 w0.508: v1(75.52,50.91) 80.76,50.91 82.71,52.87 82.71,70.39 v1(81.95,71.15)
  IN4 w0.508: v1(49.57,56.33) 49.98,56.33 51.13,57.48 59.36,57.48 63.29,53.55 64.35,53.55 v1(64.42,53.63) 65.06,53.63 68.86,49.83 69.2,49.83 69.71,49.32 69.71,48.23 71.35,46.59 73.01,46.59 74.25,47.84 v1(74.25,49.64)
  vias: v1(17.24,43.6) v1(17.24,42.96) v1(17.88,43.6) v1(17.88,42.96) v1(18.51,43.6) v1(18.51,42.96) v1(19.15,43.6) v1(19.15,42.96) v1(19.78,43.6) v1(19.78,42.96) v1(20.42,43.6) v1(20.42,42.96) v1(73.62,50.91) v1(73.62,50.28) v1(73.62,49.64) v1(74.25,50.91) v1(74.25,50.28) v1(74.89,50.91) v1(74.89,50.28) v1(74.89,49.64) v1(75.52,50.28) v1(75.52,49.64)
+PECI_VREF: length 5.2
  TOP w0.305: CE25.1 v2(259.69,74.05) 259.69,73.15 259.37,72.83 259.37,71.33 259.08,71.04 UE2.B51
  TOP w0.508: CE25.1 RE59.1
+PWR_SRC: length 329.9
  TOP w4.064: 96.62,119.43 96.17,119.43 97.23,120.48 105.98,120.48 108.6,117.86 116.8,117.86 120.3,121.37 131.56,121.37 136.2,126.02 138.16,126.02 138.5,126.36 145.37,126.36 145.68,126.06 157.06,126.06 157.54,126.54 160.8,126.54 163.66,123.68 170.33,123.68 173.56,120.45 181.91,120.45 182.53,119.82 183.68,119.82 195.01,108.49 200.43,108.49 202.13,106.79 202.13,103.82
  IN1 w0.508: v1(259.79,83.41) 259.79,79.61 261.22,78.18 261.91,78.18 262.32,77.77 263.83,77.77 264.42,78.37 265.52,78.37 266.67,79.52 266.67,81.63 268.56,83.52 268.56,84.25 269.4,85.09 279.08,85.09 279.84,84.32 v1(281.81,84.32)
  IN2 w0.508: v1(281.81,84.32) 280.31,82.83 280.31,76.37 279.18,75.24 278.69,75.24 275.75,72.3 275.75,70.34 275.51,70.1 275.51,66.11 274.42,65.02 274.42,60.63 273.77,59.98 273.77,57.76 272.78,56.77 272.78,52.49 273.94,51.33 273.94,49.97 273.78,49.82 273.78,43.88 273.2,43.29 273.2,42.02 277.06,38.16 277.06,31.62 279.14,29.54 279.14,25.43 281.77,22.81 285.1,22.81 285.67,22.23 285.67,16.4 284.63,15.36 284.63,10.71 v1(283.58,9.67)
  IN2 w2.032: 85.75,112.89 84.22,114.41 78.61,114.41 76.71,112.51 73.37,112.51 71.19,110.33 66.39,110.33 64.73,112 64.73,119.69 63.22,121.2 63.22,123.59
  IN3 w0.508: v1(251.5,83.37) 251.8,83.37 252.68,84.25 259.34,84.25 259.79,83.8 v1(259.79,83.41)
  IN4 w0.508: v1(251.5,83.37) 251.12,82.99 250.03,82.99 248.98,81.95 246.72,81.95 246.12,81.35 245.35,81.35 244.1,80.11 243.37,79.38 240.9,79.38 240.7,79.18 232.05,79.18 231.62,78.75 228.08,78.75 227.72,78.39 v1(226.92,78.39)
  BOTTOM w0.508: RZ85.1 v1(283.58,9.67)
  BOTTOM w4.064: 230.9,91.69 234.55,88.03 234.55,81.86 231.9,79.21
  vias: v1(41.76,45.77) v1(42.35,46.39) v1(42.35,45.75) v1(42.35,45.12) v1(43.53,43.98) v1(44.17,43.98) v1(44.8,43.98) v1(45.44,43.98) v1(46.07,43.98) v1(46.96,46.14) v1(46.96,45.37) v1(46.96,44.61) v1(53.49,133.16) v1(53.49,132.51) v1(53.5,131.92) v1(54.2,133.16) v1(54.2,132.51) v1(54.2,131.92) v1(62.54,125.8) v1(62.54,125.17) v1(63.18,125.8) v1(63.18,125.17) v1(66.9,63.6) v1(66.9,63.03) v1(66.9,62.45) v1(86.97,111.6) v1(86.97,110.97) v1(87.6,111.6) v1(87.6,110.97) v1(92.77,99.23) v1(92.77,98.41) v1(92.77,97.58) v1(93.33,99.23) v1(93.33,98.41) v1(93.33,97.58) v1(94.97,116.34) v1(94.97,115.71) v1(95.6,116.34) v1(95.6,115.71) v1(96.23,116.35) v1(96.23,115.72) v1(96.81,116.33) v1(96.81,115.69) v1(200.92,101.05) v1(200.92,100.41) v1(201.56,101.05) v1(201.56,100.41) v1(202.19,101.05) v1(202.19,100.41) v1(202.85,101.09) v1(202.85,100.45) v1(225.65,78.39) v1(226.29,78.39) v1(228.34,94.59) v1(228.34,93.95) v1(228.98,94.59) v1(228.98,93.95) v1(229.61,94.59) v1(229.61,93.95) v1(230.27,94.62) v1(230.27,93.99) v3(44.56,45.69)
+PWR_SRC_AC: length 44.5
  TOP w0.508: PR939.2 v1(94.08,69.88)
  IN3 w0.508: v1(64.7,55.67) 65.1,55.67 65.75,55.03 70.2,55.03 71.26,56.08 84.27,56.08 86.14,57.96 87.04,57.96 90.73,61.64 90.73,62.7 89.32,64.11 89.32,65.44 91.35,67.47 91.35,70.65 92.31,71.61 93.24,71.61 94.08,70.77 v1(94.08,69.88)
  vias: v1(7.97,48.55) v1(7.97,47.91) v1(8.61,48.55) v1(8.61,47.91) v1(9.24,48.55) v1(9.24,47.91) v1(9.88,48.55) v1(9.88,47.91) v1(63.22,54.52) v1(63.6,55.03) v1(63.73,54.14) v1(63.92,55.53) v1(64.11,54.64) v1(64.23,56.04) v1(64.42,55.15) v2(8.48,49.82)
+PWR_SRC_R: length 1.2
  TOP w0.102: v3(284.13,8.28) 284.4,8.54 v1(284.4,9.39)
+REGCTL_PNP10:
  vias: v2(264.89,93.93)
+RREF: length 3.1
  TOP w0.102: v2(264.23,77.05) 264.59,77.4 RR20.1
  TOP w0.305: 266.55,78.01 RR20.1
+RSVD_VCC3P3_1: length 4.1
  TOP w0.203: UL1.1 263.66,91.69 264.25,91.11 264.25,90.14 v2(264.44,89.95) 265.34,89.05 RL6.2
+RTC_CELL: length 265
  TOP w0.508: 243.46,73.77 243.46,73.24 244.24,72.45 244.24,71.22 243.46,70.43 243.46,64.11 244.8,62.77 244.8,60.03 245.79,59.04 245.79,56.54 245.29,56.04 v1(245.29,55.29) ; RC69.2 181.61,72.21 181.61,71.99 181.94,71.66 v1(182.34,71.66) ; 169.44,70.84 CC270.1 169.53,71.57 RC56.2 RC57.2 ; 169.44,70.84 169.44,70.76 168.78,70.1 v1(167.51,70.1) ; 169.44,70.84 169.82,70.46 172.3,70.46 173.24,69.52 v1(173.24,69.46) ; RE32.1 242.94,82.63 243.3,82.99 244.98,82.99 v1(245.44,82.54) ; v1(242.3,80.02) 242.3,79.78 242.42,79.66 RE31.1 241.5,79.36 240.9,78.76 240.9,77.08 242.07,75.92 RE62.1 242.34,75.71 242.83,75.22 243.29,75.22 243.63,74.88 243.63,74.51 ; RA21.1 v1(301.16,73.69)
  IN1 w0.508: v1(274.55,49.51) 274.14,49.11 274.14,47.23 275.88,45.49 275.88,24.57 276.87,23.58 279.11,23.58 283.22,19.47 v1(283.22,18.78)
  IN2 w0.508: v1(166.07,80.03) 166.07,78.29 168.46,75.9 168.46,71.05 167.51,70.1 v1(167.51,70.1) ; v1(274.55,49.51) 274.55,53.79 273.97,54.36 273.97,56.5 274.93,57.45 274.93,59.75 276.39,61.21 276.39,63.36 277.29,64.26 277.29,72.97 278.95,74.63 279.44,74.63 280.92,76.11 280.92,78.34 281.85,79.27 299.13,79.27 301.16,77.24 v1(301.16,73.69) ; v1(182.34,71.66) 182.34,70.94 181.63,70.23 173.95,70.23 173.24,69.52 v1(173.24,69.46)
  IN3 w0.508: v1(242.3,80.02) 241.61,79.33 241.61,77.92 240.23,76.54 234.13,76.54 233.18,75.59 230.76,75.59 230.5,75.32 227.64,75.32 226.86,74.53 v1(226.86,74.29) ; v1(274.55,49.51) 272.81,49.51 270.39,51.93 269.96,51.93 269.59,52.29 247.49,52.29 245.29,54.5 v1(245.29,55.29)
  IN4 w0.508: v1(245.44,82.54) 244.37,81.47 243.49,81.47 242.3,80.27 v1(242.3,80.02)
  BOTTOM w0.178: v1(166.07,80.03) 166.09,80.05 UC1.BB14
  BOTTOM w0.254: UC1.AK19 v1(162.72,87.18)
  BOTTOM w0.508: v1(283.22,18.78) 283.68,18.78 284.03,18.42 PC2.1 284.03,16.2 PD1.1 ; v1(182.34,71.66) 182.34,70.85 182.85,70.34 205.19,70.34 207.66,72.81 213.71,72.81 214.36,73.45 221.33,73.45 221.78,73.9 226.47,73.9 v1(226.86,74.29)
  vias: v3(162.99,81.75)
+RTC_CELL_VBAT: length 26.7
  TOP w0.305: UE2.B64 v1(252.37,70.98)
  TOP w0.356: v1(252.38,74.09) 252.38,74.46 CE11.1
  TOP w0.508: RE32.2 242.94,81.17 242.4,80.64 241.91,80.64 v2(241.58,80.32) 240.29,79.03 240.29,76.75 242.72,74.33 v1(242.92,74.33)
  IN3 w0.508: v1(242.92,74.33) 243.23,74.02 245.76,74.02 246.12,74.38 250.1,74.38 250.86,73.62 250.86,73.13 252.37,71.62 v1(252.37,70.98)
  BOTTOM w0.508: v1(252.38,74.09) 251.61,73.31 251.61,72.07 252.19,71.48 252.19,71.16 v1(252.37,70.98)
+SDC_IN: length 105.3
  TOP w0.102: v3(13.98,54.81) 13.31,54.14 v1(13.05,54.14)
  TOP w0.203: PU801.3 57.1,55.06 v1(57.31,55.28)
  TOP w0.508: PR928.1 90.27,62.19 v1(90.14,62.06)
  IN1 w0.508: v1(57.31,55.28) 57.31,55.47 55.12,57.67 49.18,57.67 48.05,56.54 47.46,56.54 47.11,56.19 39.11,56.19 38.63,55.71 33.89,55.71 33.05,56.55 25.37,56.55 24.67,55.85 14.77,55.85 v1(13.05,54.14)
  IN4 w0.508: v1(57.31,55.28) 60.7,55.28 64.11,51.88 64.11,48.17 65.69,46.58 68.55,46.58 69.58,45.55 74.26,45.55 77.42,48.71 79.04,48.71 80.26,49.93 85.47,49.93 87.73,52.19 87.73,57.5 90.14,59.91 v1(90.14,62.06)
  BOTTOM w0.508: v1(57.31,55.28) 57.53,55.28 59.12,56.87 59.12,57.73 58.76,58.09 PR812.2
+SDREG2: length 3
  TOP w0.102: CR35.1 271.27,84.16 271.73,83.7 v2(271.93,83.7)
  TOP w0.508: CR35.1 270.86,82.46
+SIM_PWR: length 47.5
  TOP w0.102: v1(284.22,122.73) v3(284.22,122.07)
  IN2 w0.102: v1(284.22,122.73) 283.88,122.38 283.88,117.13 281.36,114.61 271.85,114.61 270.05,112.81 270.05,110.63 270.6,110.08 270.6,108.15 269.61,107.16 269.61,104.86 270.6,103.87 v1(270.6,97.35)
  BOTTOM w0.102: v1(284.22,122.73) 284.53,122.42 C263.1 285,121.48 289.54,121.48 JSIM1.1 ; v1(270.6,97.35) JNGFF2.28
+USB_LEFT_PWR: length 4.7
  BOTTOM w0.127: v1(73.33,126.15) 74.22,126.15 v3(74.66,125.7) ; v1(73.33,126.15) v3(73.33,124.43) ; v1(73.33,126.15) 72.39,126.15 v3(72.01,125.76)
  vias: v1(58.54,132.34) v1(58.61,132.94) v1(58.96,131.75) v1(59.17,132.95) v1(59.17,132.36)
+USB_REAR_PWR:
  vias: v3(78.75,124.72) v3(79.09,126.46) v3(80.66,124.81)
+UZ12_TPM: length 4.3
  TOP w0.254: CZ73.1 220.58,72.02 v2(219.72,72.02) UZ12.8
  TOP w0.356: CZ73.1 RZ89.2 RZ88.2
+V_DDR_REF: length 2.7
  TOP w0.102: v1(73.38,76.76) v3(72.81,76.76)
  TOP w0.254: PC210.1 73.79,76.76 v1(73.38,76.76)
  BOTTOM w0.203: v1(73.38,76.76) 73.54,76.61 PU201.4
+VCHGR: length 1.5
  TOP w0.102: PC826.1 v2(29.11,46.81)
  vias: v1(30.64,46.01) v1(31.47,46.01) v1(32.36,46.01)
+VDISPLAY_VCC:
  vias: v2(218.62,127.25)
+VHDMI_VCC: length 3.8
  BOTTOM w0.102: UV2.3 244.36,127.38 v2(244.36,125.55)
+VLDOIN_1.2V: length 2.1
  BOTTOM w0.102: PJP203.1 73.7,72.31 v2(72.96,71.57)
+VR_CAP: length 6
  TOP w0.102: v2(247.62,65.38) 247.05,64.8 v1(247.01,64.8)
  TOP w0.305: UE2.B12 v1(250.42,65.54)
  TOP w0.508: CE31.1 v1(247.01,64.8)
  IN1 w0.508: v1(250.42,65.54) 249.31,65.54 248.47,64.7 247.11,64.7 v1(247.01,64.8)
+VREFOUT: length 6.2
  TOP w0.102: v2(295.67,65.3) 295.41,65.3 295.12,65.01 RA5.2
  TOP w0.203: 291.46,66.01 290.86,66.61 UA1.23
  TOP w0.508: 291.46,66.01 291.46,65.54 291.82,65.18 CA26.1 292.86,65.01 RA6.2 294.68,65.01 RA5.2
+Z4012: length 3.5
  BOTTOM w0.127: PD1.2 284.3,15.46 v2(284.48,15.29)
  BOTTOM w0.508: PR2.2 281.97,15.34 PD1.2
-DCIN_JACK:
  vias: v1(67.6,102.46) v1(67.79,101.89) v1(67.98,101.32) v1(68.17,102.65) v1(68.17,100.75) v1(68.36,102.08) v1(68.43,100.17) v1(68.55,101.51) v1(68.74,100.94) v1(69,100.36) v3(70.5,105.61)
/BATPRES: length 22.7
  TOP w0.203: PR828.2 51.4,57.65 51.4,56.87 51.61,56.66 PU801.15
  TOP w0.254: PR828.2 50.77,59.27 v2(50.77,59.72) 50.77,60.01 55.75,64.99 64.43,64.99 65.58,66.15 PR904.2
A_ON: length 123.1
  TOP w0.102: v1(247.65,68.79) 248.15,69.29 UE2.A4 ; v1(262.04,61.34) 262.96,61.34 263.43,61.81 263.43,62.24 263.24,62.43 RPE10.3 ; UZ8.3 199.04,78.92 199.29,78.67 199.29,78.24 v2(198.82,77.77) 197.15,77.77 v1(196.73,77.36)
  IN1 w0.102: v1(247.65,68.79) 248.05,69.19 248.6,69.19 249.79,67.99 251.23,67.99 252.72,69.49 256.58,69.49 257.06,69.96 260.06,69.96 260.41,69.62 263.27,69.62 v1(264.14,68.74)
  IN2 w0.102: v1(208.29,70.27) 207.91,70.65 206.56,70.65 205.95,71.26 193.44,71.26 193.04,71.66 193.04,72.36 193.45,72.77 194.03,72.77 195.87,74.62 195.87,76.5 v1(196.73,77.36)
  IN3 w0.102: v1(208.29,70.27) 208.46,70.09 208.46,68.42 209.68,67.2 213.95,67.2 215.59,65.57 217.31,65.57 218,64.88 221.92,64.88 224.7,62.1 231.17,62.1 232.26,61 232.26,60.44 232.96,59.74 236.11,59.74 236.72,59.14 237.68,59.14 237.81,59.27 238.97,59.27 240.71,57.53 242.35,57.53 242.65,57.23 245.51,57.23 245.91,57.64 248.4,57.64 249.73,56.31 251.1,56.31 251.8,55.61 255.47,55.61 256.41,56.55 257.24,56.55 257.85,57.16 257.85,57.53 258.84,58.52 260.09,58.52 262.04,60.46 v1(262.04,61.34)
  IN4 w0.102: v1(264.14,68.74) 264.14,68.53 263.7,68.08 263.7,67.43 263.85,67.28 263.85,64.05 262.04,62.24 v1(262.04,61.34)
AC_DIS: length 271.5
  TOP w0.102: UE1.A50 229.92,61.08 v1(229.49,60.65)
  TOP w0.254: PR837.1 PR916.1 v1(92.05,73.5) ; v1(73.33,96.88) 74.1,96.11 v2(76.98,96.11) 78.5,96.11 78.94,96.55 78.94,98.69 79.22,98.97 PQ1.5
  IN2 w0.102: v1(225.4,65.72) 224.88,65.2 224.88,62.49 215.76,53.37 86.71,53.37 84.47,51.13 v1(84,51.13) ; v1(229.38,62.98) 229.38,60.75 v1(229.49,60.65)
  IN4 w0.102: v1(225.4,65.72) 225.41,65.72 228.16,62.98 v1(229.38,62.98)
  IN4 w0.254: v1(92.05,73.5) 92.05,65.73 89.66,63.35 89.66,60.11 87.25,57.7 87.25,53.91 84.47,51.13 v1(84,51.13) 83.46,50.59 77.72,50.59 76.87,51.44 73.32,51.44 72.67,50.78 72.67,48.01 72.37,47.72 70.9,47.72 70.19,48.43 70.19,49.52 69.4,50.31 69.06,50.31 65.44,53.93 65.44,55.76 v1(63.36,57.84)
  BOTTOM w0.254: v1(63.36,57.84) 64.26,57.84 64.84,58.43 64.84,59.7 PQ809.2 63.44,60.37 63.12,60.7 62.9,60.7 62.56,61.04 62.56,71.23 74.01,82.69 74.01,96.2 v1(73.33,96.88)
AC_PRESENT: length 112.8
  TOP w0.102: v1(255.98,74) 255.98,73.76 255.57,73.36 255.57,72.92 255.62,72.87 UE2.A54 ; RC243.1 185.68,68.96 v2(186.45,68.96) 186.95,68.45 v1(186.95,67.91)
  IN3 w0.102: v1(227.23,73.26) 227.7,73.73 228.91,73.73 229.25,74.06 229.25,74.54 229.41,74.71 230.75,74.71 231.02,74.98 235.2,74.98 235.93,75.7 246.75,75.7 247.97,76.92 249.48,76.92 251.33,75.07 254.91,75.07 v1(255.98,74)
  BOTTOM w0.076: 166.61,77.29 166.43,77.29 165.91,77.8 165.91,78.36 165.09,79.18 165.09,81.04 165.2,81.15 165.2,81.43 165.37,81.71 UC1.AY15
  BOTTOM w0.102: 166.61,77.29 168.44,75.46 168.44,72.68 169.17,71.95 169.17,69.23 169.64,68.76 177.2,68.76 177.43,69 185.86,69 186.95,67.91 v1(186.95,67.91) 186.95,67.88 186.98,67.86 186.98,67.65 187.64,66.99 208.01,66.99 210.53,69.52 211.76,69.52 212.49,70.25 212.49,70.98 213.98,72.46 221.14,72.46 221.32,72.64 222.41,72.64 222.71,72.94 226.9,72.94 v1(227.23,73.26)
ACAV_DOCK_SRC#: length 173.9
  TOP w0.102: v2(68.22,70.07) 67.97,69.82 v1(67.79,69.82)
  TOP w0.254: v1(89.2,62.4) PR920.2 PR923.1
  IN2 w0.102: v1(67.79,69.82) 66.8,70.81 66.8,72.16 69.02,74.38 69.02,76.62 76.13,83.73 76.13,94.27 78.18,96.32 79.17,96.32 82.48,99.63 82.48,107.76 v1(83.02,108.29)
  IN3 w0.102: v1(83.02,108.29) 82.42,108.89 82.42,114.81 84.47,116.86 85.63,116.86 86.68,117.9 88.3,117.9 89.68,119.29 115.62,119.29 118.63,122.3 118.63,125.01 119.91,126.28 133.59,126.28 135.55,128.24 139.85,128.24 143.46,131.85 143.46,139.75 v1(144.04,140.34) ; v1(89.2,62.4) 89.2,60.69 86.88,58.36 85.98,58.36 84.1,56.49 v1(70.58,56.49)
  IN4 w0.102: v1(67.79,69.82) 67.28,69.82 66.39,68.93 66.39,64.66 66.1,64.36 66.1,61.41 66.52,60.99 67.12,60.99 68.37,59.74 68.37,58.7 v1(70.58,56.49)
  BOTTOM w0.102: v1(144.04,140.34) 144,140.29 JDOCK1.42
ACAV_IN: length 249.1
  TOP w0.102: v1(250.26,73.22) 250.26,73.15 250.62,72.79 UE2.A64
  TOP w0.254: PR815.1 58.78,58.92 v1(59.11,58.92) ; PR918.1 v1(91.41,62.45) ; PQ907.5 v1(101.78,73.19)
  IN1 w0.102: v1(59.11,58.92) 59.41,58.62 59.41,53.35 62.91,49.86 v1(64.97,49.86)
  IN2 w0.102: v1(233.56,74.38) 233.56,74.63 232.62,75.57 226.36,75.57 220.21,69.43 220.21,66.78 210.27,56.84 90.29,56.84 v1(90.08,57.06) 89.42,57.72 85.29,57.72 81.48,53.91 78.5,53.91 78.05,53.46 75.91,53.46 75.63,53.18 70.4,53.18 67.22,50.01 65.12,50.01 v1(64.97,49.86)
  IN4 w0.102: v1(233.56,74.38) 233.99,73.95 234.25,73.95 235.62,72.58 237.5,72.58 237.93,73.01 243.58,73.01 244.01,72.58 245.85,72.58 246.48,73.2 247.23,73.2 247.77,72.66 248.51,72.66 248.68,72.82 249.86,72.82 v1(250.26,73.22) ; v1(90.08,57.06) 90.08,58.17 91.41,59.51 v1(91.41,62.45) 91.41,62.49 101.78,72.85 v1(101.78,73.19)
  BOTTOM w0.254: PQ809.1 59.92,59.72 v1(59.11,58.92) 58.7,59.33 58.43,59.33 58.27,59.5 57.3,59.5 57.2,59.6 54.28,59.6 53.76,59.08 PR801.2 PR817.1
ACAV_IN#: length 9.1
  TOP w0.102: v1(101.85,70.27) v2(101.85,68.41)
  TOP w0.254: PQ907.3 104.05,73.84 PR914.2 v1(104.81,73.77) ; PU903.2 v1(101.85,70.27)
  IN1 w0.254: v1(101.85,70.27) 101.85,70.81 v1(104.81,73.77)
ACAV_IN_NB: length 231.7
  TOP w0.102: v1(251.24,63.08) 251.37,62.94 UE2.B20
  TOP w0.254: v1(64.97,60.35) 64.31,60.35 63.98,60.68 v2(63.98,61.15) 62.8,62.33 61.07,62.33 PR833.1 ; PR922.2 v1(87.6,75.73)
  IN1 w0.102: v1(86.07,54.95) 87.14,56.03 87.14,56.71 86.08,57.77 v1(86.08,58.95)
  IN1 w0.254: v1(87.6,75.73) 86.08,74.2 v1(86.08,58.95)
  IN2 w0.102: v1(225.38,66.84) 224.82,67.4 223.55,67.4 223.03,66.88 223.03,62.37 215.26,54.59 86.42,54.59 v1(86.07,54.95)
  IN3 w0.254: v1(64.97,60.35) 65.22,60.35 66.98,58.59 69.67,58.59 71.3,56.97 83.9,56.97 85.88,58.95 v1(86.08,58.95)
  IN4 w0.102: v1(225.38,66.84) 224.8,66.25 224.8,65.48 225.15,65.12 225.44,65.12 226.07,64.49 226.07,63.89 228.28,61.68 238.65,61.68 238.85,61.47 244.92,61.47 246.5,59.89 247.11,59.89 249.79,62.57 250.74,62.57 v1(251.24,63.08)
ACAVDK_SRC: length 4.8
  TOP w0.102: v2(87.88,61.63) 87.88,63.55 88.29,63.95 PR923.2
  TOP w0.254: PU901.4 88.19,64.98 88.29,64.88 PR923.2
ACAVIN: length 3.3
  TOP w0.254: PR918.2 91.67,64.25 91.67,64.79 v2(91.55,64.91) 91.44,65.02 90.88,65.02 90.19,65.71 PU901.8
ADJ:
  vias: v2(221.42,104.19)
ALW_PWRGD_3V_5V: length 74.4
  TOP w0.102: UZ6.2 266.74,70.39 v1(266.79,70.44)
  TOP w0.254: v1(222.55,74.93) 222.55,76.55 219.64,79.46 218.07,79.46 217.05,78.44 209.52,78.44 v3(209.34,78.27) PR119.2 PR120.2 205.06,78.27 PR101.2
  IN3 w0.102: v1(266.79,70.44) 265.08,72.14 264.78,72.14 262.8,74.13 261.31,74.13 261.13,73.95 260.39,73.95 259.98,74.36 259.98,74.57 259.28,75.27 251.56,75.27 249.7,77.12 247.89,77.12 246.67,75.9 235.84,75.9 235.12,75.18 230.93,75.18 230.67,74.91 228.87,74.91 228.43,74.47 228.43,74.13 228.24,73.94 227.36,73.94 226.79,73.37 226.79,72.64 225.82,71.66 223.86,71.66 223.5,72.02 223.5,73.97 v1(222.55,74.93)
ALWON: length 59.1
  TOP w0.102: v1(252.62,73.19) UE2.A60
  IN3 w0.102: v1(206.13,75.74) 206.55,75.32 209.36,75.32 209.54,75.14 218.28,75.14 219.7,73.72 222.39,73.72 223.1,73.01 223.1,71.85 223.7,71.24 226.23,71.24 228.19,73.2 229.3,73.2 230.21,74.11 230.74,74.11 231.11,73.74 234.55,73.74 236.29,75.48 246.82,75.48 247.76,76.42 248.18,76.42 249.41,75.19 250.47,75.19 252.47,73.19 v1(252.62,73.19)
  BOTTOM w0.254: v1(206.13,75.74) 206.22,75.83 206.22,79.57 205.18,80.61 PR114.1
AUD_HP_NB_SENSE: length 108.9
  TOP w0.254: JHP1.6 295.75,42.21 295.04,41.5 291.41,41.5 v2(290.19,42.72) DA2.3 287.25,43.75 284.83,43.75 RA2.1 v1(283.73,43.42) ; UE1.A41 v1(227.02,66.73) ; QA1.2 281.57,61.24 CA41.1 279.89,61.12 v1(278.14,62.87)
  IN1 w0.254: v1(278.14,62.87) 277.66,63.36 277.66,70.46 277.4,70.71 v1(276.58,70.71) ; v1(266.55,68.23) 266.5,68.28 265.81,68.28 264.64,67.12 263.4,67.12 262.5,68.02 260.6,68.02 260.41,68.21 252.59,68.21 251.41,67.03 249.73,67.03 248.43,68.32 238.55,68.32 237.93,68.94 236.61,68.94 235.81,68.14 231.43,68.14 230.26,66.98 227.27,66.98 v1(227.02,66.73)
  IN3 w0.254: v1(276.58,70.71) 274.23,70.71 272.96,69.44 272.77,69.44 271.24,67.92 268.27,67.92 268.02,68.17 266.61,68.17 v1(266.55,68.23)
  IN4 w0.254: v1(283.73,43.42) 282.32,43.42 274.66,51.08 274.66,52.4 277.06,54.8 277.06,57.95 278.57,59.46 278.57,62.44 v1(278.14,62.87)
AUD_HP_OUT_L: length 29.1
  TOP w0.102: v1(282.81,53.41) v2(282.42,53.81)
  TOP w0.381: LA2.1 282.98,53.25 v1(282.81,53.41) ; RA7.2 295.07,71.9 v1(295.5,71.47) ; CA43.2 290.36,62.66 290.36,62.21 RA24.1 290.61,61.96 290.61,61.55 v1(290.84,61.32)
  IN2 w0.381: v1(290.84,61.32) 290.84,61.36 290.88,61.39 290.88,63.21 294.87,67.2 294.87,71.12 295.22,71.47 v1(295.5,71.47)
  IN4 w0.381: v1(282.81,53.41) 285.72,56.32 287.98,56.32 290.88,59.22 290.88,61.29 v1(290.84,61.32)
AUD_HP_OUT_L1: length 6
  TOP w0.381: DA3.3 289.05,53.64 v2(290.54,53.64) 292.71,53.64 293,53.35 JHP1.1
AUD_HP_OUT_R: length 37.1
  TOP w0.102: v2(282.66,44.41) 282.66,44.85 v1(282.93,45.12)
  TOP w0.381: v1(291.51,61.39) 291.51,61.92 RA25.1 291.21,62.22 CA44.2 ; RA8.2 295.02,70.84 v1(295.5,70.84) ; LA3.1 v1(282.93,45.12)
  IN2 w0.381: v1(291.51,61.39) 291.51,62.95 295.5,66.94 v1(295.5,70.84)
  IN4 w0.381: v1(291.51,61.39) 291.51,58.95 288.25,55.69 286.19,55.69 283.25,52.75 282.62,52.75 282.18,52.31 282.18,45.87 v1(282.93,45.12)
AUD_HP_OUT_R1: length 18.8
  TOP w0.102: v1(289.42,44.66) v2(290.18,44.66)
  TOP w0.381: CA2.1 284.32,46.05 LA3.2 284.96,45.12 285.42,44.66 DA1.2 v1(289.42,44.66)
  IN4 w0.381: JHP1.2 298.5,42.25 298.21,41.96 291.09,41.96 289.42,43.63 v1(289.42,44.66)
AUD_NB_MUTE#: length 94.9
  TOP w0.102: v1(282.12,77.16) 283.78,77.16 284.39,76.55 CA31.1 284.4,76.09 RA18.2 285.36,74.96 285.99,74.33 286.21,74.33 286.86,73.68 UA1.48 ; UE1.A39 v1(227.01,67.73)
  TOP w0.254: v1(296.1,74.83) 296.65,74.83 297.97,73.51 QA2.2
  IN2 w0.102: v1(282.12,77.16) 283.66,78.71 292.02,78.71 295.9,74.83 v1(296.1,74.83)
  IN3 w0.102: v1(282.12,77.16) 282.5,77.16 282.67,76.98 282.67,74.98 279.88,72.19 279.88,67.95 277.99,66.06 264.2,66.06 263.09,67.17 261.01,67.17 260.89,67.28 259.57,67.28 258.7,68.16 256.68,68.16 256.45,67.92 252.16,67.92 251.16,68.92 249.19,68.92 248.71,69.4 243.75,69.4 242.82,68.47 239.46,68.47 238.56,69.38 236.51,69.38 235.2,68.06 227.34,68.06 v1(227.01,67.73)
AUD_OUT_L: length 2.2
  TOP w0.203: UA1.33 292.89,71.04 293.76,71.9 RA7.1
AUD_OUT_R: length 2
  TOP w0.203: UA1.32 292.84,70.64 292.9,70.7 293.62,70.7 293.93,71.01 RA8.1
AUD_PC_BEEP: length 4.2
  TOP w0.203: UA1.12 286.01,66.46
  TOP w0.254: 286.01,66.46 286.01,66.37 v2(285.5,65.86) 285.18,65.54 CA27.2 CA28.2
AUD_PWR_EN: length 140
  TOP w0.102: 274.04,68.47 274.04,63.98 271.47,61.41 v1(271.47,60.74) ; 274.04,68.47 274.04,69.03 274.27,69.27 UZ5.3 ; 274.04,68.47 UZ5.5 ; RC279.2 v2(188.54,77.76) 188.19,77.76 v1(187.7,77.28)
  IN2 w0.102: v1(174.89,78.77) 175.27,78.39 177.25,78.39 178.48,79.62 180.83,79.62 182.11,78.35 186.63,78.35 v1(187.7,77.28) 187.7,76.72 187.3,76.31 187.3,71.6 192.5,66.39 v1(213.66,66.39)
  IN3 w0.102: v1(213.66,66.39) 214.19,66.39 215.42,65.16 217.14,65.16 217.83,64.47 219.22,64.47 219.79,63.9 222.32,63.9 224.53,61.69 229.33,61.69 230.04,60.99 230.04,59.98 231.71,58.3 237.41,58.3 237.98,58.86 238.8,58.86 240.54,57.12 242.19,57.12 242.48,56.83 245.79,56.83 246.2,57.23 248.23,57.23 249.6,55.86 250.89,55.86 251.55,55.2 255.64,55.2 256.58,56.14 258.27,56.14 258.75,55.66 261.81,55.66 262.47,56.32 262.47,60.12 263.15,60.8 264.21,60.8 265.22,59.79 268.78,59.79 269.27,59.3 270.92,59.3 271.47,59.86 v1(271.47,60.74)
  BOTTOM w0.076: v1(174.89,78.77) 174.88,78.77 171.73,78.77 170.1,80.4 170.1,80.97 UC1.BA7
AUD_SENSE_A: length 12.1
  TOP w0.203: QA1.1 282.81,64.16 283.43,63.54 283.43,61.53 283.89,61.07 v2(284.86,61.07) 285.35,61.07 285.66,61.38 285.66,65.34 286.86,66.54 UA1.13
AUD_SENSE_B: length 36.4
  TOP w0.203: UA1.14 287.26,66.29 286.12,65.15 286.12,61.34 v1(286.28,61.18)
  TOP w0.254: RA28.1 275.1,52.14 v1(275.42,51.82) ; v1(286.28,61.18) 285.53,60.42 v2(283.42,60.42) 281.34,60.42 279.83,58.91 RA27.1 279.83,55.22 280.07,54.98 RA38.1
  IN4 w0.254: v1(275.42,51.82) 275.42,52.44 277.57,54.59 277.57,57.74 280.51,60.68 285.78,60.68 v1(286.28,61.18)
AUX_EN_WOWL: length 28.2
  TOP w0.102: v1(236.53,63.48) 236.67,63.35 UE1.B67 ; v1(237.27,59.98) 237.27,59.86 RZ38.2 238.22,58.92 238.22,58.12 239.05,57.29 239.82,57.29 v2(240.12,56.99) 240.12,54.47 240.85,53.74 240.85,51.85 241.54,51.16 241.54,49.06 v1(242.5,48.09)
  BOTTOM w0.102: v1(242.5,48.09) 241.75,47.34 241.75,43.98 243.06,42.67 RZ70.1 ; v1(237.27,59.98) 236.83,59.98 236.45,60.36 236.45,63.39 v1(236.53,63.48)
BAT1_LED#: length 80.4
  TOP w0.254: v1(249.29,71.4) 249.29,71.23 249.48,71.04 UE2.B1 ; RZ28.1 v1(284.79,17.69)
  BOTTOM w0.254: v1(249.29,71.4) 249.62,71.07 249.62,69.64 250.2,69.06 251.13,69.06 251.86,68.32 251.86,65.07 252.43,64.51 255.54,64.51 255.94,64.11 255.94,62.83 256.72,62.06 257.99,62.06 260.23,59.81 261.72,59.81 262.04,59.5 262.04,58.61 263.91,56.74 265.12,56.74 265.69,56.17 266.27,56.17 269.13,53.31 269.13,52.73 270.29,51.57 270.29,51.33 275.66,45.96 275.66,25.11 276.66,24.11 285.08,24.11 285.66,23.53 v2(285.66,19.24) 285.66,18.55 v1(284.79,17.69)
BAT2_LED#: length 79.7
  TOP w0.254: UE2.A55 255.12,72.74 255.29,72.91 255.29,73.49 v1(255.22,73.57) ; RZ25.1 v1(284.78,16.67)
  BOTTOM w0.254: v1(255.22,73.57) 255.29,73.49 255.29,72.87 255.04,72.61 255.04,71.52 254.86,71.34 254.86,69.26 255.55,68.58 255.55,65.22 256.89,63.88 256.89,62.77 257.25,62.41 258.96,62.41 261.21,60.17 261.87,60.17 262.39,59.64 262.39,58.76 264.06,57.1 265.27,57.1 265.82,56.55 266.39,56.55 269.48,53.46 269.48,52.88 270.71,51.65 270.71,51.41 276.02,46.11 276.02,25.26 276.8,24.47 285.23,24.47 286.06,23.63 v2(286.06,22.14) 286.06,17.95 v1(284.78,16.67)
BATDRV#: length 30.3
  TOP w0.508: PR825.2 v1(49.74,54.58)
  IN4 w0.508: v1(49.74,54.58) 49.74,53.87 47.85,51.98 45.12,51.98 44.84,52.26 42.92,52.26 41.41,50.74 38.23,50.74 29.18,41.69 v1(29.18,40.15)
  BOTTOM w0.508: PQ903.4 28.87,39.39 29.18,39.71 v1(29.18,40.15)
BATT_WHITE#: length 4.6
  TOP w0.102: v2(287.11,15.64) 287.11,16.47 v1(286.9,16.67)
  TOP w0.254: RZ25.2 v1(286.9,16.67)
  BOTTOM w0.254: JLED1.5 287.78,17.55 v1(286.9,16.67)
BATT_YELLOW#: length 4.1
  TOP w0.102: v1(286.9,17.69) 287.02,17.69 v2(287.49,18.16)
  TOP w0.254: RZ28.2 v1(286.9,17.69)
  BOTTOM w0.254: JLED1.4 287.57,18.35 v1(286.9,17.69)
BC_CLK_ECE1117: length 86.2
  TOP w0.102: UE2.A20 252.12,60.87 v1(251.64,60.38)
  BOTTOM w0.102: JKBTP1.10 277.2,8.27 275.19,10.29 275.19,18.43 277.28,20.52 277.28,22.46 274.95,24.79 274.95,40.84 271.37,44.43 271.37,47.3 271.47,47.41 271.47,48.29 270.65,49.12 268.42,49.12 264.42,53.12 264.42,55.54 261.32,58.64 256.83,58.64 255.08,56.89 255.08,55.88 254.85,55.65 253.68,55.65 252.33,56.99 250.39,56.99 249.93,57.45 249.93,58.1 250.06,58.23 250.06,59.95 249.7,60.31 249.7,61.32 250.23,61.85 251.68,61.85 252.12,61.41 252.12,60.87 v1(251.64,60.38)
BC_CLK_ECE5048: length 41.3
  TOP w0.102: UE2.A43 260.25,68.29 v1(260.62,68.66) ; v1(230.35,73.14) 230.42,73.07 UE1.A30
  IN4 w0.084: v1(230.35,73.14) 229.66,73.14 229.49,72.97 229.49,71.57 229.72,71.34 230.6,71.34 231.38,72.12 232.86,72.12 233.35,71.63 237.07,71.63 237.33,71.37 238.97,71.37 239.23,71.63 242.13,71.63 243.14,70.62 245.58,70.62 246.53,71.57 248.56,71.57 249.01,72.02 257.09,72.02 257.36,71.75 259.17,71.75 259.64,72.22 260.39,72.22 260.77,71.83 260.77,71.05 260.21,70.49 260.21,68.8 260.35,68.66 v1(260.62,68.66)
BC_DAT_ECE1117: length 103.8
  TOP w0.102: RPE5.2 246.65,73.57 v1(246.87,73.8) 247.25,73.41 v2(247.56,73.41) ; UE2.B21 v1(251.87,63.08)
  BOTTOM w0.102: v1(246.87,73.8) 244.96,71.88 244.96,70.52 245.6,69.87 245.6,65.54 246.72,64.42 248.36,64.42 248.99,63.79 251.16,63.79 v1(251.87,63.08) 251.87,62.46 251.49,62.08 250.13,62.08 249.48,61.42 249.48,60.21 249.83,59.86 249.83,58.32 249.7,58.19 249.7,57.36 250.3,56.76 252.24,56.76 253.59,55.42 254.94,55.42 255.31,55.78 255.31,56.8 256.92,58.42 261.23,58.42 264.2,55.45 264.2,53.03 268.33,48.89 270.55,48.89 271.24,48.2 271.24,47.5 271.14,47.4 271.14,44.33 274.72,40.75 274.72,24.69 277.05,22.37 277.05,20.62 274.96,18.53 274.96,10.19 277.11,8.05 278.04,8.05 278.81,7.27 JKBTP1.8
BC_DAT_ECE5048: length 47.7
  TOP w0.102: v1(230.04,70.5) 230.67,71.13 UE1.B31 ; v1(227.47,74.32) 227.05,74.74 RE36.2 ; UE2.B45 258.54,68.04 258.41,68.17 258.14,68.17 v1(257.68,67.71)
  IN4 w0.084: v1(227.47,74.32) 227.47,74.19 229.28,72.37 229.28,70.67 229.45,70.5 v1(230.04,70.5) 230.06,70.5 231.46,71.91 232.78,71.91 233.26,71.42 236.98,71.42 237.24,71.16 239.05,71.16 239.31,71.42 242.04,71.42 243.05,70.41 245.66,70.41 246.62,71.36 248.65,71.36 249.1,71.81 257,71.81 257.27,71.54 259.26,71.54 259.73,72 260.3,72 260.56,71.74 260.56,71.14 260,70.58 260,68.98 259.19,68.17 258.14,68.17 v1(257.68,67.71)
BC_INT#_ECE1117: length 76.7
  TOP w0.102: v1(270.79,47.98) v2(271.68,47.98) ; UE2.A19 251.62,61.02 v1(250.9,60.29)
  IN2 w0.102: v1(254.5,56.14) 254.5,56.17 253.38,57.3 253.38,57.85 251.91,59.31 251.91,59.64 251.66,59.89 251.29,59.89 v1(250.9,60.29)
  IN4 w0.102: v1(254.5,56.14) 254.5,56.13 254.5,56.13 254.79,55.84 254.79,54.88 256.9,52.76 267.06,52.76 269.14,50.68 270.88,50.68 271.1,50.45 271.1,48.29 v1(270.79,47.98)
  BOTTOM w0.102: JKBTP1.7 277.8,6.77 274.55,10.03 274.55,19.03 273.3,20.28 273.3,41.55 270.67,44.18 270.67,47.86 v1(270.79,47.98)
BC_INT#_ECE5048: length 40.5
  TOP w0.102: v1(230.36,73.71) 230.83,73.24 230.83,72.91 230.92,72.82 UE1.A29 ; v1(261.18,68.63) 260.33,67.79 UE2.A42
  IN3 w0.102: v1(230.36,73.71) 231.39,72.68 234.29,72.68 234.85,73.24 234.85,73.76 236.2,75.12 244.65,75.12 245.15,74.62 245.56,74.62 245.73,74.79 250.3,74.79 251.27,73.82 251.27,73.3 252.79,71.78 252.79,69.8 253.32,69.26 256.39,69.26 256.49,69.16 258.69,69.16 259.71,68.14 260.68,68.14 v1(261.18,68.63)
BCM5882_ALERT#: length 109
  TOP w0.102: UE1.B62 234.17,62.77 v1(234.43,63.03) ; v1(234.96,51.34) v2(234.96,51.88)
  IN2 w0.102: v1(234.43,63.03) 234.05,62.65 234.05,59.6 232.65,58.2 232.65,56.42 234.96,54.11 v1(234.96,51.34)
  IN4 w0.102: v1(234.96,51.34) 234.96,51.65 235.65,52.33 239.52,52.33 241.39,50.46 241.39,47.11 245.81,42.69 258.85,42.69 259.24,42.3 259.24,41.69 259.48,41.45 261.48,41.45 262.95,42.92 265.87,42.92 269.57,39.23 271.84,39.23 273.59,37.48 273.59,20.34 274.47,19.45 274.47,11.13 277.16,8.44 281.26,8.44 282.09,7.62 283.5,7.62 284.2,6.92 288.88,6.92 289.37,7.4 v1(289.74,7.4)
  BOTTOM w0.102: v1(289.74,7.4) 290.03,7.4 290.4,7.77 JUSH1.14
BEEP: length 40.3
  TOP w0.102: UE2.B19 250.87,62.85 v1(250.67,63.05) ; RA13.2 284.04,62.17 283.84,62.38 283.84,64.1 v2(282.81,65.12) 282.31,65.12 280.5,63.32 277.76,63.32 275.63,61.18 v1(275.05,61.18)
  IN3 w0.102: v1(275.05,61.18) 273.89,62.35 270.78,62.35 269.9,63.23 262.87,63.23 262.19,63.92 259.37,63.92 258.9,63.45 258.07,63.45 257.88,63.27 257.88,62.97 257.44,62.53 251.19,62.53 v1(250.67,63.05)
BIA_PWM: length 3.7
  TOP w0.102: LV1.2 96.16,110.07 RV1.1 96.95,110.85 v2(98.22,110.85) 98.42,110.65 DV1.1
BIA_PWM_EC: length 253.6
  TOP w0.102: v1(97.67,108.92) 97.14,108.92 DV1.2 ; UE2.B25 253.87,63.16 v1(253.37,63.66)
  IN1 w0.102: v1(254.7,40.64) 254.01,41.33 243.43,41.33 242.67,40.57 239.54,40.57 238.81,41.3 235.1,41.3 233.16,39.35 195.2,39.35 194.69,39.86 171.21,39.86 170.24,40.83 161.57,40.83 158.88,43.52 154.95,43.52 154.21,42.77 152.2,42.77 v1(151.5,42.08)
  IN2 w0.102: v1(253.37,63.66) 253.47,63.66 253.99,63.13 253.99,60.09 256.14,57.94 256.14,56.52 256.56,56.1 256.56,54.87 256.7,54.73 256.7,51.89 256.42,51.61 256.42,49.45 256.48,49.39 256.48,45.58 254.7,43.8 v1(254.7,40.64)
  IN4 w0.102: v1(151.5,42.08) 151.33,42.08 150.68,41.43 123.49,41.43 122.15,42.76 122.15,49.16 119.78,51.54 119.78,75.61 116.29,79.11 116.29,85.36 119.03,88.1 119.03,92.78 117.67,94.14 107.3,94.14 104.71,96.73 100.62,96.73 98.69,98.65 98.69,105.5 99.54,106.35 99.54,108.21 98.83,108.92 v1(97.67,108.92)
BL_PWR_SRC_ON: length 2.5
  TOP w0.102: v2(88.93,116.39) 88.93,116.27 88.74,116.08 88.74,115.27 89.07,114.95 QV1.3
BOARD_ID: length 7.7
  TOP w0.102: v1(247.06,66.77) 247,66.84 CE40.1 RE79.2 246.95,67.73 v2(247.49,68.26) ; UE2.B10 v1(250.42,66.54)
  IN1 w0.102: v1(247.06,66.77) 247.7,67.41 248.42,67.41 249.29,66.54 v1(250.42,66.54)
BQ24770_REGN: length 12.8
  TOP w0.254: v1(49.49,52.57) 49.49,51.65 v2(49.64,51.49) 50,51.14 PR821.2
  BOTTOM w0.254: v1(49.49,52.57) 49.18,52.88 49.18,54.71 50.02,55.55 50.02,57.44 50.78,58.2 52.3,58.2 52.69,57.81 PR827.1 53.24,57.69 PR801.1
BREATH_LED#: length 272
  TOP w0.102: v1(278.43,86.53) v2(278.95,86.53) ; UE2.B57 255.87,70.9 v1(256.37,70.4) ; QZ7.4 283.34,21.36 RZ34.1 283.36,21.79 v1(283.07,22.08)
  IN1 w0.102: v1(278.43,86.53) 278.31,86.41 271.04,86.41 269.4,88.05 269.4,89.82 270.48,90.9 270.48,94.65 271.05,95.22 271.05,104.56 271.69,105.19 271.69,108.42 271.09,109.01 267.93,109.01 v1(267.41,108.49)
  IN2 w0.102: v1(283.07,22.08) 281.92,22.08 278.74,25.26 278.74,29.37 276.65,31.45 276.65,38 272.79,41.86 272.79,43.46 273.38,44.04 273.38,48.45 272.82,49.01 272.82,51.88 272.37,52.32 272.37,56.94 273.36,57.93 273.36,60.15 274.01,60.8 274.01,69.18 v1(274.48,69.65) 275.35,70.51 275.35,72.63 278.22,75.5 278.22,86.32 v1(278.43,86.53) ; v1(267.41,108.49) 267,108.09 266.63,108.09 265.96,108.76 265.96,111.26 259.65,117.57 259.65,122.92 256.41,126.16 245.77,126.16 244.85,127.08 239.79,127.08 239.57,126.86 237.72,126.86 237.28,126.42 229.58,126.42 227.89,124.74 218.87,124.74 218.21,124.07 211.91,124.07 210.94,123.11 204.4,123.11 202.71,121.42 195.55,121.42 194.98,121.99 192.25,121.99 191.23,120.98 189.29,120.98 186.13,124.14 177.85,124.14 177.41,124.58 167.34,124.58 165.41,126.5 165.41,128.66 165.57,128.81 165.57,131.31 160.31,136.56 160.31,139.91 v1(159.93,140.29)
  IN3 w0.102: v1(274.48,69.65) 273.59,68.76 273.59,67.41 272.65,66.47 266.04,66.47 264.35,68.16 263.61,68.16 262.57,69.2 260.26,69.2 259.53,69.92 256.85,69.92 v1(256.37,70.4)
  BOTTOM w0.102: JDOCK1.98 160,140.22 v1(159.93,140.29)
BREATH_LED#_Q: length 3.3
  TOP w0.102: QZ7.3 279.21,21.36 RZ32.1 278.65,21.91 v2(277.27,21.91)
BREATH_WHITE_LED#: length 6
  TOP w0.102: v1(286.9,21.37) v2(285.65,21.37) RZ34.2
  BOTTOM w0.102: v1(286.9,21.37) 286.9,20.94 287.89,19.95 JLED1.2
BREATH_WHITE_LED_SNIFF#: length 116.6
  TOP w0.102: LED3.1 v1(294.29,119.54) ; RZ32.2 278.03,21.37 v1(277.7,21.04) ; v2(272.78,50.53) 273.26,50.53 v1(273.29,50.5)
  IN1 w0.102: v1(273.29,50.5) 273.29,46 275.02,44.27 275.02,22.34 276.31,21.04 v1(277.7,21.04)
  IN3 w0.102: v1(273.29,50.5) 274.09,51.3 274.09,52.54 275.01,53.46 275.09,53.46 282.18,60.55 284.55,60.55 285.24,61.24 285.24,63.01 286.13,63.9 286.13,74.4 285.61,74.92 285.61,82.81 282.06,86.35 282.06,88.41 287.18,93.53 287.18,101.58 289.15,103.55 289.15,109.6 294.29,114.74 v1(294.29,119.54)
BST_3V: length 1.5
  TOP w0.102: v3(218.72,88.46) 219.38,87.8 PR100.1
  vias: v1(219.71,87.12) v1(220.34,87.12)
BST_+1VALWP: length 2.6
  TOP w0.254: PU301.6 228.25,82.21 v1(228.57,81.89)
  BOTTOM w0.102: v1(228.57,81.89) v2(229.3,81.89)
  BOTTOM w0.508: PC304.1 v1(228.57,81.89)
BST_+1VALWP_C: length 1.3
  BOTTOM w0.102: PC304.2 v2(226.48,81.24)
BT_RADIO_DIS#: length 37
  TOP w0.102: UE1.A13 239.66,69.23 240.07,69.63 RE11.2 243.05,67.27 243.05,63.94 244.4,62.6 244.4,59.86 245.38,58.88 245.38,56.78 244.87,56.27 244.87,55.08 245.22,54.72 245.84,54.72 v2(246.69,53.87) 247.33,53.23 247.33,50.89 247.82,50.4 251.71,50.4 253.51,48.6 258.3,48.6 DZ2.1
BT_RADIO_DIS#_R: length 5.3
  TOP w0.102: DZ2.2 258.24,49.63 257.37,50.5 257.37,50.79 v1(256.85,51.31) 255.71,51.31 v2(255.47,51.08)
  BOTTOM w0.102: JNGFF1.46 v1(256.85,51.31)
CAM_MIC_CBL_DET#: length 132.8
  TOP w0.102: v1(172.93,102.08) 173.11,101.9 173.11,99.46 171.28,97.63 171.28,96.59 170.99,96.3 169.57,96.3 169.28,96.01 169.28,95.33 169.1,95.16 166.99,95.16 166.75,94.92 166.75,92.38 167.13,91.99 168,91.99 v1(168.42,91.57) ; v1(180.39,110.57) 180.39,109.67 176.27,105.55 v2(176.27,103.25) v1(176.27,101.76)
  IN3 w0.102: v1(172.93,102.08) 173.25,101.76 v1(176.27,101.76) ; v1(180.39,110.57) 180.39,114.19 178.08,116.49 170.8,116.49 165.5,121.79 163.08,121.79 162.1,120.81 158.7,120.81 155.37,124.14 144.36,124.14 144.36,124.14 137.05,124.14 135.22,122.31 133.98,122.31 132.04,120.37 122.17,120.37 116.55,114.75 107.67,114.75 106.61,113.7 101,113.7 99.73,112.43 98.89,112.43 98.56,112.1 96.31,112.1 v1(96.26,112.15)
  BOTTOM w0.076: RPC4.4 176.68,102.43 176.27,102.03 v1(176.27,101.76) ; UC1.AB11 v1(168.42,91.57)
  BOTTOM w0.102: JEDP1.14 97.11,112.98 96.92,112.98 96.26,112.31 v1(96.26,112.15)
CD3301_DCIN: length 5.1
  TOP w0.102: PR921.2 86.02,62.04 v2(86.46,61.6)
  TOP w0.254: PR921.2 86.01,63.06 PC906.1 86.01,65.06 86.69,65.73 PU901.1
CD3301_SDC_IN: length 2.6
  TOP w0.254: PU901.6 89.19,65.19 PR928.2
CD_PBATT_OFF: length 4.7
  TOP w0.102: PR937.1 85.87,74.13 86.28,74.53 v2(86.28,76.15)
  TOP w0.254: PU901.27 86.69,72.49 86.07,73.11 86.07,73.88 PR937.1
CFG0: length 53.2
  TOP w0.102: v1(120.94,127.71) 120.94,126.89 RC126.1
  IN4 w0.102: v1(120.94,127.71) 120.94,127.03 122.95,125.03 125.64,125.03 126.36,124.31 126.36,118.93 124.73,117.31 123.98,117.31 122.02,115.35 122.02,109.81 122.5,109.32 126.46,109.32 130.32,105.47 132.72,105.47 v1(133.4,104.79)
  BOTTOM w0.076: 129.6,106.22 130.12,105.7 132.49,105.7 v1(133.4,104.79) 133.85,104.34 135.89,104.34 136.14,104.09 136.14,103.73 136.29,103.58 136.29,103.44 136.29,103.43 136.29,103.07 136.29,103.06 136.25,102.97 136.25,102.84 136.26,102.75 136.29,102.67 136.29,102.61 136.29,102.5 136.29,102.49 136.29,102.45 136.27,102.39 136.24,102.3 136.19,102.11 136.15,101.85 136.07,101.59 UC1.E68
  BOTTOM w0.102: 129.6,106.22 129.55,106.22 128.19,107.58 RC113.2 ; v1(120.94,127.71) 120.66,127.71 120.39,127.44 JXDP1.9

# Allegro board LAC451PR10-0923B.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
CFG1: length 47.4
  IN4 w0.102: v1(120.32,124.38) 120.56,124.62 125,124.62 125.23,124.38 125.23,118.71 124.23,117.71 123.81,117.71 121.61,115.52 121.61,109.64 122.33,108.92 126.29,108.92 130.44,104.77 v1(132.26,104.77)
  BOTTOM w0.076: 129.6,102.99 131.38,104.77 v1(132.26,104.77) 133.09,103.94 134.62,103.94 135.05,103.5 135.34,103.5 135.5,103.34 135.5,103.1 135.86,102.74 UC1.B67
  BOTTOM w0.102: RC112.2 128.32,101.71 129.6,102.99 ; v1(120.32,124.38) 120.89,124.95 JXDP1.11
CFG2: length 44.5
  IN4 w0.102: v1(133.98,104.83) 133.14,105.67 130.4,105.67 126.55,109.53 122.59,109.53 122.22,109.89 122.22,115.26 124.06,117.1 124.81,117.1 126.56,118.85 126.56,124.4 125.69,125.27 124.09,125.27 122.12,127.24 v1(122.12,127.68)
  BOTTOM w0.076: v1(133.98,104.83) 134.31,104.5 136.48,104.5 136.95,104.04 136.95,103.61 136.78,103.44 136.78,103.07 136.81,102.98 136.81,102.79 136.78,102.69 136.78,102.45 136.79,102.4 136.83,102.25 136.91,101.97 136.91,101.85 136.99,101.59 UC1.D65
  BOTTOM w0.102: v1(122.12,127.68) 121.89,127.45 JXDP1.15
CFG3: length 62.5
  IN4 w0.102: v1(132.84,104.76) 132.41,105.19 130.31,105.19 126.38,109.12 122.42,109.12 121.82,109.72 121.82,115.43 123.89,117.51 124.32,117.51 125.44,118.63 125.44,124.47 125.08,124.82 121.31,124.82 120.44,125.69 120.44,128.08 121.58,129.21 v1(122.04,129.21)
  BOTTOM w0.076: 129.85,103.77 129.86,103.78 129.86,103.8 131.43,105.37 132.24,105.37 v1(132.84,104.76) 133.43,104.17 135.82,104.17 135.97,104.02 135.97,103.67 136.12,103.52 136.12,103.1 136.06,102.99 136.06,102.84 136.12,102.65 136.12,102.47 136.04,102.22 UC1.D67
  BOTTOM w0.102: 129.85,103.77 127.27,101.19 125.69,101.19 RC110.2 ; JXDP1.17 122.39,127.39 122.5,127.5 122.5,128.62 122.04,129.08 v1(122.04,129.21) 122,129.26 119.29,129.26 RC121.2
CFG4: length 42.7
  IN4 w0.102: v1(124.1,124.15) 124.83,123.43 124.83,118.88 124.06,118.12 123.64,118.12 121.21,115.69 121.21,109.47 122.17,108.51 126.12,108.51 131.1,103.54 131.85,103.54 132.48,102.91 132.48,101.84 v1(132.6,101.73)
  BOTTOM w0.076: UC1.E70 133.82,100.91 133.62,101.11 133.22,101.11 v1(132.6,101.73) 131.92,102.41 130.76,102.41 129.89,101.55 129.89,100.24 129.6,99.94
  BOTTOM w0.102: JXDP1.27 124.89,124.94 v1(124.1,124.15) ; 129.6,99.94 v2(129.44,99.79) 129.26,99.6 RC109.2
CFG5: length 36
  IN4 w0.102: v1(124.67,124.14) 125.03,123.78 125.03,118.8 124.15,117.92 123.72,117.92 121.41,115.6 121.41,109.56 122.25,108.72 126.21,108.72 131.13,103.79 133.08,103.79 134.8,102.08 v1(134.8,101.89)
  BOTTOM w0.076: UC1.C68 135.13,101.55 v1(134.8,101.89)
  BOTTOM w0.102: JXDP1.29 125.39,124.86 v1(124.67,124.14)
CFG6: length 37.6
  IN4 w0.102: v1(123.53,124.09) 123.91,123.71 123.91,118.68 121,115.77 121,109.39 122.08,108.31 126.04,108.31 131.13,103.22 131.64,103.22 132.06,102.8 v1(132.06,102.79)
  BOTTOM w0.076: v1(132.06,102.79) 132.2,102.79 133.25,101.74 133.63,101.74 133.94,101.43 UC1.D68
  BOTTOM w0.102: JXDP1.33 126.39,124.98 125.14,123.73 123.89,123.73 v1(123.53,124.09)
CFG7: length 41.3
  IN4 w0.102: v1(131.48,102.84) 131.22,102.84 125.95,108.11 121.99,108.11 120.24,109.86 120.24,115.3 123.71,118.76 123.71,123.33 v1(122.96,124.07)
  BOTTOM w0.076: UC1.C67 135.27,102.68 135.07,102.89 134.39,102.89 134.24,103.04 134.24,103.48 134.14,103.58 132.24,103.58 131.48,102.83 v1(131.48,102.84)
  BOTTOM w0.102: JXDP1.35 126.89,125.02 125.4,123.53 123.5,123.53 v1(122.96,124.07)
CFG8: length 31.6
  IN4 w0.102: v1(131.7,100.56) 131.66,100.52 130.22,100.52 127.42,103.31 127.42,105.78 125.7,107.5 121.74,107.5 119.63,109.6 119.63,115.55 120.69,116.6 v1(120.69,117.26)
  BOTTOM w0.076: UC1.F71 133.83,100.35 131.91,100.35 v1(131.7,100.56)
  BOTTOM w0.102: v1(120.69,117.26) 120.24,117.26 120.05,117.45 120.05,118.27 120.39,118.61 JXDP1.10
CFG9: length 37.9
  IN4 w0.102: v1(120.43,117.8) 119.52,117.8 117.89,116.18 117.89,113.98 118.62,113.25 118.62,109.18 120.16,107.64 120.16,102.58 124.29,98.45 131.58,98.45 132.08,98.94 v1(132.08,99.46)
  BOTTOM w0.076: UC1.G69 134.64,99.46 134.39,99.46 134.17,99.38 134.04,99.38 133.81,99.45 133.67,99.45 133.55,99.39 133.29,99.39 133.03,99.65 132.26,99.65 v1(132.08,99.46)
  BOTTOM w0.102: v1(120.43,117.8) 120.43,118.27 120.89,118.73 JXDP1.12
CFG10: length 31
  IN4 w0.102: v1(121.68,117.81) 121.68,117.02 120.04,115.38 120.04,109.77 121.91,107.9 125.87,107.9 128.41,105.37 128.41,104.64 130.59,102.46 131.71,102.46 132.16,102.01 v1(132.16,100.89)
  BOTTOM w0.076: v1(132.16,100.89) 132.52,100.53 133.6,100.53 133.61,100.55 134.21,100.55 UC1.F70
  BOTTOM w0.102: JXDP1.16 121.89,118.97 121.68,118.75 v2(121.68,118.42) v1(121.68,117.81)
CFG11: length 34.1
  IN4 w0.102: v1(130.35,100.92) 127.63,103.65 127.63,105.86 125.79,107.7 121.82,107.7 119.83,109.69 119.83,115.46 121.16,116.79 121.16,117.71 v1(121.04,117.83)
  BOTTOM w0.076: UC1.G68 134.85,99.83 134.79,99.85 134.32,99.85 134.25,99.92 133.99,99.92 133.43,100.17 131.1,100.17 v1(130.35,100.92)
  BOTTOM w0.102: JXDP1.18 122.39,119.18 122.06,118.85 122.06,117.61 121.88,117.43 121.24,117.43 121.04,117.64 v1(121.04,117.83)
CFG12: length 39.9
  IN4 w0.102: v1(118.67,116.33) 118.52,116.33 118.09,115.9 118.09,114.06 118.82,113.34 118.82,109.27 120.36,107.73 120.36,102.67 124.35,98.67 131.12,98.67 v1(131.44,98.99)
  BOTTOM w0.076: v1(131.44,98.99) 131.74,98.69 132.93,98.69 133,98.76 133.58,98.76 133.71,98.71 133.82,98.71 133.95,98.76 134.19,98.76 UC1.H70
  BOTTOM w0.102: JXDP1.28 124.89,118.92 122.82,116.85 119.19,116.85 v1(118.67,116.33)
CFG13: length 37.8
  IN4 w0.076: v1(130.32,99.48) 129.93,99.08 129.59,99.08
  IN4 w0.102: 129.59,99.08 124.52,99.08 120.77,102.83 120.77,107.9 119.23,109.44 119.23,113.72 118.87,114.08 118.87,115.93 119.43,116.49 119.78,116.49 v1(119.86,116.42)
  BOTTOM w0.076: UC1.G71 133.26,99.83 131.24,99.83 130.88,99.48 v1(130.32,99.48)
  BOTTOM w0.102: v1(119.86,116.42) 120.09,116.65 122.9,116.65 125.39,119.13 JXDP1.30
CFG14: length 41.8
  IN4 w0.102: v1(118.48,115.74) 118.48,114.12 119.02,113.57 119.02,109.35 120.56,107.81 120.56,102.75 124.43,98.88 130.66,98.88 v1(130.86,99.08)
  BOTTOM w0.076: v1(130.86,99.08) 131.17,99.39 131.58,99.39 131.95,99.02 132.17,99.02 132.62,99.47 132.93,99.47 133.17,99.22 133.58,99.22 133.7,99.27 133.81,99.27 134.03,99.21 134.18,99.21 134.33,99.26 134.8,99.26 UC1.H69
  BOTTOM w0.102: v1(118.48,115.74) 118.69,115.74 119.15,116.2 119.52,116.2 119.77,115.95 120.1,115.95 120.6,116.44 122.98,116.44 125.17,118.62 126.09,118.62 126.39,118.92 JXDP1.34
CFG15: length 36.9
  IN4 w0.102: v1(119.29,115.78) 119.43,115.64 119.43,109.52 121.66,107.29 125.62,107.29 127.22,105.69 127.22,103.14 v1(130.32,100.03)
  BOTTOM w0.076: UC1.G70 133.94,99.66 133.8,99.8 133.8,99.8 133.8,99.8 133.38,100 130.36,100 v1(130.32,100.03)
  BOTTOM w0.102: v1(119.29,115.78) 119.33,115.74 120.19,115.74 120.69,116.24 123.07,116.24 125,118.17 v2(125.66,118.17) 125.96,118.17 126.89,119.1 JXDP1.36
CFG16: length 45
  IN4 w0.102: v1(114.83,115.35) 114.83,115.15 115.83,114.14 115.83,111.1 119.55,107.39 119.55,102.33 124.04,97.84 135.53,97.84 136.31,98.61 136.31,99.09 v1(137.93,100.71)
  BOTTOM w0.076: UC1.E63 v1(137.93,100.71)
  BOTTOM w0.102: JXDP1.6 119.39,118.64 116.51,115.76 115.24,115.76 v1(114.83,115.35)
CFG17: length 46.1
  IN4 w0.102: v1(114.26,115.35) 115.53,114.08 115.53,111.12 119.34,107.3 119.34,102.24 124.89,96.69 132.92,96.69 133.64,97.42 135.44,97.42 136.54,98.51 136.54,99.03 137.58,100.08 v1(137.93,100.08)
  BOTTOM w0.076: UC1.F63 v1(137.93,100.08)
  BOTTOM w0.102: JXDP1.4 118.89,118.71 v2(117.55,117.37) 116.29,116.11 115.02,116.11 v1(114.26,115.35)
CFG18: length 43.1
  IN4 w0.102: v1(122.44,118.08) 122.2,118.32 119.75,118.32 117.69,116.26 117.69,113.89 118.41,113.17 118.41,109.1 119.95,107.56 119.95,102.5 124.21,98.24 133.43,98.24 v1(135.9,100.71)
  BOTTOM w0.076: UC1.E66 v1(135.9,100.71)
  BOTTOM w0.102: v1(122.44,118.08) 123.13,118.08 v2(123.35,118.3) 123.89,118.84 JXDP1.24
CFG19: length 42.8
  IN4 w0.102: v1(122.44,118.65) 122.31,118.53 119.67,118.53 117.49,116.34 117.49,113.81 118.21,113.08 118.21,109.01 119.75,107.47 119.75,102.41 124.12,98.04 133.86,98.04 v1(135.9,100.08)
  BOTTOM w0.076: UC1.F66 v1(135.9,100.08)
  BOTTOM w0.102: v1(122.44,118.65) 122.48,118.61 123.08,118.61 123.39,118.92 JXDP1.22
CFG_RCOMP: length 1.1
  TOP w0.381: v1(139.86,100.71) 139.85,100.69 RC114.1
  BOTTOM w0.254: UC1.E60 139.94,100.67 v1(139.86,100.71)
CHAGER_SRC:
  vias: v1(58.01,48.55) v1(58.01,47.98) v1(58.58,48.55) v1(58.58,47.98) v1(58.58,47.41) v1(59.22,48.55) v1(59.22,47.98) v1(59.22,47.41) v2(57.25,48.55)
CHARGER_SMBCLK: length 269.5
  TOP w0.102: RPE6.2 261.99,72.04 261.43,71.47 261.43,70.57 v1(261.16,70.3) ; v1(65.42,62.82) 65.24,62.64 65.02,62.64 64.89,62.77 64.89,63.65 64.11,64.44 55.99,64.44 53.2,61.65 53.2,60.7 PR835.1 ; v1(258.32,70.51) 258.35,70.54 UE2.B50
  IN1 w0.084: v1(65.42,62.82) 65.23,62.63 65,62.63 64.77,62.39 64.77,61.11 65.35,60.53 65.35,59.53 66.27,58.61 66.27,58.47 67.24,57.5 67.24,55.76 68,55 69.93,55 70.75,54.18 70.75,47.83 72.44,46.14 78.52,46.14 79.25,45.41 79.25,43.62 81.32,41.55 140.48,41.55 140.65,41.72 146.49,41.72 147.9,43.12 147.9,44.38 150.14,46.63 155.63,46.63 156.87,45.39 159.57,45.39 162.34,42.62 173.82,42.62 174.39,42.05 230.61,42.05 230.88,42.32 232.86,42.32 233.93,43.38 239.73,43.38 239.99,43.13 254.57,43.13 256.78,45.33 256.78,46.45 257.06,46.74 260.29,46.74 260.83,47.27 260.83,47.59 v1(261.01,47.77) ; v1(261.16,70.3) 260.79,70.67 258.48,70.67 v1(258.32,70.51)
  IN2 w0.122: v1(261.16,70.3) 261,70.14 261,69.65 260.67,69.32 260.31,69.32 259.69,68.7 259.69,63.46 261.14,62 261.14,61.49 262.2,60.43 262.2,59.38 262.87,58.71 262.87,55.29 262.49,54.91 262.49,52.96 260.85,51.33 260.85,47.93 v1(261.01,47.77)
CHARGER_SMBDAT: length 265.8
  TOP w0.102: UE2.A47 v1(260.59,70.29) v2(261.09,70.79) 261.09,71.62 262.01,72.54 RPE6.1 ; v1(65.42,62.23) 65.24,62.41 64.93,62.41 64.67,62.67 64.67,63.56 64.02,64.21 56.08,64.21 53.43,61.55 53.43,60.7 PR836.1
  IN1 w0.084: v1(65.42,62.23) 65.23,62.42 65.09,62.42 64.98,62.3 64.98,61.2 65.56,60.62 65.56,59.61 66.48,58.7 66.48,58.56 67.45,57.58 67.45,55.85 68.09,55.22 70.01,55.22 70.97,54.26 70.97,47.91 72.53,46.35 78.61,46.35 79.46,45.5 79.46,43.71 81.4,41.76 140.4,41.76 140.56,41.93 146.4,41.93 147.69,43.21 147.69,44.47 150.06,46.84 155.72,46.84 156.96,45.6 159.66,45.6 162.42,42.83 173.9,42.83 174.48,42.26 230.52,42.26 230.79,42.53 232.78,42.53 233.84,43.59 239.82,43.59 240.08,43.34 254.48,43.34 256.57,45.42 256.57,46.54 256.98,46.95 260.2,46.95 260.62,47.36 260.62,47.58 v1(260.42,47.77)
  IN2 w0.122: v1(260.42,47.77) 260.6,47.95 260.6,51.43 262.24,53.07 262.24,55.01 262.62,55.39 262.62,58.61 261.95,59.27 261.95,60.33 260.89,61.38 260.89,61.9 259.44,63.35 259.44,68.8 260.21,69.57 260.57,69.57 260.75,69.75 260.75,70.13 v1(260.59,70.29)
CHG_LGATE: length 9
  TOP w0.102: 51.9,42.95 51.65,43.2 v2(51.65,43.63)
  IN4 w1.016: 52.23,43.34 51.92,43.66 51.92,50.9 52.3,51.28
  vias: v1(52.03,42.46) v1(52.61,52.1) v1(52.6,42.46) v1(52.99,52.55)
CHG_SNUB: length 1.3
  TOP w0.102: PC832.1 v2(49.18,39.72)
CHG_SW: length 7.6
  TOP w0.102: PR824.2 v2(56.07,40.17)
  IN1 w1.016: 56.3,51.13 56.3,48.87 55.79,48.36 55.79,45.06
  vias: v1(53.87,44.12) v1(53.87,43.48) v1(53.87,42.85) v1(53.87,42.21) v1(54.7,44.12) v1(54.7,43.48) v1(54.7,42.85) v1(54.7,42.21) v1(55.53,52.49) v1(55.52,44.12) v1(55.52,43.48) v1(55.52,42.85) v1(55.52,42.21) v1(55.85,51.98)
CHG_UGATE: length 9.6
  TOP w0.102: v1(58.11,42.5) 58.11,41.66 v2(58.07,41.63)
  IN4 w1.016: 54.9,51.02 54.9,48.23 57.88,45.25 57.88,43.6
  vias: v1(54.65,52.49) v1(54.9,51.98) v1(57.52,42.5)
CLK_27M_IN: length 8.4
  TOP w0.089: UV8.K1 219.56,112.2 219.56,111.98 220.44,111.1
  TOP w0.102: 220.44,111.1 220.56,111.1 v2(220.9,110.76) 221.45,110.21 RV80.1 222.72,109.32 CV115.1 223.11,108.95 223.11,107.4 YV2.1
CLK_27M_OUT: length 5
  TOP w0.089: 219.86,112.06 UV8.L1
  TOP w0.102: RV81.2 RV80.2 221.9,111.04 221.7,111.04 221.45,111.29 220.63,111.29 219.86,112.06
CLK_27M_OUT_R: length 2.9
  TOP w0.102: YV2.3 224.34,108.59 CV113.1 223.63,109.32 RV81.1
CLK_ITPXDP_N: length 12.7
  TOP w0.102: v1(146.5,108.48) 146.66,108.64 146.93,108.64 146.97,108.6 146.97,104.66 148.23,103.41 148.23,101.24 148.67,100.8 148.67,100.54 v1(149.05,100.16)
  BOTTOM w0.102: RC297.1 145.86,109.91 145.86,108.85 146.1,108.62 146.36,108.62 v1(146.5,108.48) ; v1(149.05,100.16) 149.37,99.84 UC1.F43
CLK_ITPXDP_N_R: length 26.6
  TOP w0.102: v1(145.67,111.83) 145.85,112.01 145.85,114.07 143.24,116.68 143.24,116.98 142.74,117.48 138.43,117.48 138.02,117.9 137.58,117.9 137.49,117.81 137.49,117.66 v1(137.67,117.48)
  IN2 w0.102: v1(128.47,118.71) 128.09,118.33 128.09,117.99 128.31,117.76 133.07,117.76 133.45,118.15 137,118.15 v1(137.67,117.48)
  BOTTOM w0.102: v1(128.47,118.71) 128.39,118.79 JXDP1.42 ; RC297.2 145.86,111.47 145.86,111.64 v1(145.67,111.83)
CLK_ITPXDP_P: length 12.1
  TOP w0.102: v1(146.5,109.07) 146.69,108.87 147.03,108.87 147.2,108.7 147.2,104.76 148.46,103.5 148.46,101.33 v1(149.05,100.74)
  BOTTOM w0.102: RC298.1 146.09,109.91 146.09,108.95 146.19,108.85 146.28,108.85 v1(146.5,109.07) ; v1(149.05,100.74) 149.3,100.49 UC1.E43
CLK_ITPXDP_P_R: length 26.9
  TOP w0.102: v1(146.26,111.83) 146.08,112.01 146.08,114.16 143.47,116.77 143.47,117.08 142.83,117.71 138.53,117.71 138.11,118.13 137.49,118.13 137.26,117.9 137.26,117.71 v1(137.04,117.5)
  IN2 w0.102: v1(137.04,117.5) 137.04,117.75 136.85,117.95 133.54,117.95 133.15,117.56 128.23,117.56 127.88,117.9 v1(127.88,118.71)
  BOTTOM w0.102: v1(146.26,111.83) 146.09,111.67 146.09,111.47 RC298.2 ; v1(127.88,118.71) 127.94,118.77 127.94,119.21 127.89,119.26 JXDP1.40
CLK_KBD: length 174.9
  TOP w0.102: RPE2.8 262.44,64.94 262.4,64.91 262.05,64.91 v1(261.67,65.29) v2(261.27,65.69) 261.17,65.79 UE2.A38
  IN1 w0.084: v1(153.96,140.21) 154.14,140.02 154.14,139.54 154.6,139.08 157.18,139.08 157.63,139.52 159.92,139.52 160.43,139.02 171.53,139.02 172.84,140.33 179.59,140.33 180.52,139.4 180.52,134.32 182.49,132.35 186.84,132.35 190.52,128.67 190.52,127.9 192.56,125.87 200.17,125.87 201.26,126.96 215.47,126.96 216.55,125.87 223.07,125.87 226.08,122.86 226.08,114.8 225.63,114.34 225.63,112.74 227.09,111.27 229.25,111.27 229.65,111.67 240.4,111.67 250.93,101.15 252.23,101.15 254.69,98.69 254.69,93.69 256.5,91.88 256.5,86.91 255.83,86.24 255.83,85.38 v1(255.66,85.21)
  IN2 w0.122: v1(255.66,85.21) 255.83,85.04 255.83,84.77 256.13,84.47 257.47,84.47 258.39,83.55 258.39,82.81 259.64,81.56 259.64,76.25 260.98,74.9 260.98,71.31 262.65,69.64 262.65,66.18 262.48,66.01 262.15,66.01 261.82,65.68 261.82,65.46 261.67,65.3 v1(261.67,65.29)
  BOTTOM w0.102: v1(153.96,140.21) 154.14,140.03 154.14,139.68 154,139.54 JDOCK1.78
CLK_MSE: length 159.6
  TOP w0.102: RPE2.6 262.31,65.94 v1(261.67,66.58) 261.48,66.58 261.18,66.29 UE2.A39
  IN1 w0.084: v1(250.28,88.4) 250.1,88.58 249.78,88.58 249.24,89.12 249.24,95.26 242.15,102.35 227.69,102.35 227.17,102.86 214.45,102.86 213.84,103.48 209.68,103.48 204.83,108.32 192.24,108.32 181,119.57 170.93,119.57 164.96,125.54 164.46,125.54 161.71,128.29 158.27,128.29 157.55,129.02 157.55,129.21 156.65,130.11 154.87,130.11 154.2,129.44 154.2,129.03 153.49,128.32 152.89,128.32 152.65,128.56 152.65,128.77 v1(152.46,128.96)
  BOTTOM w0.102: v1(152.46,128.96) 152.64,129.14 152.64,129.39 152.5,129.53 JDOCK1.71 ; v1(250.28,88.4) 250.46,88.57 251.44,88.57 252.18,87.84 253.88,87.84 254.23,88.18 261.02,88.18 261.68,87.52 261.68,80.21 262.38,79.51 262.38,77.01 263,76.39 263,68.13 261.85,66.98 261.85,66.75 261.67,66.57 v1(261.67,66.58)
CLK_PCI_5048: length 93.4
  TOP w0.102: RC16.2 CC3.2 177.2,71.58 v1(177.2,71.83) ; v2(236.67,59.04) 236.88,59.24 v1(236.88,59.54) ; RE27.1 229.47,74.77 229.47,74.48 v1(229.63,74.33) 229.8,74.15 230.6,74.15 231.32,73.44 231.32,73.1 231.42,73 UE1.A28
  IN1 w0.102: v1(177.2,71.83) 178.3,70.73 179.82,70.73 181.23,69.32 196.47,69.32 205.69,60.1 228.61,60.1 229.39,59.32 231.91,59.32 232.32,59.73 236.37,59.73 236.55,59.54 v1(236.88,59.54)
  BOTTOM w0.102: v1(229.63,74.33) 229.63,72.22 228.53,71.13 228.53,68.96 229.07,68.42 230.58,68.42 231.98,67.03 231.98,62.58 233.27,61.28 233.27,59.9 233.63,59.54 v1(236.88,59.54)
CLK_PCI_DOCK: length 110.5
  TOP w0.102: RC24.2 CC6.2 178.72,71.46 178.49,71.46 v1(178.11,71.84)
  IN1 w0.084: v1(177.82,117.88) 177.82,117.12 178.52,116.42 180.1,116.42 182.82,113.7 182.82,113.36 187.5,108.68 189.39,108.68 190.14,107.93 190.14,100.46 v1(189.95,100.28)
  IN2 w0.122: v1(196.39,73.19) 196.39,73.78 196.95,74.34 196.95,76.83 197.21,77.09 197.21,77.98 196.9,78.29 196.9,79.03 195.91,80.02 194.71,80.02 194.22,80.51 194.22,82.25 192.39,84.07 191.09,84.07 189.6,85.56 189.6,85.61 188.67,86.54 188.67,88.68 185.47,91.88 183.36,91.88 182.83,92.41 182.83,93.65 181.72,94.75 181.72,95.56 182.05,95.89 182.05,97.77 184.55,100.28 v1(189.95,100.28)
  BOTTOM w0.102: v1(177.82,117.88) 173.34,122.36 172.76,122.36 169.86,125.26 169.86,126.86 168.68,128.04 167.33,128.04 166.41,127.11 R273.1 166.09,127.9 166.43,128.24 166.43,128.56 166,128.99 JDOCK1.121 ; v1(196.39,73.19) 195.96,72.75 179.03,72.75 v1(178.11,71.84)
CLK_PCI_LPDEBUG: length 142.4
  TOP w0.102: v1(179.68,71.82) 179.68,71.39 CC5.2 180.15,71.12 180.15,72.29 RC22.2
  IN1 w0.084: v1(260.49,43.24) 260.77,43.24 262.88,45.35 262.88,46.05 263.54,46.71 263.54,47.62 264.94,49.02 267.14,49.02 268.15,50.04 268.15,51.4 269.2,52.45 270.4,52.45 271.59,53.64 274.19,53.64 275.72,55.16 275.72,56.07 274.88,56.91 270.13,56.91 268.49,58.55 266.38,58.55 265.78,57.96 265.78,56.52 265.02,55.75 263.15,55.75 262.45,56.45 260.66,56.45 260.55,56.34 259.63,56.34 259.01,56.97 257.64,56.97 257.44,56.76 255.84,56.76 255.34,57.26 249.96,57.26 249.74,57.48 246.64,57.48 243.68,60.44 237.13,60.44 236.88,60.2 233.68,60.2 233.11,60.78 232.7,60.78 231.97,60.05 229.34,60.05 228.81,60.57 205.89,60.57 196.67,69.79 181.7,69.79 179.9,71.6 v1(179.68,71.82)
  IN4 w0.084: v1(253.86,43.71) 254.37,43.2 259.06,43.2 259.47,42.79 260.04,42.79 v1(260.49,43.24)
  BOTTOM w0.102: v1(253.86,43.71) 253.34,43.19 252.91,43.19 v2(252.77,43.05) 252.77,42.95 252,42.18 JLPDE1.10
CLK_PCI_MEC: length 102.1
  TOP w0.102: RE66.1 257.4,59.8 257.07,60.13 257.07,60.43 v1(256.62,60.88) UE2.A29 ; RC18.2 176.58,72.16 176.58,71.53 176.81,71.3 CC4.2 176.38,71.08 175.86,71.61 v1(175.86,71.87)
  IN1 w0.084: v1(175.86,71.87) 175.86,71.61 176.6,70.86 177.48,70.86 178.09,70.25 179.63,70.25 181.04,68.85 196.28,68.85 205.5,59.63 228.41,59.63 229.19,58.84 232.11,58.84 232.52,59.25 236.16,59.25 236.42,59 237.12,59 238.1,59.98 243.49,59.98 246.45,57.02 249.54,57.02 249.92,56.64 253.13,56.64 254.13,55.64 254.93,55.64 255.55,56.26 257.59,56.26 257.83,56.5 258.78,56.5 v1(258.8,56.52)
  IN2 w0.122: v1(256.62,60.88) 257.22,60.28 257.22,59.65 258.46,58.42 258.46,56.99 258.8,56.65 v1(258.8,56.52)
CLK_PCIE_N0: length 166
  IN4 w0.102: v1(152.19,107.77) 152.38,107.59 152.57,107.59 153.38,108.4 157.14,108.4 158.8,110.06 158.8,110.6 161.27,113.06 161.8,113.06 165.06,116.32 168.96,116.32 169.69,115.59 208.67,115.59 212.53,119.45 212.53,120.81 213.66,121.94 217.88,121.94 218.56,121.26 238.03,121.26 243.5,115.79 246.52,115.79 249.9,112.41 265.21,112.41 267.16,110.46 280.64,110.46 285.36,105.74 285.36,102.59 v1(285.54,102.41)
  BOTTOM w0.076: v1(152.19,107.77) 150.37,107.77 149.32,106.73 149.32,103.62 149.17,103.46 149.17,103.07 149.2,102.98 149.2,102.79 149.17,102.69 149.17,102.45 149.18,102.4 149.26,102.14 149.31,101.97 149.31,101.85 149.38,101.59 UC1.D42
  BOTTOM w0.094: v1(285.54,102.41) 285.38,102.24 285.38,102.02 285.19,101.84 284.71,101.84 284.31,102.23 282.04,102.23 281.41,101.6 JNGFF2.45
CLK_PCIE_N1: length 198.5
  IN2 w0.122: v1(255.64,46.55) 255.43,46.76 255.43,55.82 255.14,56.1 255.14,57.12 254.49,57.77 254.49,57.95 252.96,59.48 252.96,61.36 252.33,61.98 250.62,61.98 249.82,62.78 249.82,70.9 250.66,71.74 252.66,71.74 253.34,72.41 253.34,73.21 253.71,73.58 254.53,73.58 255.47,74.52 255.47,74.69 257.3,76.53 257.3,80.32 253.78,83.84 253.78,85.44 253.05,86.17 253.05,90.41 253.55,90.91 253.55,92.28 253.05,92.78 253.05,101.23 252.74,101.53 252.74,102.59 251.94,103.39 251.94,108.02 253.72,109.8 253.72,111.09 v1(253.9,111.27)
  IN4 w0.102: v1(253.9,111.27) 253.7,111.08 253.7,110.81 253.48,110.59 246.82,110.59 236.98,120.42 218.17,120.42 217.5,121.09 214.13,121.09 213.47,120.43 213.47,119.14 209.09,114.76 169.27,114.76 168.54,115.49 165.4,115.49 162.06,112.14 161.53,112.14 159.64,110.25 159.64,109.72 157.49,107.57 153.78,107.57 152.81,106.59 151.83,106.59 v1(151.66,106.42)
  BOTTOM w0.076: v1(151.66,106.42) 151.65,106.42 150.27,106.42 149.87,106.02 149.87,103.05 149.6,102.78 UC1.B42
  BOTTOM w0.094: JNGFF1.41 255.6,45.71 255.44,45.87 255.44,46.35 v1(255.64,46.55)
CLK_PCIE_N2: length 192.8
  IN2 w0.122: v1(262.29,47.44) 262.51,47.66 263.36,47.66 264.2,48.5 264.2,53.24 264.11,53.32 264.11,54.89 264.37,55.15 264.37,59.98 264.02,60.33 264.02,60.91 262.95,61.97 262.95,65.02 263.65,65.72 263.65,71.24 261.96,72.93 261.96,73.3 261.99,73.33 261.99,75.4 260.64,76.74 260.64,81.92 259.35,83.21 259.35,83.95 257.86,85.44 257.07,85.44 255.74,86.78 255.74,92.87 254.98,93.63 254.98,101.54 255.32,101.89 255.32,107.03 254.38,107.97 254.38,109.79 254.73,110.14 254.73,110.71 v1(254.82,110.79)
  IN4 w0.102: v1(152.19,105.62) 152.24,105.66 156.56,105.66 157.11,106.21 158.37,106.21 158.94,106.78 158.94,107.95 160.26,109.27 160.26,109.47 164.7,113.9 168.03,113.9 168.26,114.14 204.07,114.14 205.63,112.57 212.82,112.57 213.83,111.57 218.46,111.57 220.93,114.04 221.64,114.04 223.34,115.75 240.78,115.75 246.58,109.96 254.43,109.96 254.71,110.23 254.71,110.68 v1(254.82,110.79)
  BOTTOM w0.076: v1(152.19,105.62) 152.07,105.74 150.85,105.74 150.25,105.14 150.25,102.56 150.45,102.36 150.45,102.12 150.16,101.82 UC1.D41
  BOTTOM w0.094: v1(262.29,47.44) 262.09,47.64 261.69,47.64 261.44,47.39 261.44,45.93 261.6,45.77 JNGFF1.65
CLK_PCIE_N3: length 217.4
  IN1 w0.102: v1(152.05,103.72) 152.05,103.73 151.96,103.82 151.56,103.82 151.36,104.02 151.36,104.23 151.07,104.53 151.07,108.04 147.62,111.5 147.62,113.72 145.02,116.31 145.02,117.62 144.45,118.2 143.14,118.2 142.45,118.89 140.34,118.89 140.03,118.58 138.95,118.58 138.82,118.71 135.1,118.71 133.99,119.82 126.93,119.82 126.5,119.39 121.09,119.39 117.64,115.94 108.68,115.94 108.39,116.23 104.49,116.23 104.06,115.8 99.7,115.8 97.51,113.61 82.8,113.61 82.23,113.04 82.23,100.48 76.4,94.66 76.4,84.52 68.62,76.73 68.62,74.43 55.34,61.16 53.86,61.16 50.99,58.29 47.36,58.29 46.75,57.68 43.59,57.68 42.71,56.8 36.52,56.8 36.17,57.16 14.09,57.16 12.12,55.19 12.12,38.58 v1(12.49,38.21)
  BOTTOM w0.076: UC1.D40 150.94,101.59 151.02,101.85 151.02,101.97 151.1,102.25 151.14,102.4 151.15,102.42 151.16,102.45 151.16,102.69 151.12,102.79 151.12,102.79 151.12,102.98 151.14,103.04 151.16,103.08 151.21,103.17 151.21,103.55 151.66,104.01 151.86,104.01 152.05,103.82 v1(152.05,103.72)
  BOTTOM w0.094: v1(12.49,38.21) 12.29,38.01 12.29,35.82 12.45,35.66 JNGFF3.53
CLK_PCIE_N4: length 144.9
  TOP w0.094: UL1.45 261.2,90.33 261.08,90.21 261.08,89.73 v1(261.28,89.53)
  IN2 w0.122: v1(196.28,113.06) 196.28,112.44 196.52,112.19 199.48,112.19 199.91,111.77 214.48,111.77 214.94,111.3 218.73,111.3 221.6,114.17 226.02,114.17 226.41,114.56 242.96,114.56 244.13,113.39 257.3,113.39 258.84,111.86 258.84,110.96 259.45,110.35 259.45,106.92 261.07,105.29 261.07,97.06 261.97,96.16 261.97,91.26 261.28,90.56 v1(261.28,89.53)
  IN4 w0.102: v1(196.28,113.06) 196.17,113.17 196.17,113.53 195.98,113.73 168.43,113.73 168.19,113.49 164.86,113.49 160.67,109.3 160.67,109.1 159.35,107.78 159.35,106.6 158.47,105.72 157.3,105.72 156.81,105.23 151.8,105.23 v1(151.67,105.36)
  BOTTOM w0.076: UC1.B40 150.43,102.86 150.43,104.86 150.92,105.36 151.66,105.36 v1(151.67,105.36)
CLK_PCIE_N5: length 164.7
  TOP w0.094: v1(265.19,79.92) 265.36,80.1 265.56,80.1 265.71,79.95 UR2.6
  IN1 w0.102: v1(265.19,79.92) 265.01,80.09 264.72,80.09 264.45,80.36 264.45,83.84 267.13,86.52 267.13,87.07 267.98,87.92 267.98,89.36 269.25,90.63 269.25,107.21 268.64,107.82 268.64,108.24 v1(268.46,108.43)
  IN4 w0.102: v1(151.76,100.21) 151.76,100.21 151.97,100.42 152.25,100.42 152.83,101 152.83,101.95 153.67,102.79 157.79,102.79 159.2,104.2 159.2,105.28 160.18,106.26 160.18,106.89 161.5,108.21 161.5,108.96 164.84,112.29 167.71,112.29 167.73,112.31 172.29,112.31 172.64,111.96 174.45,111.96 175.37,112.87 194.22,112.87 194.62,112.47 204.82,112.47 205.9,111.39 212.78,111.39 213.78,110.4 214.33,110.4 214.68,110.74 218.51,110.74 221.17,113.41 222.02,113.41 223.7,115.1 240.56,115.1 246.79,108.86 254.98,108.86 256.35,110.23 265.04,110.23 266.35,108.93 268.51,108.93 268.64,108.8 268.64,108.61 v1(268.46,108.43)
  BOTTOM w0.076: UC1.E40 151.45,100.49 v1(151.76,100.21)
CLK_PCIE_P0: length 165.7
  IN4 w0.102: v1(284.96,102.41) 285.15,102.6 285.15,105.65 280.55,110.25 267.08,110.25 265.12,112.2 249.81,112.2 246.43,115.58 243.41,115.58 237.95,121.04 218.48,121.04 217.79,121.73 213.75,121.73 212.75,120.73 212.75,119.36 208.76,115.38 169.6,115.38 168.87,116.11 165.15,116.11 161.89,112.85 161.36,112.85 159.02,110.51 159.02,109.98 157.23,108.19 153.46,108.19 152.65,107.38 152.38,107.38 v1(152.19,107.19)
  BOTTOM w0.076: UC1.C42 149.7,101.81 149.84,101.81 149.92,101.89 149.92,102 149.7,102.22 149.41,102.22 149.33,102.47 149.33,102.65 149.39,102.84 149.39,102.99 149.33,103.1 149.33,103.39 149.49,103.55 149.49,106.66 150.44,107.61 151.83,107.61 152.19,107.25 v1(152.19,107.19)
  BOTTOM w0.094: JNGFF2.47 281.07,102.1 281.13,102.04 281.13,101.85 281.2,101.78 281.34,101.78 281.97,102.41 284.39,102.41 284.78,102.02 285.11,102.02 285.19,102.1 285.19,102.22 285.01,102.41 v1(284.96,102.41)
CLK_PCIE_P1: length 198.1
  IN2 w0.122: v1(253.32,111.27) 253.5,111.09 253.5,109.89 251.72,108.11 251.72,103.3 252.52,102.5 252.52,101.44 252.83,101.14 252.83,92.7 253.33,92.19 253.33,91 252.83,90.5 252.83,86.08 253.57,85.35 253.57,83.75 257.09,80.23 257.09,76.62 255.25,74.78 255.25,74.61 254.44,73.8 253.62,73.8 253.12,73.3 253.12,72.5 252.57,71.95 250.57,71.95 249.6,70.99 249.6,62.7 250.53,61.77 252.24,61.77 252.74,61.27 252.74,59.39 254.28,57.86 254.28,57.68 254.92,57.03 254.92,56.01 255.21,55.73 255.21,46.7 v1(255.06,46.55)
  IN4 w0.102: v1(253.32,111.27) 253.49,111.1 253.49,110.9 253.39,110.8 246.91,110.8 237.07,120.64 218.25,120.64 217.58,121.31 214.04,121.31 213.26,120.52 213.26,119.22 209,114.97 169.36,114.97 168.63,115.7 165.32,115.7 161.97,112.35 161.44,112.35 159.42,110.34 159.42,109.81 157.4,107.78 153.7,107.78 152.72,106.8 151.86,106.8 v1(151.66,107)
  BOTTOM w0.076: UC1.A42 149.64,103.21 149.7,103.27 149.7,106.09 150.2,106.59 151.31,106.59 151.51,106.79 151.67,106.79 151.74,106.85 151.74,106.92 v1(151.66,107)
  BOTTOM w0.094: v1(255.06,46.55) 255.26,46.35 255.26,45.87 255.1,45.71 JNGFF1.39
CLK_PCIE_P2: length 192.6
  IN2 w0.122: v1(262.29,48.02) 262.44,47.87 263.27,47.87 263.98,48.59 263.98,53.15 263.89,53.23 263.89,54.98 264.16,55.24 264.16,59.89 263.8,60.24 263.8,60.82 262.74,61.88 262.74,65.11 263.43,65.81 263.43,71.15 261.74,72.84 261.74,73.39 261.77,73.42 261.77,75.31 260.42,76.65 260.42,81.83 259.14,83.12 259.14,83.86 257.77,85.23 256.98,85.23 255.52,86.69 255.52,92.78 254.76,93.54 254.76,101.63 255.1,101.98 255.1,106.94 254.16,107.88 254.16,109.88 254.52,110.23 254.52,110.51 v1(254.23,110.79)
  IN4 w0.102: v1(152.19,106.2) 152.52,105.87 156.47,105.87 157.02,106.42 158.28,106.42 158.73,106.87 158.73,108.04 160.05,109.36 160.05,109.55 164.61,114.12 167.94,114.12 168.18,114.35 204.15,114.35 205.72,112.78 212.91,112.78 213.92,111.78 218.37,111.78 220.84,114.26 221.55,114.26 223.25,115.96 240.87,115.96 246.66,110.17 254.34,110.17 254.5,110.32 254.5,110.53 v1(254.23,110.79)
  BOTTOM w0.076: v1(152.19,106.2) 152.19,106.14 151.95,105.9 150.78,105.9 150.09,105.21 150.09,102.63 149.88,102.42 149.88,102.28 149.98,102.18 150.1,102.18 UC1.C41
  BOTTOM w0.094: v1(262.29,48.02) 262.09,47.82 261.61,47.82 261.26,47.47 261.26,45.93 261.1,45.77 JNGFF1.63
CLK_PCIE_P3: length 217.2
  IN1 w0.102: v1(152.05,104.35) 151.72,104.03 151.65,104.03 151.57,104.11 151.57,104.32 151.28,104.62 151.28,108.13 147.83,111.58 147.83,113.81 145.23,116.4 145.23,117.71 144.54,118.41 143.23,118.41 142.54,119.1 140.25,119.1 139.94,118.79 139.04,118.79 138.91,118.92 135.19,118.92 134.08,120.03 126.84,120.03 126.41,119.6 121,119.6 117.55,116.15 108.77,116.15 108.48,116.44 104.4,116.44 103.97,116.01 99.61,116.01 97.43,113.83 82.71,113.83 82.01,113.13 82.01,100.57 76.19,94.75 76.19,84.6 68.4,76.82 68.4,74.52 55.25,61.37 53.77,61.37 50.9,58.5 47.27,58.5 46.66,57.9 43.5,57.9 42.62,57.02 36.61,57.02 36.25,57.37 14.01,57.37 11.91,55.28 v1(11.91,38.21)
  BOTTOM w0.076: UC1.C40 150.91,102.22 150.99,102.47 150.99,102.65 150.93,102.84 150.93,102.99 151,103.11 151.04,103.21 151.04,103.62 151.6,104.17 151.85,104.17 151.87,104.19 151.88,104.19 v1(152.05,104.35)
  BOTTOM w0.094: v1(11.91,38.21) 12.11,38.01 12.11,35.82 11.95,35.66 JNGFF3.55
CLK_PCIE_P4: length 144.6
  TOP w0.094: v1(260.69,89.53) 260.89,89.73 260.89,90.23 260.8,90.33 UL1.44
  IN2 w0.122: v1(260.69,89.53) 261.06,89.9 261.06,90.65 261.76,91.35 261.76,96.07 260.86,96.97 260.86,105.2 259.23,106.83 259.23,110.26 258.62,110.87 258.62,111.77 257.21,113.18 244.04,113.18 242.87,114.35 226.5,114.35 226.11,113.95 221.69,113.95 218.82,111.08 214.86,111.08 214.39,111.55 199.82,111.55 199.39,111.98 196.43,111.98 196.07,112.35 196.07,112.7 v1(195.7,113.06)
  IN4 w0.102: v1(151.67,104.78) 151.9,105.01 156.9,105.01 157.39,105.51 158.55,105.51 159.56,106.52 159.56,107.69 160.88,109.02 160.88,109.21 164.95,113.28 168.28,113.28 168.52,113.52 195.89,113.52 195.96,113.45 195.96,113.33 v1(195.7,113.06)
  BOTTOM w0.076: UC1.A40 150.81,103.21 150.87,103.27 150.87,103.46 150.81,103.53 150.66,103.53 150.59,103.59 150.59,104.8 150.99,105.19 151.31,105.19 151.51,104.99 151.65,104.99 151.71,104.92 151.71,104.82 v1(151.67,104.78)
CLK_PCIE_P5: length 164.7
  TOP w0.094: v1(265.19,80.51) 265.41,80.29 265.64,80.29 265.71,80.35 UR2.5
  IN1 w0.102: v1(265.19,80.51) 264.99,80.31 264.81,80.31 264.67,80.45 264.67,83.75 267.34,86.43 267.34,86.98 268.2,87.83 268.2,89.27 269.47,90.54 269.47,107.3 268.86,107.91 268.86,108.24 v1(269.04,108.43)
  IN4 w0.102: v1(269.04,108.43) 268.85,108.62 268.85,108.89 268.6,109.14 266.44,109.14 265.13,110.45 256.26,110.45 254.89,109.07 246.88,109.07 240.65,115.31 223.62,115.31 221.93,113.62 221.08,113.62 218.42,110.96 214.59,110.96 214.24,110.61 213.86,110.61 212.87,111.6 205.99,111.6 204.91,112.68 194.71,112.68 194.31,113.08 175.28,113.08 174.37,112.17 172.73,112.17 172.38,112.53 167.64,112.53 167.62,112.51 164.75,112.51 161.29,109.05 161.29,108.3 159.97,106.98 159.97,106.35 158.99,105.37 158.99,104.29 157.71,103.01 153.58,103.01 152.62,102.04 152.62,101.09 152.16,100.63 151.97,100.63 v1(151.76,100.84)
  BOTTOM w0.076: UC1.E38 152.08,100.62 151.99,100.62 v1(151.76,100.84)
CLK_TP_SIO: length 75.2
  TOP w0.102: UE2.A37 v1(260.66,65.29) ; v1(283.28,12.02) 283.46,11.84 283.73,11.84 CZ31.1
  IN2 w0.122: v1(283.28,12.02) 283.12,11.85 280.51,11.85 279.97,12.39 279.97,17.29 277.14,20.12 277.14,21.04 277.36,21.25 277.36,22.08 277.2,22.24 277.2,23.24 277.62,23.66 277.62,24.86 v1(277.77,25.01)
  BOTTOM w0.102: v1(277.77,25.01) 277.61,25.18 277.61,38.61 278.85,39.86 278.85,51.08 276.3,53.63 272.86,53.63 272.03,54.45 272.03,54.89 271.51,55.41 271.19,55.73 271.19,55.74 270.99,55.94 270.78,56.16 270.76,56.16 266.89,60.03 265.2,60.03 264.28,60.95 264.28,61.93 261.73,64.49 260.07,64.49 259.73,64.83 259.73,65.17 259.84,65.29 v1(260.66,65.29) ; RZ19.2 283.7,11.84 283.46,11.84 v1(283.28,12.02) 283.1,11.83 282.94,11.83 RZ23.2
CLK_TP_SIO_R: length 3.7
  TOP w0.102: v1(280.51,11.03) 280.51,11.4 v2(280.4,11.51)
  BOTTOM w0.102: RZ23.1 281.28,12.18 280.51,11.41 v1(280.51,11.03) 280.51,10.51 280.28,10.27 JKBTP1.14
CLKDET#: length 16.4
  TOP w0.102: T121.1 180.92,75.14 178.88,77.18 177.05,77.18 v1(175.46,78.77)
  BOTTOM w0.076: v1(175.46,78.77) 175.09,78.41 171.86,78.41 169.93,80.33 169.93,81.29 170.03,81.39 170.03,81.68 169.74,81.97 UC1.AY8
CLKREQ_PCIE#0: length 171.3
  TOP w0.102: v1(192.8,77.17) 192.21,77.76 RC189.2
  IN1 w0.076: 179.01,78.02 179.01,78.26 177.05,80.22 174.77,80.22 173.64,81.34 173.64,82.71 172.36,83.99 171.65,83.99 171.1,83.44 170.53,83.44 170.36,83.61 169.82,83.61 169.63,83.8 169.63,84.13 v1(169.12,84.64)
  IN1 w0.084: 179.01,78.02 181.09,75.94 182.92,75.94 183.51,76.53 185.67,76.53 186.26,77.12 186.26,77.57 186.98,78.29 191.68,78.29 v1(192.8,77.17) 192.91,77.17 193.42,77.68 194.56,77.68 196.21,76.03 197.38,76.03 209.31,64.1 217.13,64.1 218.22,65.2 218.88,65.2 219.4,65.72 221.42,65.72 223.57,63.57 227.64,63.57 228.1,64.03 236.3,64.03 236.7,64.44 240.17,64.44 240.6,64.01 244.18,64.01 246.82,61.38 247.36,61.38 247.9,61.92 252.97,61.92 253.38,61.51 259.91,61.51 260.5,62.1 262.58,62.1 263.96,60.73 267.14,60.73 v1(267.99,61.58)
  BOTTOM w0.076: v1(169.12,84.64) 168.76,85 UC1.AR10
  BOTTOM w0.102: JNGFF2.44 265.25,101.35 264.45,100.55 264.45,97.82 267.15,95.12 267.15,92.63 265.9,91.37 264.14,91.37 263.04,90.27 263.04,86.21 264.2,85.05 264.2,71.13 265.01,70.32 265.01,66.53 266.91,64.63 266.91,62.73 267.99,61.65 v1(267.99,61.58)
CLKREQ_PCIE#1: length 119.5
  TOP w0.102: v1(192.81,77.76) 192.81,78.04 RC47.2
  IN1 w0.084: v1(192.81,77.76) 193.2,78.15 194.75,78.15 195.97,76.93 196.96,76.93 197.09,77.06 197.72,77.06 207.82,66.96 215.69,66.96 216.55,66.1 218.11,66.1 218.33,66.32 221.49,66.32 222.95,64.85 230.32,64.85 230.68,64.5 235.56,64.5 236.48,65.43 237.92,65.43 238.44,64.9 240.04,64.9 240.51,65.38 243.78,65.38 246.71,62.45 252.15,62.45 v1(252.79,63.09)
  IN2 w0.122: v1(170.04,84) 171.24,82.8 172.23,82.8 173.33,83.89 177.12,83.89 177.45,83.56 180.07,83.56 182.15,85.65 185.07,85.65 187.63,83.08 187.63,80.31 189.29,78.65 191.92,78.65 v1(192.81,77.76) ; v1(255.99,47.04) 255.93,47.1 255.93,56.03 255.65,56.32 255.65,57.74 253.5,59.89 253.5,62.38 v1(252.79,63.09)
  BOTTOM w0.076: v1(170.04,84) 170.39,84.35 UC1.AT7
  BOTTOM w0.102: JNGFF1.45 256.6,46.43 v1(255.99,47.04)
CLKREQ_PCIE#2: length 119.7
  TOP w0.102: RC50.2 v1(192.8,75.98)
  IN1 w0.076: v1(169.12,84) 168.74,83.62 168.74,83.03 168.98,82.79 169.57,82.79 169.75,82.61 170.55,82.61 170.72,82.79 170.92,82.79 171.79,83.66 172.1,83.66 172.8,82.96 172.8,80.33 175.02,78.11 176.62,78.11 177.79,76.94
  IN1 w0.084: 177.79,76.94 179.72,75.01 186.26,75.01 187.32,76.08 187.32,76.23 187.59,76.5 188.73,76.5 189.6,77.36 191.08,77.36 192.46,75.98 v1(192.8,75.98) 193.15,75.98 193.57,76.4 194.42,76.4 196.75,74.08 197.24,74.08 198.04,73.27 198.04,73.06 207.93,63.17 217.51,63.17 218.61,64.27 219.26,64.27 219.78,64.79 221.04,64.79 223.9,61.93 228.86,61.93 229.07,62.14 235.09,62.14 235.26,61.97 237.97,61.97 238.35,61.59 240.08,61.59 240.67,62.18 243.75,62.18 246.55,59.38 247.78,59.38 247.96,59.2 249.97,59.2 250.33,58.85 260.06,58.85 v1(261.41,57.49)
  BOTTOM w0.076: v1(169.12,84) 169.47,84.35 UC1.AT8
  BOTTOM w0.102: JNGFF1.60 260.35,56.05 259.93,56.47 259.93,57.74 260.11,57.92 260.98,57.92 v1(261.41,57.49)
CLKREQ_PCIE#3: length 239.5
  IN1 w0.076: 178.5,80.8 178.15,81.15 176.08,81.15 175.11,82.13 174.88,82.13 174.03,82.98 174.03,84.18 173.28,84.93 171.76,84.93 171.14,85.56 169.87,85.56 169.33,85.01 168.69,85.01 168.56,84.88 168.56,84.31 v1(168.24,83.98)
  IN1 w0.084: 178.5,80.8 181.79,77.5 182.33,77.5 v1(182.37,77.46)
  IN2 w0.122: v1(182.37,77.46) 182.13,77.22 181.04,77.22 176.34,72.53 173.19,72.53 171.07,70.4 171.07,67.64 165.53,62.11 99.65,62.11 99.11,62.65 93.84,62.65 91.69,60.5 84.96,60.5 79.96,55.51 77.85,55.51 77.71,55.37 71.15,55.37 69.97,56.54 68.53,56.54 68.42,56.43 65.22,56.43 64.24,57.41 63.02,57.41 62.29,58.14 60.41,58.14 59.97,57.7 51.02,57.7 50.14,56.82 50.14,56.17 49.45,55.48 45.29,55.48 44.93,55.84 42.95,55.84 42.43,56.35 39.13,56.35 38.57,55.79 33.44,55.79 32.74,56.49 25.44,56.49 25.11,56.16 8.15,56.16 5.98,54 5.98,49.77 5.48,49.26 5.48,45.11 6.74,43.85 9.38,43.85 v1(11.45,41.79)
  IN4 w0.084: JNGFF3.52 12.7,36.84 13.37,37.51 13.37,39.86 v1(11.45,41.79)
  BOTTOM w0.076: UC1.AT10 168.61,84.35 v1(168.24,83.98)
  BOTTOM w0.102: v1(182.37,77.46) 182.37,77.81 RC59.2
CLKREQ_PCIE#4: length 153.8
  TOP w0.102: v1(193.48,77.08) 193.13,76.73 192.51,76.73 192.37,76.87 RC51.2 ; RL4.1 264.45,89.16 v1(264.22,89.39) 263.38,90.23 262.52,90.23 262.4,90.35 UL1.48
  IN1 w0.076: v1(169.16,83.37) 169.22,83.37 169.81,82.77 170.48,82.77 170.98,83.28 171.17,83.28 171.72,83.83 172.17,83.83 173.48,82.52 173.48,80.77 174.55,79.7 176.18,79.7 178.52,77.36
  IN1 w0.084: v1(265.3,57.73) 265.02,58.01 261.58,58.01 260.61,58.98 260.61,59.39 260.09,59.91 259.04,59.91 258.43,59.31 254.04,59.31 253.51,59.85 250.15,59.85 249.94,60.06 246.53,60.06 243.53,63.07 240.51,63.07 239.8,62.36 238.78,62.36 238.23,62.91 237.29,62.91 236.98,62.6 229.13,62.6 228.66,63.07 223.42,63.07 221.23,65.26 219.59,65.26 219.07,64.74 218.42,64.74 217.32,63.64 209.1,63.64 197.18,75.56 195.92,75.56 194.4,77.08 v1(193.48,77.08) 193.02,76.63 192.47,76.63 191.27,77.83 187.17,77.83 186.73,77.38 186.73,76.14 186.06,75.48 180.4,75.48 178.52,77.36
  IN2 w0.122: v1(265.3,57.73) 265.3,57.73 265.3,60.36 264.94,60.72 264.94,61.4 263.92,62.43 263.92,64.63 264.65,65.36 264.65,66.87 265.05,67.26 265.05,70.39 264.22,71.22 264.22,80.3 264.87,80.95 264.87,82.48 264.22,83.13 v1(264.22,89.39)
  BOTTOM w0.076: UC1.AU8 169.5,83.7 v1(169.16,83.37)
CLKREQ_PCIE#5: length 125.6
  TOP w0.102: v1(265.47,81.61) 265.52,81.55 UR2.2 ; v1(189.37,79.29) 189.51,79.15 RC190.2
  IN1 w0.084: v1(189.37,79.29) 189.55,79.11 190.78,79.11 191.81,80.15 194.65,80.15 195.92,78.88 195.92,78.04 196.19,77.77 197.67,77.77 203.9,71.54 207.48,71.54 208.94,73 213.93,73 214.27,73.34 219.73,73.34 223.59,69.48 227.53,69.48 229.37,71.32 236.92,71.32 238.94,69.3 241.07,69.3 241.58,69.81 244.98,69.81 246.5,71.33 248.61,71.33 248.96,70.99 249.56,70.99 249.88,71.31 251.19,71.31 251.3,71.42 258.1,71.42 258.38,71.14 261.45,71.14 262.33,70.27 266,70.27 v1(266.76,71.03)
  IN2 w0.122: v1(265.47,81.61) 265.63,81.45 265.63,75.98 266.76,74.84 v1(266.76,71.03) ; v1(189.37,79.29) 188.14,80.52 188.14,83.29 185.27,86.15 181.94,86.15 179.86,84.06 177.69,84.06 177.36,84.4 176.1,84.4 175.5,85 172.51,85 171.41,83.89 v1(170.97,83.89)
  BOTTOM w0.076: v1(170.97,83.89) 170.77,83.7 UC1.AU7
CLKRUN#: length 123.1
  TOP w0.102: UE1.B20 236.17,70.85 v1(236.68,70.34) ; v1(258.2,60.89) 258.12,60.97 UE2.A32 ; RC27.1 173.71,75.83 v2(173.93,76.05) 174.03,76.15 v1(174.55,76.15)
  IN1 w0.102: v1(174.55,76.15) 178.04,72.67 180.9,72.67 181.54,72.03 181.54,71.3 182.38,70.47 196.95,70.47 206.17,61.25 229.15,61.25 229.36,61.46 234.27,61.46 v1(234.97,60.75) 234.97,60.89 235.38,61.3 237.69,61.3 238.07,60.92 240.36,60.92 240.95,61.51 243.47,61.51 246.27,58.71 247.5,58.71 248.25,57.96 250.05,57.96 250.25,58.16 259.18,58.16 v1(259.55,57.79)
  IN2 w0.102: v1(258.2,60.89) 258.2,59.37 259.55,58.02 v1(259.55,57.79)
  BOTTOM w0.076: 171.5,76.83 169.91,78.42 169.42,78.42 168.21,79.63 168.21,82.07 167.9,82.39 UC1.AW11
  BOTTOM w0.102: v1(234.97,60.75) 234.97,61.44 236.05,62.52 236.05,69.72 v1(236.68,70.34) ; 171.5,76.83 172.18,76.15 v1(174.55,76.15)
CMPIN: length 13.1
  TOP w0.102: v2(63.36,59.62) 63.26,59.52 PR830.2
  TOP w0.203: PU801.13 53.26,58 v1(52.55,58.71)
  TOP w0.254: PR830.2 PR832.1 PR831.2 PC833.1 58.89,59.52 v1(58.62,59.79)
  IN4 w0.254: v1(58.62,59.79) 58.4,59.57 53.03,59.57 52.55,59.09 v1(52.55,58.71)
CMPOUT: length 14.4
  TOP w0.102: v2(62.02,61.63) 61.82,61.43 PR833.2
  TOP w0.203: v1(51.92,58.68) 52.46,58.14 52.55,58.14 52.86,57.83 PU801.14
  TOP w0.254: v1(58.01,60.04) 58.01,60.49 58.54,61.02 58.87,61.02 PC834.2 PR834.1 PR833.2 PR832.2
  IN4 w0.254: v1(58.01,60.04) 52.87,60.04 51.92,59.09 v1(51.92,58.68)
COMP_IA: length 3.3
  TOP w0.203: PU602.16 90.39,88.05 90.46,87.98 90.46,88.01 v1(90.45,88.01)
  BOTTOM w0.102: v2(90.74,88.43) 90.45,88.14 v1(90.45,88.01)
  BOTTOM w0.254: PR639.2 PC636.2 90.08,87.47 90.46,87.85 90.46,88.01 v1(90.45,88.01)
COMP_VSA: length 3.9
  TOP w0.203: v1(87.88,91.66) 87.67,91.45 87.67,90.97 87.72,90.92 PU602.24
  BOTTOM w0.254: PR630.1 86.83,90.46 PC628.1 86.92,90.53 87.48,91.09 87.48,91.27 87.88,91.68 v1(87.88,91.66)
CONTACTLESS_DET#: length 198.7
  TOP w0.102: v1(222.32,58.56) 221.59,59.29 216.41,59.29 201.42,74.29 201.42,78.04 v2(201.84,78.46) 202.43,79.04 202.43,84.46 201.01,85.87 201.01,87.3 199.65,88.66 196.84,88.66 195.93,89.56 195.93,94.37 v1(195.53,94.77)
  IN3 w0.102: v1(195.53,94.77) 194.77,94.77 193.76,93.76 190.81,93.76 189.46,95.12 184.69,95.12 183.72,96.1 182,96.1 181.37,96.73 v1(180.58,96.73) 180.3,96.73 179.48,95.92 177.66,95.92 177.31,96.27 175.9,96.27 172.64,93.01 170.4,93.01 170.05,92.66 168.49,92.66 v1(168.44,92.6)
  IN4 w0.102: v1(295.78,9.33) 294.47,8.02 282.26,8.02 281.43,8.85 277.33,8.85 274.94,11.23 274.94,20.61 274.25,21.3 274.25,37.39 272,39.65 269.72,39.65 266.04,43.33 263.2,43.33 262.56,43.96 256.34,43.96 255.71,44.59 244.49,44.59 241.8,47.28 241.8,50.63 239.69,52.74 229.22,52.74 228.79,53.17 227.43,53.17 222.32,58.28 v1(222.32,58.56)
  BOTTOM w0.076: UC1.W11 168.09,92.95 v1(168.44,92.6)
  BOTTOM w0.102: JUSH1.4 295.4,8.95 v1(295.78,9.33) ; v1(180.58,96.73) 180.64,96.8 RC278.2
CORE_SNUB: length 1.3
  TOP w0.102: PC662.1 v2(105.95,107.02)
CORE_SW: length 0.7
  TOP w0.102: v1(107.86,102.08) v2(107.86,101.37)
  vias: v1(107.16,102.08)
CORE_VID0: length 101.9
  TOP w0.254: v1(237.12,81.23) 237.23,81.23 240.92,84.91 v2(243.08,84.91) 243.58,84.91 244.88,86.2 PR408.1
  IN2 w0.254: v1(237.12,81.23) 237.12,80.95 235.63,79.46 234.38,79.46 231.86,76.95 222.43,76.95 221.57,76.09 221.57,74.55 217.8,70.78 217.8,68.88 216.14,67.22 193.18,67.22 189.15,71.24 189.15,77.56 188.63,78.09 187.79,78.09 186.9,78.98 182.38,78.98 180.58,80.78 172.9,80.78 172,81.68 168.25,81.68 167.78,82.15 167.78,85.47 v1(168.21,85.91)
  BOTTOM w0.254: UC1.AN11 v1(168.21,85.91)
CORE_VID1: length 103.2
  TOP w0.254: v1(237.14,81.86) 240.62,85.34 v2(241.21,85.34) 243.34,85.34 243.99,85.99 PR411.1
  IN2 w0.254: v1(166.38,85.91) 166.85,85.44 166.85,82.46 167.98,81.33 171.85,81.33 172.75,80.43 180.43,80.43 182.23,78.62 186.75,78.62 187.64,77.73 188.48,77.73 188.8,77.42 188.8,71.09 193.03,66.86 216.29,66.86 218.16,68.73 218.16,70.63 221.93,74.4 221.93,75.95 222.57,76.59 232.01,76.59 234.53,79.11 235.78,79.11 237.6,80.93 237.6,81.4 v1(237.14,81.86)
  BOTTOM w0.254: UC1.AN13 v1(166.38,85.91)
CPU_B+: length 66.4
  IN2 w0.508: 99.91,98.21 99.91,96.8 98.94,95.83 90.84,95.83 89.65,97.02 88.83,97.02 85.3,93.49 85.3,90.83 84.81,90.33 81.95,90.33 81.21,91.07 v1(81.21,91.27)
  IN2 w0.762: 126.51,112.71 126.1,113.12 125.35,113.12 124.81,112.58 123.9,112.58 121.03,115.45 120.01,115.45 118.39,113.83 112.92,113.83 110.57,111.48 103.73,111.48 99.87,107.62 99.87,99.26
  BOTTOM w0.508: PR603.2 81.21,91.02 v1(81.21,91.27)
  vias: v1(101.62,99.59) v1(101.64,98.97) v1(127.04,112.18) v1(127.04,111.6) v2(101.01,99.59)
CPU_DP1_AUXN: length 13.6
  IN1 w0.076: 145.31,103.57 145.32,103.56 145.32,103.55 145.9,102.98 145.9,99.83 145.77,99.71 145.6,99.71 v1(145.34,99.45)
  IN1 w0.089: 145.31,103.57 144.21,104.67 144.21,109.05 144.36,109.2 144.5,109.2 144.72,108.98 v1(144.72,108.97)
  BOTTOM w0.076: UC1.G50 145.8,99.19 145.34,99.45 v1(145.34,99.45)
  BOTTOM w0.094: v1(144.72,108.97) 144.53,109.17 144.3,109.17 144.11,109.36 144.11,109.89 RC179.2
CPU_DP1_AUXP: length 13.3
  IN1 w0.076: 145.19,103.45 145.24,103.4 145.25,103.4 145.74,102.91 145.74,99.9 145.71,99.87 145.56,99.87 v1(145.34,100.09)
  IN1 w0.089: 145.19,103.45 144.04,104.6 144.04,109.12 144.29,109.37 144.54,109.37 144.72,109.55 v1(144.72,109.56)
  BOTTOM w0.076: v1(145.34,100.09) 145.81,99.85 UC1.F50
  BOTTOM w0.094: RC180.2 144.29,109.89 144.29,109.44 144.38,109.35 144.52,109.35 144.56,109.39 v1(144.72,109.56)
CPU_DP1_CTRL_CLK: length 102.9
  TOP w0.102: v1(176.81,95.19) 176.65,95.04 176.65,94.8 176.41,94.56 175.8,94.56 175.66,94.42 174.95,94.42 RC175.1
  IN2 w0.122: v1(241.35,126.48) 240.8,125.93 240.8,125.03 240.53,124.76 238.16,124.76 237.63,125.29 229.66,125.29 228,123.64 221.4,123.64 220.93,123.16 212.04,123.16 211.24,122.37 204.91,122.37 203.2,120.65 199.92,120.65 198.57,119.3 198.57,118.36 193.85,113.63 193.85,110.22 194.38,109.69 194.38,101.49 194.1,101.21 193.8,101.21 v1(193.64,101.05)
  IN4 w0.076: v1(167.09,96.77) 167.23,96.63 167.23,96.4 167.42,96.21 170.46,96.21 170.47,96.21 170.49,96.21 ; v1(176.81,95.19) 176.61,95.4
  IN4 w0.084: 176.61,95.4 176.59,95.41 176.59,95.59 176.78,95.78 178.27,95.78 178.48,95.98 179.19,95.98 180.31,97.1 183.67,97.1 184.43,97.85 187.61,97.85 188.64,98.88 190.91,98.88 193.26,101.23 193.45,101.23 v1(193.64,101.05) ; v1(176.81,95.19) 176.35,94.74 175.89,94.74 175.62,94.48 174.84,94.48 173.11,96.21 170.49,96.21
  BOTTOM w0.076: v1(167.09,96.77) 166.79,97.15 UC1.L13
  BOTTOM w0.102: v1(241.35,126.48) 241.03,126.8 QV3.1
CPU_DP1_CTRL_DATA: length 102.9
  TOP w0.102: v1(176.23,95.19) 176.29,95.19 176.43,95.06 176.43,94.9 176.32,94.79 175.71,94.79 175.57,94.65 174.83,94.65 174.74,94.73 RC178.1
  IN2 w0.122: v1(193.64,101.63) 193.8,101.46 194,101.46 194.13,101.59 194.13,109.59 193.6,110.12 193.6,113.73 198.33,118.46 198.33,119.41 199.82,120.9 203.1,120.9 204.81,122.61 211.14,122.61 211.94,123.41 220.82,123.41 221.29,123.88 227.9,123.88 229.56,125.54 237.73,125.54 238.26,125.01 240.43,125.01 240.55,125.13 240.55,125.92 240.37,126.11 239.68,126.11 239.52,125.94 v1(239.52,125.5)
  IN4 w0.076: v1(167.79,96.78) 167.58,96.78 167.43,96.63 167.43,96.48 167.5,96.41 170.46,96.41 170.47,96.42 170.49,96.42 ; 176.38,95.4 176.38,95.35 v1(176.23,95.19)
  IN4 w0.084: v1(193.64,101.63) 193.45,101.44 193.17,101.44 190.82,99.09 188.55,99.09 187.52,98.07 184.34,98.07 183.59,97.31 180.22,97.31 179.1,96.19 178.39,96.19 178.19,95.99 176.69,95.99 176.38,95.68 176.38,95.4 ; 170.49,96.42 173.2,96.42 174.92,94.69 175.54,94.69 175.8,94.95 175.98,94.95 v1(176.23,95.19)
  BOTTOM w0.076: UC1.L12 v1(167.79,96.78)
  BOTTOM w0.102: QV3.4 238.92,125.5 239,125.42 239.45,125.42 v1(239.52,125.5)
CPU_DP1_HPD: length 129.1
  TOP w0.102: v1(169.69,96.78) 170.34,97.43 RC312.2 ; v1(251.18,128.2) v2(251.18,128.72)
  IN2 w0.102: v1(191.27,119.08) 190.52,118.33 190.52,101.73 v1(190.51,101.74)
  IN3 w0.102: v1(251.18,128.2) 250.89,127.91 250.89,120.26 248.4,117.78 229.04,117.78 228.15,118.66 228.15,122.36 225.57,124.94 218.5,124.94 217.85,124.29 215.68,124.29 215.08,124.89 211.02,124.89 208.56,122.42 206.67,122.42 203.62,119.38 200.39,119.38 199.73,120.04 192.22,120.04 v1(191.27,119.08) ; v1(169.69,96.78) 170.33,96.78 171.43,97.89 171.43,98.45 172.98,100 172.98,101.09 172.34,101.74 172.34,102.55 172.96,103.17 176.95,103.17 177.72,102.4 181.19,102.4 182.39,101.2 189.97,101.2 v1(190.51,101.74)
  BOTTOM w0.076: UC1.L9 v1(169.69,96.78)
  BOTTOM w0.102: v1(251.18,128.2) 250.67,128.71 RV22.1 250.6,131.21 QV5.3
CPU_DP1_N0: length 108.4
  IN4 w0.084: v1(142.61,100.71) 142.79,100.53 143.09,100.53 143.29,100.73 143.29,102 143.61,102.32 148.37,102.32 149.44,103.39 149.44,104.26 149.97,104.79 149.97,107.21 152.35,109.59 156.65,109.59 157.61,110.56 157.61,111.09 159.46,112.94 159.46,113.49 160.48,114.51 161.56,114.51 164.56,117.51 169.9,117.51 170.14,117.27 177.59,117.27 177.91,116.95 179.04,116.95 179.37,117.27 180.7,117.27 181.01,116.96 183.32,116.96 183.62,117.27 205.83,117.27 212.35,123.79 214.74,123.79 215.4,123.13 221,123.13 221.62,123.76 227.78,123.76 229.35,125.33 233.13,125.33 233.39,125.07 v1(233.39,124.27)
  BOTTOM w0.076: UC1.E55 v1(142.61,100.71)
  BOTTOM w0.094: v1(233.39,124.27) 233.18,124.47 233.18,124.97 CV18.2
CPU_DP1_N1: length 112.3
  IN4 w0.084: v1(235.15,124.27) 234.96,124.46 234.96,125.45 234.53,125.88 229.12,125.88 227.59,124.35 221.43,124.35 220.82,123.73 215.58,123.73 214.97,124.35 212.12,124.35 207.11,119.34 204.85,119.34 203.81,118.3 198.83,118.3 198.48,118.65 193.38,118.65 192.77,118.04 189.5,118.04 188.89,118.65 168.93,118.65 168.01,119.57 165.69,119.57 162.57,116.45 161.55,116.45 157.4,112.29 157.4,111.66 157.06,111.32 157.06,110.79 156.6,110.33 152.25,110.33 149.31,107.39 149.31,105.04 148.21,103.93 148.21,103.54 147.57,102.9 143.33,102.9 141.74,101.32 141.37,101.32 141.15,101.09 141.15,100.78 141.08,100.71 v1(140.78,100.71)
  BOTTOM w0.076: UC1.E58 v1(140.78,100.71)
  BOTTOM w0.094: CV22.2 234.95,124.95 234.95,124.47 v1(235.15,124.27)
CPU_DP1_N2: length 106
  IN4 w0.084: v1(143.52,100.08) 143.73,99.87 143.84,99.87 143.9,99.93 143.9,100.97 144.27,101.34 149.18,101.34 150.07,102.24 150.07,104.12 150.64,104.69 150.64,107.06 152.62,109.04 156.87,109.04 158.16,110.33 158.16,110.86 161.04,113.74 161.57,113.74 164.79,116.96 169.32,116.96 169.63,116.65 177.42,116.65 177.68,116.39 179.27,116.39 179.53,116.65 180.31,116.65 180.68,116.28 183.59,116.28 183.96,116.65 200.29,116.65 200.66,116.28 205.62,116.28 212.58,123.24 214.51,123.24 215.17,122.58 221.23,122.58 221.84,123.19 227.99,123.19 229.58,124.77 231.3,124.77 231.52,124.56 231.52,124.15 v1(231.59,124.08)
  BOTTOM w0.076: UC1.F53 v1(143.52,100.08)
  BOTTOM w0.094: v1(231.59,124.08) 231.39,124.28 231.39,124.95 CV29.2
CPU_DP1_N3: length 119.7
  IN4 w0.076: v1(141.69,100.08) 141.69,99.97 141.16,99.44 141.16,99.27 140.95,99.07 140.52,99.07 140.4,99.19 140.4,101.49 140.4,101.5 140.4,101.52
  IN4 w0.084: 140.4,101.52 140.4,102.25 141.45,103.29 147.2,103.29 147.7,103.79 147.7,104.12 148.54,104.96 148.54,107.91 151.36,110.73 156.44,110.73 156.67,110.96 156.67,111.51 157.01,111.85 157.01,112.47 161.38,116.83 162.41,116.83 165.53,119.96 168.23,119.96 169.13,119.06 189.66,119.06 190.28,118.44 192.59,118.44 193.22,119.06 198.71,119.06 199.08,118.69 201.18,118.69 201.59,119.1 204,119.1 204.67,119.77 206.99,119.77 211.96,124.74 215.13,124.74 215.74,124.13 217.86,124.13 218.48,124.74 227.43,124.74 228.96,126.27 234.93,126.27 235.75,125.45 235.75,124.25 236.1,123.9 236.51,123.9 236.71,124.09 236.71,124.26 v1(236.92,124.47)
  BOTTOM w0.076: UC1.F56 v1(141.69,100.08)
  BOTTOM w0.094: CV14.2 236.72,124.94 236.72,124.67 v1(236.92,124.47)
CPU_DP1_P0: length 108.4
  IN4 w0.084: v1(142.61,100.08) 142.61,100.16 142.81,100.36 143.16,100.36 143.46,100.66 143.46,101.93 143.68,102.15 148.44,102.15 149.6,103.32 149.6,104.19 150.14,104.72 150.14,107.15 152.42,109.43 156.71,109.43 157.78,110.49 157.78,111.02 159.62,112.87 159.62,113.42 160.55,114.34 161.63,114.34 164.63,117.35 169.83,117.35 170.07,117.1 177.52,117.1 177.84,116.78 179.11,116.78 179.44,117.1 180.64,117.1 180.94,116.8 183.38,116.8 183.69,117.1 205.9,117.1 212.42,123.63 214.67,123.63 215.33,122.97 221.07,122.97 221.69,123.59 227.85,123.59 229.42,125.16 233.06,125.16 233.22,125 233.22,124.69 v1(232.8,124.27)
  BOTTOM w0.076: UC1.F55 v1(142.61,100.08)
  BOTTOM w0.094: CV17.2 233,124.94 233,124.47 v1(232.8,124.27)

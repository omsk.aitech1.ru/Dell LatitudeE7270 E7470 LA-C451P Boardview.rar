# Allegro board LAC451PR10-0923B.brd (continued)
## Footprints (pads in the part's own frame, mm; a bottom-side part is the same pattern mirrored in y, then rotated) (continued)
SW_SKRBAAE010_4P
  rect 0.889x1.219 smd: 1(0,0) 2(3.9,0) 3(0,4.075) 4(3.9,4.075)
SW_SS3-CMFTQR9_3P
  oval 0.991x2.489 smd: 1(0,0) 2(2,0) 3(4,0)
  round 1.651 hole 0.889: 4(-0.15,-3.75) 5(6.15,-3.75)
SY6288D20AAC_SOT23-5
  oval 0.559x0.787 smd: 1(0,0) 2(0.95,0) 3(1.9,0) 4(1.9,2.4) 5(0,2.4)
SY8032ABC_SOT23-6
  oval 0.61x0.991 smd: 1(0,0) 2(0.95,0) 3(1.9,0) 4(1.9,2.4) 5(0.95,2.4) 6(0,2.4)
SY8286BRAC_QFN20_3X3
  oval 0.889x0.254 smd: 1(0,0) 2(0,-0.45) 3(0,-0.9) 4(0,-1.35) 5(0,-1.8) 11(3.1,-1.8) 12(3.1,-1.35) 13(3.1,-0.9) 14(3.1,-0.45) 15(3.1,0)
  oval 0.254x0.889 smd: 6(0.65,-2.45) 7(1.1,-2.45) 8(1.55,-2.45) 9(2,-2.45) 10(2.45,-2.45) 16(2.45,0.65) 17(2,0.65) 18(1.55,0.65) 19(1.1,0.65) 20(0.65,0.65)
  rect 0.991x0.991 smd: 21(1.55,-0.9)
SY8286CRAC_QFN20_3X3
  oval 0.889x0.254 smd: 1(0,0) 2(0,-0.45) 3(0,-0.9) 4(0,-1.35) 5(0,-1.8) 11(3.1,-1.8) 12(3.1,-1.35) 13(3.1,-0.9) 14(3.1,-0.45) 15(3.1,0)
  oval 0.254x0.889 smd: 6(0.65,-2.45) 7(1.1,-2.45) 8(1.55,-2.45) 9(2,-2.45) 10(2.45,-2.45) 16(2.45,0.65) 17(2,0.65) 18(1.55,0.65) 19(1.1,0.65) 20(0.65,0.65)
  rect 0.991x0.991 smd: 21(1.55,-0.9)
SYX196DQNC_QFN10_3X3
  oval 0.254x0.61 smd: 1(0,0) 2(0.45,0) 3(0.9,0) 4(1.35,0) 5(1.8,0) 6(2.25,0)
  rect 1.118x0.229 smd: 7(2.215,-0.662)
  rect 0.864x2.007 smd: 8(2.09,-2)
  custom 0.47x0.47 smd: 9(1.077,-1.775)
  rect 0.787x1.143 smd: 10(0.113,-1.6)
T-SOL_5-991503004000-6_8P-T
  round 0.787 hole 0.787 unplated: (-1.39,-11.52)
  round 1.092 hole 1.092 unplated: (10.31,0.48)
  oval 0.889x1.092 smd: 1(0,0) 2(2.54,0) 3(5.08,0) 4(7.62,0) 5(0,-13.48) 6(2.54,-13.48) 7(5.08,-13.48) 8(7.62,-13.48)
  rect 0.889x0.813 smd: 9(-2.94,3.44)
  rect 1.245x1.803 smd: 10(-3.39,-13.33)
  rect 1.245x1.397 smd: 11(-3.39,-5.33)
  rect 1.295x1.016 smd: 12(-0.715,3.56) 13(9.535,3.56)
  rect 1.041x1.397 smd: 14(12.105,0.87)
  rect 0.94x1.397 smd: 15(12.555,-6.62)
  rect 1.219x1.143 smd: 16(10.8,-13.65)
T-SOL_156-2000302608_19P_NR
  round 0.889 hole 0.889 unplated: (-7.075,-28.925) (13.425,-1.825)
  oval 0.787x1.651 smd: 1(0,0) 2(1.4,0) 3(2.8,0) 4(4.2,0) 5(7.1,0) 6(9.9,0) 7(11.3,0) 8(12.7,0) 9(-1.4,0) 18(8.5,0) 19(14.1,0)
  oval 1.346x0.787 smd: 10(-9.2,-22.975) 11(-9.2,-24.075) 12(-9.2,-25.175) 13(-9.2,-26.275) 14(20.05,-26.275) 15(20.05,-25.175) 16(20.05,-24.075) 17(20.05,-22.975)
  rect 1.397x1.448 smd: 20(17.2,0.6) 21(5.65,0.6) 22(-6.35,0.6)
  rect 1.448x1.397 smd: 23(19.525,-6.575) 24(-8.675,-6.575) 25(19.525,-20.675) 26(-8.675,-18.825)
TAIYO_BRC2012T4R7MD_2P
  rect 0.61x1.448 smd: 1(0,0) 2(1.6,0)
TAIYO_FBMJ4516HS720NT_2P
  rect 1.549x1.854 smd: 1(0,0) 2(3.95,0)
TAIYO_MCF12102G900-T_4P-NPM
  rect 0.508x0.305 smd: 1(0,0) 2(0,-0.55) 3(1.25,-0.55) 4(1.25,0)
TC7SH08FU_SSOP5
  oval 0.406x0.787 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.3,1.9) 5(0,1.9)
TOKO_FDVE1040-H-3R3M-P3_2P
  rect 3.81x3.988 smd: 1(0,0) 2(9.8,0)
TPC12
  round 0.305 smd: 1(0,0)
TPS22961DNYR_WSON8
  oval 0.305x0.508 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.95,0) 5(1.95,2.7)
  oval 1.6x0.508 smd: 6(0.65,2.7)
  rect 2.388x1.6 smd: 7(0.975,1.35)
TPS22966DPUR_SON14_2X3
  oval 0.203x0.762 smd: 1(0,0) 2(0.4,0) 3(0.8,0) 4(1.2,0) 5(1.6,0) 6(2,0) 7(2.4,0) 8(2.4,2.05) 9(2,2.05) 10(1.6,2.05) 11(1.2,2.05) 12(0.8,2.05) 13(0.4,2.05) 14(0,2.05)
  rect 2.489x0.889 smd: 15(1.2,1.025)
TPS62134BRGT_QFN16_3X3
  oval 0.889x0.254 smd: 1(0,0) 2(0,-0.5) 3(0,-1) 4(0,-1.5) 9(3.1,-1.5) 10(3.1,-1) 11(3.1,-0.5) 12(3.1,0)
  oval 0.254x0.889 smd: 5(0.8,-2.3) 6(1.3,-2.3) 7(1.8,-2.3) 8(2.3,-2.3) 13(2.3,0.8) 14(1.8,0.8) 15(1.3,0.8) 16(0.8,0.8)
  rect 1.702x1.702 smd: 17(1.55,-0.75)
TPS62134CRGT_QFN16_3X3
  oval 0.889x0.254 smd: 1(0,0) 2(0,-0.5) 3(0,-1) 4(0,-1.5) 9(3.1,-1.5) 10(3.1,-1) 11(3.1,-0.5) 12(3.1,0)
  oval 0.254x0.889 smd: 5(0.8,-2.3) 6(1.3,-2.3) 7(1.8,-2.3) 8(2.3,-2.3) 13(2.3,0.8) 14(1.8,0.8) 15(1.3,0.8) 16(0.8,0.8)
  rect 1.702x1.702 smd: 17(1.55,-0.75)
TS5A63157DCKR_SC70-6
  oval 0.406x0.889 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.3,2.2) 5(0.65,2.2) 6(0,2.2)
TVNST52302AB0_SOT523-3
  oval 0.508x0.559 smd: 1(0,0) 2(-0.5,-1.4) 3(0.5,-1.4)
TYCO_2-1775293-2_2P
  oval 0.787x1.6 smd: 1(0,0) 2(-1.25,0)
  rect 2.108x2.997 smd: 3(2.55,2.9) 4(-3.8,2.9)
VMM3320BJGR_BGA_168P-NH
  round 0.279 smd: A1(0,0) A2(0.65,0) A3(1.3,0) A4(1.95,0) A5(2.6,0) A6(3.25,0) A7(3.9,0) A8(4.55,0) A9(5.2,0) A10(5.85,0) A11(6.5,0) A12(7.15,0) A13(7.8,0) A14(8.45,0) B1(0,-0.65) B2(0.65,-0.65) B3(1.3,-0.65) B4(1.95,-0.65) B5(2.6,-0.65) B6(3.25,-0.65) B7(3.9,-0.65) B8(4.55,-0.65) B9(5.2,-0.65) B10(5.85,-0.65) B11(6.5,-0.65) B12(7.15,-0.65) B13(7.8,-0.65) B14(8.45,-0.65) C1(0,-1.3) C2(0.65,-1.3) C3(1.3,-1.3) C4(1.95,-1.3) C5(2.6,-1.3) C6(3.25,-1.3) C7(3.9,-1.3) C8(4.55,-1.3) C9(5.2,-1.3) C10(5.85,-1.3) C11(6.5,-1.3) C12(7.15,-1.3) C13(7.8,-1.3) C14(8.45,-1.3) D1(0,-1.95) D2(0.65,-1.95) D3(1.3,-1.95) D4(1.95,-1.95) D5(2.6,-1.95) D6(3.25,-1.95) D7(3.9,-1.95) D8(4.55,-1.95) D9(5.2,-1.95) D10(5.85,-1.95) D11(6.5,-1.95) D12(7.15,-1.95) D13(7.8,-1.95) D14(8.45,-1.95) E1(0,-2.6) E2(0.65,-2.6) E3(1.3,-2.6) E4(1.95,-2.6) E5(2.6,-2.6) E6(3.25,-2.6) E7(3.9,-2.6) E8(4.55,-2.6) E9(5.2,-2.6) E10(5.85,-2.6) E11(6.5,-2.6) E12(7.15,-2.6) E13(7.8,-2.6) E14(8.45,-2.6) F1(0,-3.25) F2(0.65,-3.25) F3(1.3,-3.25) F4(1.95,-3.25) F5(2.6,-3.25) F6(3.25,-3.25) F7(3.9,-3.25) F8(4.55,-3.25) F9(5.2,-3.25) F10(5.85,-3.25) F11(6.5,-3.25) F12(7.15,-3.25) F13(7.8,-3.25) F14(8.45,-3.25) G1(0,-3.9) G2(0.65,-3.9) G3(1.3,-3.9) G4(1.95,-3.9) G5(2.6,-3.9) G6(3.25,-3.9) G7(3.9,-3.9) G8(4.55,-3.9) G9(5.2,-3.9) G10(5.85,-3.9) G11(6.5,-3.9) G12(7.15,-3.9) G13(7.8,-3.9) G14(8.45,-3.9) H1(0,-4.55) H2(0.65,-4.55) H3(1.3,-4.55) H4(1.95,-4.55) H5(2.6,-4.55) H6(3.25,-4.55) H7(3.9,-4.55) H8(4.55,-4.55) H9(5.2,-4.55) H10(5.85,-4.55) H11(6.5,-4.55) H12(7.15,-4.55) H13(7.8,-4.55) H14(8.45,-4.55) J1(0,-5.2) J2(0.65,-5.2) J3(1.3,-5.2) J4(1.95,-5.2) J5(2.6,-5.2) J6(3.25,-5.2) J7(3.9,-5.2) J8(4.55,-5.2) J9(5.2,-5.2) J10(5.85,-5.2) J11(6.5,-5.2) J12(7.15,-5.2) J13(7.8,-5.2) J14(8.45,-5.2) K1(0,-5.85) K2(0.65,-5.85) K3(1.3,-5.85) K4(1.95,-5.85) K5(2.6,-5.85) K6(3.25,-5.85) K7(3.9,-5.85) K8(4.55,-5.85) K9(5.2,-5.85) K10(5.85,-5.85) K11(6.5,-5.85) K12(7.15,-5.85) K13(7.8,-5.85) K14(8.45,-5.85) L1(0,-6.5) L2(0.65,-6.5) L3(1.3,-6.5) L4(1.95,-6.5) L5(2.6,-6.5) L6(3.25,-6.5) L7(3.9,-6.5) L8(4.55,-6.5) L9(5.2,-6.5) L10(5.85,-6.5) L11(6.5,-6.5) L12(7.15,-6.5) L13(7.8,-6.5) L14(8.45,-6.5) M1(0,-7.15) M2(0.65,-7.15) M3(1.3,-7.15) M4(1.95,-7.15) M5(2.6,-7.15) M6(3.25,-7.15) M7(3.9,-7.15) M8(4.55,-7.15) M9(5.2,-7.15) M10(5.85,-7.15) M11(6.5,-7.15) M12(7.15,-7.15) M13(7.8,-7.15) M14(8.45,-7.15)
W25Q64FVSSIQ_SO8
  oval 0.635x1.676 smd: 1(0,0) 2(1.27,0) 3(2.54,0) 4(3.81,0) 5(3.81,7.25) 6(2.54,7.25) 7(1.27,7.25) 8(0,7.25)
W25Q128FVSIQ_SO8
  oval 0.635x1.676 smd: 1(0,0) 2(1.27,0) 3(2.54,0) 4(3.81,0) 5(3.81,7.25) 6(2.54,7.25) 7(1.27,7.25) 8(0,7.25)
W25X10BVSNIG_SO8
  oval 0.635x1.854 smd: 1(0,0) 2(1.27,0) 3(2.54,0) 4(3.81,0) 5(3.81,5.165) 6(2.54,5.165) 7(1.27,5.165) 8(0,5.165)
WGI217LM-QPN9-A2_QFN48_6X6
  oval 0.203x1.041 smd: 1(0,0) 2(0.4,0) 3(0.8,0) 4(1.2,0) 5(1.6,0) 6(2,0) 7(2.4,0) 8(2.8,0) 9(3.2,0) 10(3.6,0) 11(4,0) 12(4.4,0) 25(4.4,5.95) 26(4,5.95) 27(3.6,5.95) 28(3.2,5.95) 29(2.8,5.95) 30(2.4,5.95) 31(2,5.95) 32(1.6,5.95) 33(1.2,5.95) 34(0.8,5.95) 35(0.4,5.95) 36(0,5.95)
  oval 1.041x0.203 smd: 13(5.175,0.775) 14(5.175,1.175) 15(5.175,1.575) 16(5.175,1.975) 17(5.175,2.375) 18(5.175,2.775) 19(5.175,3.175) 20(5.175,3.575) 21(5.175,3.975) 22(5.175,4.375) 23(5.175,4.775) 24(5.175,5.175) 37(-0.775,5.175) 38(-0.775,4.775) 39(-0.775,4.375) 40(-0.775,3.975) 41(-0.775,3.575) 42(-0.775,3.175) 43(-0.775,2.775) 44(-0.775,2.375) 45(-0.775,1.975) 46(-0.775,1.575) 47(-0.775,1.175) 48(-0.775,0.775)
  rect 2.997x2.997 smd: 49(2.2,2.975)
Y_7V25000034_4P
  rect 1.397x1.194 smd: 1(0,0) 2(2.2,0) 3(2.2,1.8) 4(0,1.8)
Y_9H03200042_2P
  rect 0.991x1.803 smd: 1(0,0) 2(2.5,0)
Y_Q13FC135000040_2P
  rect 0.991x1.803 smd: 1(0,0) 2(2.5,0)
Y_X1E000021042600_4P
  rect 1.397x1.143 smd: 1(0,0) 2(2.2,0) 3(2.2,1.6) 4(0,1.6)
Y_X3G024000DC1H_4P
  rect 1.397x1.194 smd: 1(0,0) 2(2.2,0) 3(2.2,1.7) 4(0,1.7)

## Nets
0.6V_DDR_VTT_ON: PR210.1 RD30.1 UD1.4
1.2V_B+: PC201.1 PC202.1 PC203.1 PC204.1 PJP202.2 PQ201.2 PR207.1
1.2V_FB: PC212.1 PR206.1 PR209.1 PU201.6
1.5VSP: PC509.1 PC511.1 PJP504.1 PR508.1 PU502.3 PU502.4
2.5VSP: PC1502.1 PC1503.1 PJP1500.1 PR1501.1 PU1500.3 PU1500.4
3.3V_CAM_EN#: QZ1.2 RC311.2 UC1.AT15
3.3V_HDD_EN: RC184.2 UC1.AN5 UZ4.5
3.3V_TP_EN: RC270.2 UC1.AM5
3.3V_TS_EN: QV7.2 RC282.2 UC1.AP5
3.3V_WWAN_EN: RZ40.2 UE1.B42 UZ2.3
3V5V_EN: PC128.1 PR114.2 PR116.1 PU100.12 PU102.12
3V_FB: PC113.1 PR109.2 PR110.1 PU100.13
3V_SN: PC112.1 PR106.2
3V_VIN: PC100.1 PC103.1 PC104.1 PC105.1 PJP100.2 PU100.2 PU100.3 PU100.4 PU100.5
5V_FB: PC127.1 PR115.2 PR118.1 PU102.13
5V_SN: PC125.1 PR112.2
5V_VIN: PC115.1 PC116.1 PC117.1 PC118.1 PJP101.2 PU102.2 PU102.3 PU102.4 PU102.5
+0.6V_DDR_VTT: CD24.1 CD25.1 CD26.1 CD27.1 CD28.1 CD29.1 CD57.1 CD58.1 CD59.1 CD60.1 CD61.1 CD62.1 JDIMM1.258 JDIMM2.258 PJP205.2
+0.6V_P: PC206.1 PJP205.1 PU201.2 PU201.20
+0.9V_LAN: CL3.1 CL4.1 CL8.1 CL9.1 CL10.1 CL11.1 CL12.1 LL1.2 UL1.8 UL1.11 UL1.16 UL1.22 UL1.37 UL1.40 UL1.43 UL1.46 UL1.47
+1.0V_AMPHYPLL: CC219.1 CC264.1 RC169.2 UC1.K15 UC1.L15
+1.0V_APLL: CC225.1 CC314.1 LC2.2 UC1.V15
+1.0V_APLLEBB: CC218.1 RC310.2 UC1.N18
+1.0V_CLK1: RC302.2 UC1.A14
+1.0V_CLK2: CC220.1 RC170.2 UC1.K19
+1.0V_CLK3: RC303.2 UC1.L21
+1.0V_CLK4: CC226.1 RC173.2 UC1.N20
+1.0V_CLK5: CC221.1 RC52.2 RC171.2 UC1.L19
+1.0V_CLK6: CC216.1 RC300.2 UC1.A10
+1.0V_DTS: RC301.2 UC1.T1
+1.0V_MPHYAON: CC203.1 RC299.2 UC1.K17 UC1.L1
+1.0V_MPHYGT: CC210.1 CC211.1 CC281.1 CZ85.1 PJP35.2 RC169.1 RC309.1 RC310.1 UC1.N15 UC1.N16 UC1.N17 UC1.P15 UC1.P16 UZ20.6
+1.0V_PRIM: CC206.1 CC273.1 CC283.1 CC284.1 CC285.1 CC286.1 CZ84.1 CZ87.1 CZ95.1 LC2.1 PJP35.1 PJP302.2 RC170.1 RC171.1 RC173.1 RC194.1 RC216.1 RC299.1 RC300.1 RC301.1 RC302.1 RC303.1 UC1.AB17 UC1.AB19 UC1.AB20 UC1.AK20 UC1.P18 UC1.Y18 UZ19.1 UZ19.2 UZ19.7 UZ20.1 UZ20.2 UZ20.7 UZ21.1 UZ21.2 UZ21.7
+1.0V_PRIM_CORE: CC205.1 CC274.1 PJP402.2 RC194.2 UC1.AF18 UC1.AF19 UC1.V20 UC1.V21
+1.0V_PRIM_COREP: PC415.1 PC416.1 PC424.1 PJP402.1 PL404.2 PR423.2 PU402.1
+1.0V_PRIM_XDP: CC28.1 CC29.1 JXDP1.43 JXDP1.44 RC115.2 RC138.1 RC216.2
+1.0V_RUN_VMM: CV615.1 CV617.2 LV22.1 LV23.1 RV659.1 RV661.1 UV28.6 UV29.3 UV29.4 UV29.5
+1.0V_SRAM: CC217.1 RC309.2 UC1.AF20 UC1.AF21 UC1.T19 UC1.T20
+1.0V_VCCST: CC195.1 CC202.1 PC602.1 PJP27.1 PR601.1 PR604.1 PR605.1 RC71.1 RC79.1 RC80.1 RC120.2 RC152.1 RC157.1 RC218.1 RC238.2 UC1.A18 UC1.K20 UC1.K21
+1.0V_VCCST_C: CZ78.1 PJP27.2 UZ21.6
+1.0V_VCCSTG: CC199.1 PJP32.1 RC81.1 RC82.1 RC83.1 RC87.2 RC130.1 RC131.1 RC134.1 RC135.1 RC143.2 RC238.1 UC1.A22
+1.0V_VCCSTG_C: CZ82.1 PJP32.2 UZ19.6
+1.0V_VCCSTG_R: RC143.1 UC1.G20
+1.0V_VMM_VDD: CV82.1 CV83.1 CV84.1 CV85.1 CV86.1 CV87.1 CV88.1 CV89.1 LV22.2 UV8.C8 UV8.C9 UV8.D3 UV8.E3 UV8.E6 UV8.E7 UV8.E8 UV8.E9 UV8.F12 UV8.G3 UV8.G12 UV8.H6 UV8.H7 UV8.H8 UV8.H9
+1.0V_VMM_VDDTX: CV90.1 CV91.1 CV92.1 CV93.1 LV23.2 UV8.C6 UV8.C7 UV8.D12 UV8.E12 UV8.F3 UV8.J2 UV8.J10 UV8.K8 UV8.K9 UV8.K10
+1.0VO_DSW: CC204.1 UC1.AL1
+1.0VS_VCCIO: CC181.1 CC182.1 CC185.1 CC186.1 CC248.1 CC249.1 CC250.1 CC251.1 CC252.1 CC253.1 CV616.1 PJP401.2 QE11.1 RC2.1 RC132.1 RC165.1 RE59.2 RE90.1 UC1.AK28 UC1.AK30 UC1.AL30 UC1.AL42 UC1.AM28 UC1.AM30 UC1.AM42 UV8.E5 UV8.J3 UV28.1 UV28.2 UV28.7
+1.2V_LDO: CR9.1 CR10.1 CR13.1 UR2.10 UR2.14
+1.2V_MEM: CC174.1 CC175.1 CC176.1 CC177.1 CC178.1 CC179.1 CC254.1 CC255.1 CC256.1 CC257.1 CC282.2 CC286.2 CC294.1 CC295.1 CC296.1 CD2.1 CD3.1 CD4.1 CD7.1 CD8.1 CD9.1 CD10.1 CD11.1 CD12.1 CD13.1 CD14.1 CD15.1 CD16.1 CD17.1 CD18.1 CD19.1 CD20.1 CD30.1 CD37.1 CD38.1 CD39.1 CD40.1 CD41.1 CD42.1 CD43.1 CD44.1 CD45.1 CD46.1 CD47.1 CD48.1 CD49.1 CD50.1 CD51.1 CD52.1 CD53.1 CD78.1 CD79.1 CD80.1 CD81.1 CD82.1 CD83.1 CD84.1 CD85.1 CD86.1 CD87.1 CD88.1 CD89.1 CD90.1 CD91.1 CD92.1 CD93.1 CD94.1 CD95.1 CD96.1 CD97.1 CD98.1 CD99.1 CD100.1 CD101.1 CD102.1 CD103.1 CD104.1 CD105.1 CD106.1 CD107.1 CD108.1 CD109.1 CZ113.1 JDIMM1.12 JDIMM1.33 JDIMM1.54 JDIMM1.75 JDIMM1.96 JDIMM1.111 JDIMM1.112 JDIMM1.117 JDIMM1.118 JDIMM1.123 JDIMM1.124 JDIMM1.129 JDIMM1.130 JDIMM1.135 JDIMM1.136 JDIMM1.141 JDIMM1.142 JDIMM1.147 JDIMM1.148 JDIMM1.153 JDIMM1.154 JDIMM1.159 JDIMM1.160 JDIMM1.163 JDIMM1.178 JDIMM1.199 JDIMM1.220 JDIMM1.241 JDIMM2.12 JDIMM2.33 JDIMM2.54 JDIMM2.75 JDIMM2.96 JDIMM2.111 JDIMM2.112 JDIMM2.117 JDIMM2.118 JDIMM2.123 JDIMM2.124 JDIMM2.129 JDIMM2.130 JDIMM2.135 JDIMM2.136 JDIMM2.141 JDIMM2.142 JDIMM2.147 JDIMM2.148 JDIMM2.153 JDIMM2.154 JDIMM2.159 JDIMM2.160 JDIMM2.163 JDIMM2.178 JDIMM2.199 JDIMM2.220 JDIMM2.241 PJP201.2 PJP204.2 RC119.1 RC231.2 RD2.1 RD18.1 RD22.1 UC1.AU23 UC1.AU28 UC1.AU35 UC1.AU42 UC1.BB23 UC1.BB32 UC1.BB41 UC1.BB47 UC1.BB51 UD1.5 UZ26.1 UZ26.2 UZ26.7
+1.2V_MEM_CPUCLK: CC194.1 CC297.1 RC231.1 UC1.AM40
+1.2V_MEN_P: PC212.2 PC213.1 PC215.1 PC216.1 PC217.1 PC218.1 PC219.1 PC220.1 PJP201.1 PJP203.2 PJP204.1 PL201.1 PR206.2 PU201.5
+1.5V_RUN: PJP504.2 RA3.1
+1.5V_RUN_AUDIO: CA16.1 RA3.2 UA1.40
+1.5V_VIN: PC508.1 PJP503.2 PU502.5 PU502.9
+1.8V_PGPPF: RC304.2 UC1.AF16
+1.8V_PRIM: CC212.1 CC272.1 CV618.1 PJP502.2 RC212.1 RC234.1 RC304.1 RC313.1 UC1.AA1 UV29.6 UV29.7 UV29.8
+1.8V_RUN_CARD: CR40.2 CR41.2 JSD1.14 UR2.13
+1.8VALWP: PC501.1 PC503.1 PC504.1 PJP502.1 PL501.2 PR501.1
+1VALWP: PC307.1 PC308.1 PC309.1 PC310.1 PC311.1 PJP302.1 PL301.2 PR306.1
+1VALWP_B+: PC301.1 PC303.1 PC305.1 PC306.1 PJP301.2 PU301.8
+1VS_VCCIOP: PC406.1 PC407.1 PC422.1 PJP401.1 PL402.2 PR421.1 PU401.1
+2.5V_MEM: CD70.1 CD71.1 CD72.1 CD73.1 CD74.1 CD75.1 CD76.1 CD77.1 JDIMM1.257 JDIMM1.259 JDIMM2.257 JDIMM2.259 PJP1500.2
+2.5V_VIN: PC1501.1 PJP1501.2 PU1500.5 PU1500.9
+3.3V_1.8V_PGPPA: RC211.2 RC212.2 UC1.AK15
+3.3V_1.8V_PGPPG: RC234.2 RC235.2 UC1.AD15
+3.3V_ALW: CC271.1 CE1.1 CE21.1 CE52.1 CV10.1 CZ12.1 CZ28.1 CZ34.1 CZ48.1 CZ71.1 CZ72.1 CZ115.1 JKBTP1.6 JLED1.8 JUSH1.11 JUSH1.12 JUSH1.13 PC101.2 PC312.1 PC903.2 PJP14.1 PJP15.1 PJP102.2 PJP501.1 PJP1501.1 PR3.1 PR6.2 PR107.1 PR113.1 PR307.1 PR404.1 PR410.1 PR413.1 PR414.1 PR417.1 PR418.1 PR834.2 PR902.1 PR903.1 PR905.1 PR913.1 PR931.2 PU101.5 PU301.7 PU902.5 RC68.2 RC214.1 RD30.2 RE5.1 RE8.1 RE9.1 RE10.1 RE11.1 RE12.1 RE25.1 RE35.1 RE36.1 RE38.1 RE63.1 RE68.1 RE69.1 RE71.1 RE72.1 RE73.1 RE74.1 RE75.1 RE79.1 RE81.1 RE84.2 RE298.2 RE300.1 RE301.2 RPE3.7 RPE3.8 RPE5.7 RPE6.5 RPE6.6 RPE6.7 RPE6.8 RPE7.5 RPE7.6 RPE7.7 RPE7.8 RPE9.5 RPE9.6 RPE9.7 RPE9.8 RPE11.5 RPE11.6 RPE11.7 RPE11.8 RZ8.1 RZ9.1 RZ24.1 UC13.5 UC14.5 UE3.5 UE4.5 UE5.5 UV24.5 UZ2.1 UZ2.2 UZ2.6 UZ2.7 UZ3.1 UZ3.2 UZ3.6 UZ3.7 UZ4.6 UZ4.7 UZ6.5 UZ8.1 UZ8.2 UZ10.5 UZ12.1 UZ22.1 UZ22.2
+3.3V_ALW2: CZ24.1 PC905.2 PR104.2 PR909.2 PR914.1 PR917.1 PR920.1 PR932.1 PU903.5 R272.2 RE57.2 RZ84.1
+3.3V_ALW2_R: JUSH1.25 RZ84.2
+3.3V_ALW_DSW: CC279.1 CC280.1 JAPS1.3 JAPS1.7 RC67.1 RC72.2 RC214.2 RC241.1 RC243.2 RC323.1 UC1.AD17 UC1.AD18 UC1.AJ17
+3.3V_ALW_PCH: CC209.1 CC215.1 CC223.1 CC224.1 JAPS1.1 LC1.1 PJP11.1 PJP19.2 RC12.2 RC14.2 RC15.2 RC17.2 RC23.2 RC25.2 RC26.2 RC73.2 RC74.1 RC133.1 RC183.1 RC184.1 RC186.1 RC187.1 RC211.1 RC222.1 RC235.1 RC283.1 RC288.2 RC289.2 RC305.1 RC306.1 RC307.1 RC308.1 RC317.2 RC330.1 RC331.1 RC341.2 RC344.2 RC346.1 RC347.2 RC348.2 RPC3.5 RPC3.6 RPC3.7 RPC3.8 UC1.AJ21 UC1.AK17 UC1.V19 UC7.5
+3.3V_ALW_PCH_UZ22: CZ40.1 PJP19.1 UZ22.7 UZ22.8
+3.3V_ALW_UE1: CE2.1 CE3.1 CE4.1 CE5.1 CE6.1 PJP14.2 UE1.A17 UE1.A43 UE1.A54 UE1.B5 UE1.B30
+3.3V_ALW_UE2: CE13.1 CE14.1 CE15.1 CE16.1 CE17.1 CE18.1 CE19.1 CE20.1 CE22.1 CE23.1 PJP15.2 UE2.A11 UE2.A22 UE2.A26 UE2.A41 UE2.A52 UE2.A58 UE2.B3 UE2.B35
+3.3V_ALWP: PC106.1 PC107.1 PC108.1 PC109.1 PC110.1 PJP102.1 PL100.2 PR108.2 PR109.1 PU100.14
+3.3V_CAM: CZ1.1 JEDP1.11 QZ1.1
+3.3V_HDD: CN19.1 CN20.1 CN29.1 CN30.1 PJP18.2 PJP34.2 PJP36.2 RN25.1 RN26.1 RN27.1 RN28.1 RN37.1 RN42.1 RN43.1 RN44.1 RN49.1 RN50.1 RN51.1 RN55.1 RN56.1 RN57.1 RN58.1 RN63.1 RN64.1 RN65.1 RN69.1 RN70.1 RN71.1 UN4.12 UN4.24 UN5.12 UN5.24
+3.3V_HDD_P: CN41.1 CN42.1 CZ60.1 CZ61.1 JNGFF3.2 JNGFF3.4 JNGFF3.12 JNGFF3.14 JNGFF3.16 JNGFF3.18 JNGFF3.62 JNGFF3.64 JNGFF3.66 PJP34.1
+3.3V_HDD_UZ4: CZ64.1 PJP18.1 UZ4.8 UZ4.9
+3.3V_LAN: CL15.1 CL18.1 CL19.1 CL25.1 CL26.1 CL27.1 JLOM1.9 JLOM1.12 PJP13.2 RC19.2 RC20.2 RL1.1 RL2.1 RL4.2 RL5.1 RL6.1 RL8.1 RL29.1 RL30.1 RL70.1 UL2.5 UL4.1 UL4.4 UL4.8 UL4.14 UL4.21 UL4.30 UL4.39
+3.3V_LAN_OUT: CL7.1 CL28.1 RL8.2 UL1.4 UL1.5 UL1.15 UL1.19 UL1.29
+3.3V_LAN_UZ2: CZ50.1 PJP13.1 UZ2.8 UZ2.9
+3.3V_M: PJP20.2 RC276.2 RZ72.1
+3.3V_M_TPM: CZ74.1 CZ75.1 CZ76.1 PJP11.2 QZ9.3 RZ69.1 RZ72.2 RZ88.1 UZ12.14 UZ12.22
+3.3V_M_UZ8: CZ43.1 PJP20.1 UZ8.7 UZ8.8
+3.3V_MMI_AUX: CR8.1 CR42.1 R274.1 RR16.1 RR19.1 UR2.27
+3.3V_MMI_IN: CR36.1 CR43.1 PJP26.2 R274.2 UR2.11
+3.3V_PGPPB: CC265.1 RC305.2 UC1.AG15
+3.3V_PGPPC: CC207.1 RC306.2 UC1.Y16
+3.3V_PGPPD: RC307.2 UC1.Y15
+3.3V_PGPPE: CC208.1 RC308.2 UC1.T16
+3.3V_RTC_LDO: PD1.3 PR105.2
+3.3V_RUN: CA7.1 CC30.2 CC285.2 CC287.2 CV61.1 CV62.1 CV66.1 CV69.1 CV70.1 CV510.1 CV600.1 CV601.1 CV602.1 CV603.1 CV604.1 CZ11.1 JEDP1.10 JLPDE1.1 JLPDE1.2 JUSH1.8 PJP10.1 PJP16.1 PJP22.2 PJP25.1 PJP26.1 PJP36.1 PJP503.1 PR507.1 PR612.1 QC2.2 QC2.5 QV3.2 QV3.5 QV5.2 QV8.3 QZ1.3 RC13.1 RC21.1 RC27.2 RC47.1 RC50.1 RC51.1 RC59.1 RC137.1 RC175.2 RC176.2 RC177.2 RC178.2 RC179.1 RC181.1 RC189.1 RC190.1 RC225.1 RC237.2 RC245.1 RC267.1 RC270.1 RC272.1 RC278.1 RC279.1 RC281.1 RC282.1 RC287.2 RC291.1 RC292.1 RC318.1 RC319.1 RC326.2 RC345.2 RD60.1 RD62.1 RD63.1 RD64.1 RD65.1 RD69.1 RD70.1 RD71.1 RE48.1 RE51.1 RE67.1 RPC4.5 RPC4.6 RPC4.7 RPC4.8 RPC5.2 RPC5.4 RPE3.5 RPE3.6 RPE8.5 RPE8.6 RPE8.7 RPE8.8 RV6.1 RV8.2 RV19.1 RV22.2 RV51.1 RV52.1 RV53.1 RV54.1 RV55.1 RV56.1 RV57.1 RV58.1 RV60.1 RV69.1 RV501.1 RV601.1 RV602.1 RV603.1 RV604.1 RV605.1 RV610.1 RV611.1 RV612.1 RV613.1 RV614.1 RV615.1 RV622.1 RV623.1 RZ89.1 RZ90.1 UC8.14 UC12.5 UV7.5 UV7.21 UV7.30 UV7.51 UV7.57 UV26.5 UV26.21 UV26.30 UV26.51 UV26.57 UV27.5 UZ5.6 UZ5.7
+3.3V_RUN_AUDIO: CA10.1 CA11.1 CA50.1 PJP10.2 PJP30.2 RA1.1 RA4.1 RA18.1 RA26.1 RA29.1 RA38.2 RA45.2 UA1.3 UA1.9
+3.3V_RUN_AUDIO_UZ5: CZ92.1 PJP30.1 UZ5.8 UZ5.9
+3.3V_RUN_CARD: CR38.2 CR39.2 JSD1.4 UR2.12
+3.3V_RUN_DIMM1: CD31.1 CD32.1 JDIMM1.255 RD65.2
+3.3V_RUN_DIMM2: CD63.1 CD64.1 JDIMM2.255 RD60.2
+3.3V_RUN_UZ3: CZ47.1 PJP22.1 UZ3.13 UZ3.14
+3.3V_RUN_VDDA: CV98.1 CV99.1 CV100.1 CV101.1 LV25.1 UV8.C10 UV8.H5 UV8.H12 UV8.J4 UV8.K6 UV8.K7
+3.3V_RUN_VDDIO: CV94.1 CV95.1 CV96.1 CV97.1 LV24.2 UV8.B5 UV8.B6 UV8.C3 UV8.C4 UV8.C11 UV8.C12 UV8.K3 UV8.K4 UV8.K11 UV8.K12
+3.3V_RUN_VMM: CV114.1 CV118.1 CV121.1 LV24.1 LV25.2 PJP25.2 RPV1.5 RPV1.6 RPV1.7 RPV1.8 RPV2.5 RPV2.6 RPV2.7 RPV2.8 RV82.2 RV83.2 RV84.2 RV85.2 RV86.1 RV87.1 RV88.1 RV90.1 RV91.1 RV516.2 RV517.1 RV518.1 RV519.1 UV9.8 UV11.14 UV12.14
+3.3V_SPI: CC9.1 CC10.1 JSPI1.6 RC30.1 RC31.1 RC41.2 UC1.AJ16 UC5.8 UC6.8
+3.3V_SPI_R: JSPI1.5 RC41.1 RC276.1 RC289.1
+3.3V_TP: CZ27.1 JKBTP1.12 PJP16.2 RZ18.1 RZ19.1 RZ20.1 RZ21.1 RZ116.1 RZ117.1
+3.3V_TSP: CZ2.1 JEDP1.1 QV8.1
+3.3V_VCCHDA: CC313.1 LC1.2 UC1.AJ19
+3.3V_WLAN: CZ15.1 CZ16.1 CZ17.1 CZ18.1 CZ19.1 CZ20.1 JNGFF1.2 JNGFF1.4 JNGFF1.64 JNGFF1.66 PJP12.2
+3.3V_WLAN_UZ3: CZ36.1 PJP12.1 UZ3.8 UZ3.9
+3.3V_WWAN: CZ51.1 CZ52.1 CZ53.1 CZ54.1 CZ55.1 CZ57.1 JNGFF2.2 JNGFF2.4 JNGFF2.62 JNGFF2.64 JNGFF2.66 PJP23.2 RZ43.1
+3.3V_WWAN_UZ2: CZ39.1 PJP23.1 UZ2.13 UZ2.14
+5V_ALW: CI6.1 CI7.1 CI11.1 CI12.1 CI19.1 CI31.1 CI33.1 CI34.1 CZ94.1 JLED1.1 JUSH1.9 LED3.2 PC507.1 PC1500.1 PJP103.2 PJP403.1 PJP404.1 PR9.1 PR201.2 PR205.1 PR602.2 PR937.2 PU1.5 PU502.6 PU602.9 PU602.10 PU1500.6 RI13.2 RV662.2 UI1.5 UI2.5 UI3.1 UI3.7 UI3.8 UV28.3 UZ2.4 UZ3.4 UZ4.1 UZ4.2 UZ4.4 UZ5.4 UZ8.4 UZ19.3 UZ20.3 UZ21.3 UZ22.4 UZ26.3
+5V_ALW2: PC126.1 PU102.15 RZ86.1
+5V_ALW2_R: JUSH1.10 RZ86.2
+5V_ALWP: PC120.1 PC121.1 PC122.1 PC123.1 PC124.1 PJP103.1 PL101.2 PR115.1 PR117.2 PU102.14
+5V_RUN: CE32.1 CV23.1 CZ10.1 CZ29.1 DE1.1 JFAN1.4 JKBTP1.5 JUSH1.7 PC661.1 PC677.1 PC685.1 PJP9.1 PJP21.2 PU603.2 PU605.2 PU606.6 RPE2.1 RPE2.2 RPE2.3 RPE2.4 UV2.1 UZ5.1 UZ5.2
+5V_RUN_AUDIO: LA5.2 PJP9.2 PJP31.1 RA39.1
+5V_RUN_AUDIO_UZ5: CZ89.1 PJP31.2 UZ5.13 UZ5.14
+5V_RUN_PVDD: CA45.1 CA46.1 CA47.1 CA48.1 RA39.2 UA1.41 UA1.46
+5V_RUN_UZ4: CZ44.1 PJP21.1 UZ4.13 UZ4.14
+5V_USB_CHG_PWR: CI14.1 CI17.1 CI32.1 JUSB3.1 UI3.12
+DV33_18: CR37.1 UR2.18
+GND_CHASSIS: CL22.2 RL15.2 RL16.2 RL17.2 RL18.2
+VCC_1P8: CC222.1 RC313.2 UC1.U11 UC1.U12
+VCC_CORE: CC282.1 CC283.2 CC284.2 CC287.1 PC1001.1 PC1002.1 PC1003.1 PC1004.1 PC1005.1 PC1006.1 PC1007.1 PC1008.1 PC1009.1 PC1010.1 PC1011.1 PC1012.1 PC1013.1 PC1030.1 PC1031.1 PC1032.1 PC1033.1 PC1034.1 PC1035.1 PC1036.1 PC1037.1 PC1038.1 PC1039.1 PC1050.1 PC1051.1 PC1052.1 PC1053.1 PC1054.1 PC1061.1 PC1062.1 PC1064.1 PC1065.1 PC1066.1 PC1067.1 PC1068.1 PC1069.1 PC1070.1 PC1071.1 PC1072.1 PC1073.1 PC1074.1 PC1075.1 PC1076.1 PC1077.1 PC1078.1 PC1079.1 PC1080.1 PC1081.1 PC1082.1 PC1083.1 PC1084.1 PC1085.1 PC1086.1 PC1087.1 PC1088.1 PC1089.1 PC1090.1 PC1091.1 PC1092.1 PC1093.1 PC1094.1 PC1095.1 PC1096.1 PC1097.1 PC1098.1 PC1099.1 PC1125.1 PC1126.1 PC1127.1 PC1164.1 PC1170.1 PC1171.1 PC1172.1 PC1173.1 PC1174.1 PL603.1 RC140.1 UC1.A30 UC1.A34 UC1.A39 UC1.A44 UC1.AK33 UC1.AK35 UC1.AK37 UC1.AK38 UC1.AK40 UC1.AL33 UC1.AL37 UC1.AL40 UC1.AM32 UC1.AM33 UC1.AM35 UC1.AM37 UC1.AM38 UC1.G30 UC1.G32 UC1.G33 UC1.G35 UC1.G37 UC1.G38 UC1.G40 UC1.G42 UC1.J30 UC1.J33 UC1.J37 UC1.J40 UC1.K33 UC1.K35 UC1.K37 UC1.K38 UC1.K40 UC1.K42 UC1.K43
+VCC_CORE_G0: T122.1(TP-1) UC1.K32
+VCC_CORE_G1: T123.1(TP-1) UC1.AK32
+VCC_GT: PC1014.1 PC1015.1 PC1016.1 PC1017.1 PC1018.1 PC1019.1 PC1020.1 PC1021.1 PC1022.1 PC1023.1 PC1024.1 PC1025.1 PC1026.1 PC1027.1 PC1028.1 PC1029.1 PC1040.1 PC1041.1 PC1042.1 PC1043.1 PC1044.1 PC1045.1 PC1046.1 PC1047.1 PC1048.1 PC1049.1 PC1055.1 PC1056.1 PC1063.1 PC1128.1 PC1129.1 PC1130.1 PC1131.1 PC1132.1 PC1133.1 PC1134.1 PC1135.1 PC1136.1 PC1137.1 PC1138.1 PC1175.1 PC1176.1 PC1177.1 PC1178.1 PC1179.1 PC1180.1 PC1181.1 PL604.1 RC161.1 UC1.A48 UC1.A53 UC1.A58 UC1.A62 UC1.A66 UC1.AA63 UC1.AA64 UC1.AA66 UC1.AA67 UC1.AA69 UC1.AA70 UC1.AA71 UC1.AC64 UC1.AC65 UC1.AC66 UC1.AC67 UC1.AC68 UC1.AC69 UC1.AC70 UC1.AC71 UC1.J43 UC1.J45 UC1.J46 UC1.J48 UC1.J50 UC1.J52 UC1.J53 UC1.J55 UC1.J56 UC1.J58 UC1.J60 UC1.K48 UC1.K50 UC1.K52 UC1.K53 UC1.K55 UC1.K56 UC1.K58 UC1.K60 UC1.L62 UC1.L63 UC1.L64 UC1.L65 UC1.L66 UC1.L67 UC1.L68 UC1.L69 UC1.L70 UC1.L71 UC1.M62 UC1.N63 UC1.N64 UC1.N66 UC1.N67 UC1.N69 UC1.N70 UC1.N71 UC1.R63 UC1.R64 UC1.R65 UC1.R66 UC1.R67 UC1.R68 UC1.R69 UC1.R70 UC1.R71 UC1.T62 UC1.U65 UC1.U68 UC1.U71 UC1.W63 UC1.W64 UC1.W65 UC1.W66 UC1.W67 UC1.W68 UC1.W69 UC1.W70 UC1.W71 UC1.Y62
+VCC_GTUS: UC1.AK42 UC1.AK43 UC1.AK45 UC1.AK46 UC1.AK48 UC1.AK50 UC1.AK52 UC1.AK53 UC1.AK55 UC1.AK56 UC1.AK58 UC1.AK60 UC1.AL43 UC1.AL46 UC1.AL50 UC1.AL53 UC1.AL56 UC1.AL60 UC1.AM48 UC1.AM50 UC1.AM52 UC1.AM53 UC1.AM56 UC1.AM58
+VCC_SA: PC633.2 PC637.2 PC644.1 PC1057.1 PC1058.1 PC1059.1 PC1060.1 PC1139.1 PC1140.1 PC1141.1 PC1142.1 PC1143.1 PC1144.1 PC1145.1 PC1146.1 PC1147.1 PC1148.1 PC1149.1 PC1150.1 PC1151.1 PC1152.1 PC1153.1 PH604.2 PL601.2 PR636.2 PR641.2 PR643.1 RC168.1 UC1.AK23 UC1.AK25 UC1.G23 UC1.G25 UC1.G27 UC1.G28 UC1.J22 UC1.J23 UC1.J27 UC1.K23 UC1.K25 UC1.K27 UC1.K28 UC1.K30
+VCC_SFR_OC: CC288.1 CZ114.1 RC119.2 UC1.AL23 UZ26.6
+VDDA_AVDD1: CA8.1 CA9.1 LA5.1 UA1.27
+VDDA_PVDD: CA17.1 CA18.1 RA4.2 UA1.38
GND: C33.2 C42.2 C43.2 C263.2 C310.2 C311.2 C316.2 C317.2 C318.2 C319.2 CA5.2 CA6.2 CA7.2 CA10.2 CA11.2 CA12.2 CA13.1 CA19.2 CA22.2 CA23.2 CA24.2 CA31.2 CA33.2 CA41.2 CA45.2 CA46.2 CA47.2 CA48.2 CA49.1 CA50.2 CA53.2 CA54.2 CC3.1 CC4.1 CC5.1 CC6.1 CC7.1 CC8.1 CC9.2 CC10.2 CC21.2 CC22.2 CC23.2 CC24.2 CC25.2 CC26.2 CC27.2 CC28.2 CC29.2 CC30.1 CC32.2 CC33.2 CC174.2 CC175.2 CC176.2 CC177.2 CC178.2 CC179.2 CC181.2 CC182.2 CC185.2 CC186.2 CC194.2 CC195.2 CC199.2 CC202.2 CC203.2 CC204.2 CC205.2 CC206.2 CC207.2 CC208.2 CC209.2 CC210.2 CC211.2 CC212.2 CC213.2 CC214.2 CC215.2 CC216.2 CC217.2 CC218.2 CC219.2 CC220.2 CC221.2 CC222.2 CC223.2 CC224.2 CC225.2 CC226.2 CC248.2 CC249.2 CC250.2 CC251.2 CC252.2 CC253.2 CC254.2 CC255.2 CC256.2 CC257.2 CC264.2 CC265.2 CC266.2 CC269.2 CC270.2 CC271.2 CC272.2 CC273.2 CC274.2 CC279.2 CC280.2 CC281.2 CC288.2 CC294.2 CC295.2 CC296.2 CC297.2 CC300.2 CC301.2 CC302.2 CC303.2 CC304.2 CC305.2 CC306.2 CC307.2 CC308.2 CC310.2 CC311.2 CC312.2 CC313.2 CC314.2 CD2.2 CD3.2 CD4.2 CD6.2 CD7.2 CD8.2 CD9.2 CD10.2 CD11.2 CD12.2 CD13.2 CD14.2 CD15.2 CD16.2 CD17.2 CD18.2 CD19.2 CD20.2 CD24.2 CD25.2 CD26.2 CD27.2 CD28.2 CD29.2 CD30.2 CD31.2 CD32.2 CD35.2 CD37.2 CD38.2 CD39.2 CD40.2 CD41.2 CD42.2 CD43.2 CD44.2 CD45.2 CD46.2 CD47.2 CD48.2 CD49.2 CD50.2 CD51.2 CD52.2 CD53.2 CD57.2 CD58.2 CD59.2 CD60.2 CD61.2 CD62.2 CD63.2 CD64.2 CD70.2 CD71.2 CD72.2 CD73.2 CD74.2 CD75.2 CD76.2 CD77.2 CD78.2 CD79.2 CD80.2 CD81.2 CD82.2 CD83.2 CD84.2 CD85.2 CD86.2 CD87.2 CD88.2 CD89.2 CD90.2 CD91.2 CD92.2 CD93.2 CD94.2 CD95.2 CD96.2 CD97.2 CD98.2 CD99.2 CD100.2 CD101.2 CD102.2 CD103.2 CD104.2 CD105.2 CD106.2 CD107.2 CD108.2 CD109.2 CE1.2 CE2.2 CE3.2 CE4.2 CE5.2 CE6.2 CE7.2 CE8.2 CE9.2 CE10.2 CE11.2 CE12.2 CE13.2 CE14.2 CE15.2 CE16.2 CE17.2 CE18.2 CE19.2 CE20.2 CE21.2 CE22.2 CE23.2 CE25.2 CE28.2 CE29.2 CE30.2 CE31.2 CE32.2 CE34.2 CE36.2 CE38.2 CE40.2 CE44.2 CE45.2 CE47.2 CE52.2 CI1.2 CI3.2 CI6.2 CI7.2 CI8.2 CI10.2 CI11.2 CI12.2 CI14.2 CI17.2 CI19.2 CI31.2 CI32.2 CI33.2 CI34.2 CL3.2 CL4.2 CL7.2 CL8.2 CL9.2 CL10.2 CL11.2 CL12.2 CL13.1 CL14.1 CL15.2 CL16.2 CL17.2 CL18.2 CL19.2 CL20.2 CL21.2 CL22.1 CL25.2 CL26.2 CL27.2 CL28.2 CMOS1.2 CN19.2 CN20.2 CN29.2 CN30.2 CN41.2 CN42.2 CR8.2 CR9.2 CR10.2 CR13.2 CR23.2 CR35.2 CR36.2 CR37.2 CR38.1 CR39.1 CR40.1 CR41.1 CR42.2 CR43.2 CV7.2 CV8.2 CV9.2 CV10.2 CV12.2 CV23.2 CV26.2 CV27.2 CV60.2 CV61.2 CV62.2 CV66.2 CV69.2 CV70.2 CV82.2 CV83.2 CV84.2 CV85.2 CV86.2 CV87.2 CV88.2 CV89.2 CV90.2 CV91.2 CV92.2 CV93.2 CV94.2 CV95.2 CV96.2 CV97.2 CV98.2 CV99.2 CV100.2 CV101.2 CV113.2 CV114.2 CV115.2 CV118.2 CV121.2 CV374.2 CV509.2 CV510.2 CV600.2 CV601.2 CV602.2 CV603.2 CV604.2 CV605.2 CV615.2 CV616.2 CV617.1 CV618.2 CV619.1 CZ1.2 CZ2.2 CZ10.2 CZ11.2 CZ12.2 CZ15.2 CZ16.2 CZ17.2 CZ18.2 CZ19.2 CZ20.2 CZ23.2 CZ24.2 CZ27.2 CZ28.2 CZ29.2 CZ30.2 CZ31.2 CZ34.2 CZ36.2 CZ37.2 CZ38.2 CZ39.2 CZ40.2 CZ41.2 CZ42.2 CZ43.2 CZ44.2 CZ45.2 CZ46.2 CZ47.2 CZ48.2 CZ50.2 CZ51.2 CZ52.2 CZ53.2 CZ54.2 CZ55.2 CZ57.2 CZ60.2 CZ61.2 CZ64.2 CZ65.2 CZ66.2 CZ67.2 CZ68.2 CZ69.2 CZ71.2 CZ72.2 CZ73.2 CZ74.2 CZ75.2 CZ76.2 CZ77.2 CZ78.2 CZ82.2 CZ84.2 CZ85.2 CZ87.2 CZ89.2 CZ90.2 CZ91.2 CZ92.2 CZ94.2 CZ95.2 CZ113.2 CZ114.2 CZ115.2 D20.1 DA1.1 DA2.1 DA3.1 DA6.1 DA7.1 DE1.2 DI1.3 DI2.1 DI3.1 DI4.3 DI5.1 DI6.3 DI7.3 DV4.1 H1.1(TP-1) H2.1(TP-1) H3.1(TP-1) H4.1(TP-1) H7.1(TP-1) H8.1(TP-1) H10.1(TP-1) H11.1(TP-1) H12.1(TP-1) H13.1(TP-1) H14.1(TP-1) H15.1(TP-1) H16.1(TP-1) H17.1(TP-1) H18.1(TP-1) H19.1(TP-1) H20.1(TP-1) H21.1(TP-1) H22.1(TP-1) H23.1(TP-1) H24.1(TP-1) H25.1(TP-1) H26.1(TP-1) H27.1(TP-1) H28.1(TP-1) JAPS1.8 JAPS1.10 JAPS1.12 JAPS1.14 JAPS1.19 JAPS1.20 JDEG1.10 JDEG1.11 JDEG1.12 JDIMM1.1 JDIMM1.2 JDIMM1.5 JDIMM1.6 JDIMM1.9 JDIMM1.10 JDIMM1.14 JDIMM1.15 JDIMM1.18 JDIMM1.19 JDIMM1.22 JDIMM1.23 JDIMM1.26 JDIMM1.27 JDIMM1.30 JDIMM1.31 JDIMM1.35 JDIMM1.36 JDIMM1.39 JDIMM1.40 JDIMM1.43 JDIMM1.44 JDIMM1.47 JDIMM1.48 JDIMM1.51 JDIMM1.52 JDIMM1.56 JDIMM1.57 JDIMM1.60 JDIMM1.61 JDIMM1.64 JDIMM1.65 JDIMM1.68 JDIMM1.69 JDIMM1.72 JDIMM1.73 JDIMM1.77 JDIMM1.78 JDIMM1.81 JDIMM1.82 JDIMM1.85 JDIMM1.86 JDIMM1.89 JDIMM1.90 JDIMM1.93 JDIMM1.94 JDIMM1.98 JDIMM1.99 JDIMM1.102 JDIMM1.103 JDIMM1.106 JDIMM1.107 JDIMM1.167 JDIMM1.168 JDIMM1.171 JDIMM1.172 JDIMM1.175 JDIMM1.176 JDIMM1.180 JDIMM1.181 JDIMM1.184 JDIMM1.185 JDIMM1.188 JDIMM1.189 JDIMM1.192 JDIMM1.193 JDIMM1.196 JDIMM1.197 JDIMM1.201 JDIMM1.202 JDIMM1.205 JDIMM1.206 JDIMM1.209 JDIMM1.210 JDIMM1.213 JDIMM1.214 JDIMM1.217 JDIMM1.218 JDIMM1.222 JDIMM1.223 JDIMM1.226 JDIMM1.227 JDIMM1.230 JDIMM1.231 JDIMM1.234 JDIMM1.235 JDIMM1.238 JDIMM1.239 JDIMM1.243 JDIMM1.244 JDIMM1.247 JDIMM1.248 JDIMM1.251 JDIMM1.252 JDIMM1.261 JDIMM1.262 JDIMM2.1 JDIMM2.2 JDIMM2.5 JDIMM2.6 JDIMM2.9 JDIMM2.10 JDIMM2.14 JDIMM2.15 JDIMM2.18 JDIMM2.19 JDIMM2.22 JDIMM2.23 JDIMM2.26 JDIMM2.27 JDIMM2.30 JDIMM2.31 JDIMM2.35 JDIMM2.36 JDIMM2.39 JDIMM2.40 JDIMM2.43 JDIMM2.44 JDIMM2.47 JDIMM2.48 JDIMM2.51 JDIMM2.52 JDIMM2.56 JDIMM2.57 JDIMM2.60 JDIMM2.61 JDIMM2.64 JDIMM2.65 JDIMM2.68 JDIMM2.69 JDIMM2.72 JDIMM2.73 JDIMM2.77 JDIMM2.78 JDIMM2.81 JDIMM2.82 JDIMM2.85 JDIMM2.86 JDIMM2.89 JDIMM2.90 JDIMM2.93 JDIMM2.94 JDIMM2.98 JDIMM2.99 JDIMM2.102 JDIMM2.103 JDIMM2.106 JDIMM2.107 JDIMM2.167 JDIMM2.168 JDIMM2.171 JDIMM2.172 JDIMM2.175 JDIMM2.176 JDIMM2.180 JDIMM2.181 JDIMM2.184 JDIMM2.185 JDIMM2.188 JDIMM2.189 JDIMM2.192 JDIMM2.193 JDIMM2.196 JDIMM2.197 JDIMM2.201 JDIMM2.202 JDIMM2.205 JDIMM2.206 JDIMM2.209 JDIMM2.210 JDIMM2.213 JDIMM2.214 JDIMM2.217 JDIMM2.218 JDIMM2.222 JDIMM2.223 JDIMM2.226 JDIMM2.227 JDIMM2.230 JDIMM2.231 JDIMM2.234 JDIMM2.235 JDIMM2.238 JDIMM2.239 JDIMM2.243 JDIMM2.244 JDIMM2.247 JDIMM2.248 JDIMM2.251 JDIMM2.252 JDIMM2.261 JDIMM2.262 JDOCK1.1 JDOCK1.7 JDOCK1.8 JDOCK1.13 JDOCK1.14 JDOCK1.19 JDOCK1.20 JDOCK1.25 JDOCK1.26 JDOCK1.31 JDOCK1.32 JDOCK1.37 JDOCK1.38 JDOCK1.43 JDOCK1.44 JDOCK1.47 JDOCK1.49 JDOCK1.50 JDOCK1.51 JDOCK1.52 JDOCK1.55 JDOCK1.57 JDOCK1.58 JDOCK1.61 JDOCK1.63 JDOCK1.64 JDOCK1.69 JDOCK1.70 JDOCK1.75 JDOCK1.76 JDOCK1.81 JDOCK1.82 JDOCK1.87 JDOCK1.88 JDOCK1.91 JDOCK1.93 JDOCK1.94 JDOCK1.95 JDOCK1.96 JDOCK1.101 JDOCK1.102 JDOCK1.107 JDOCK1.108 JDOCK1.113 JDOCK1.114 JDOCK1.119 JDOCK1.120 JDOCK1.123 JDOCK1.125 JDOCK1.126 JDOCK1.131 JDOCK1.132 JDOCK1.137 JDOCK1.138 JDOCK1.145 JDOCK1.148 JDOCK1.151 JDOCK1.152 JDOCK1.153 JDOCK1.154 JDOCK1.155 JDOCK1.156 JDOCK1.157 JDOCK1.158 JDOCK1.159 JDOCK1.160 JDOCK1.161 JDOCK1.162 JEDP1.4 JEDP1.6 JEDP1.8 JEDP1.15 JEDP1.23 JEDP1.24 JEDP1.25 JEDP1.27 JEDP1.28 JEDP1.39 JEDP1.41 JEDP1.42 JEDP1.43 JEDP1.44 JEDP1.45 JFAN1.1 JFAN1.5 JFAN1.6 JHDMI1.2 JHDMI1.5 JHDMI1.8 JHDMI1.11 JHDMI1.17 JHDMI1.20 JHDMI1.21 JHDMI1.22 JHDMI1.23 JIR1.4 JIR1.5 JIR1.7 JIR1.8 JKBTP1.2 JKBTP1.3 JKBTP1.9 JKBTP1.15 JKBTP1.17 JKBTP1.20 JKBTP1.21 JKBTP1.22 JLED1.6 JLED1.9 JLED1.10 JLOM1.14 JLOM1.15 JLOM1.16 JLOM1.17 JLPDE1.9 JLPDE1.11 JLPDE1.12 JMDP1.1 JMDP1.7 JMDP1.8 JMDP1.13 JMDP1.14 JMDP1.19 JMDP1.21 JMDP1.22 JMDP1.23 JMDP1.24 JNGFF1.1 JNGFF1.7 JNGFF1.10 JNGFF1.15 JNGFF1.16 JNGFF1.21 JNGFF1.22 JNGFF1.25 JNGFF1.28 JNGFF1.31 JNGFF1.37 JNGFF1.43 JNGFF1.49 JNGFF1.55 JNGFF1.61 JNGFF1.67 JNGFF1.68 JNGFF1.69 JNGFF2.3 JNGFF2.5 JNGFF2.11 JNGFF2.19 JNGFF2.25 JNGFF2.31 JNGFF2.37 JNGFF2.43 JNGFF2.49 JNGFF2.63 JNGFF2.65 JNGFF2.68 JNGFF2.69 JNGFF3.1 JNGFF3.3 JNGFF3.9 JNGFF3.15 JNGFF3.21 JNGFF3.27 JNGFF3.33 JNGFF3.39 JNGFF3.45 JNGFF3.51 JNGFF3.57 JNGFF3.63 JNGFF3.65 JNGFF3.67 JNGFF3.68 JNGFF3.69 JRTC1.2 JRTC1.3 JRTC1.4 JSD1.3 JSD1.6 JSD1.10 JSD1.13 JSD1.17 JSD1.20 JSD1.21 JSD1.22 JSD1.23 JSD1.24 JSD1.25 JSD1.26 JSIM1.5 JSIM1.10 JSIM1.11 JSIM1.12 JSIM1.13 JSIM1.14 JSIM1.15 JSIM1.16 JSPI1.1 JSPI1.2 JSPI1.3 JSPI1.21 JSPI1.22 JSPK1.5 JSPK1.6 JTAG1.2 JUSB1.4 JUSB1.7 JUSB1.10 JUSB1.11 JUSB1.12 JUSB1.13 JUSB2.4 JUSB2.7 JUSB2.10 JUSB2.11 JUSB2.12 JUSB2.13 JUSB3.4 JUSB3.7 JUSB3.10 JUSB3.11 JUSB3.12 JUSB3.13 JUSH1.2 JUSH1.3 JUSH1.17 JUSH1.20 JUSH1.21 JUSH1.27 JUSH1.28 JXDP1.2 JXDP1.7 JXDP1.8 JXDP1.13 JXDP1.14 JXDP1.19 JXDP1.20 JXDP1.25 JXDP1.26 JXDP1.31 JXDP1.32 JXDP1.37 JXDP1.38 JXDP1.49 JXDP1.50 JXDP1.59 PBATT1.7 PBATT1.8 PBATT1.9 PBATT1.10 PC1.2 PC2.2 PC3.2 PC4.2 PC6.2 PC7.2 PC100.2 PC101.1 PC103.2 PC104.2 PC105.2 PC106.2 PC107.2 PC108.2 PC109.2 PC110.2 PC111.2 PC112.2 PC115.2 PC116.2 PC117.2 PC118.2 PC119.2 PC120.2 PC121.2 PC122.2 PC123.2 PC124.2 PC125.2 PC126.2 PC128.2 PC201.2 PC202.2 PC203.2 PC204.2 PC206.2 PC207.1 PC209.2 PC210.2 PC211.2 PC213.2 PC214.2 PC215.2 PC216.2 PC217.2 PC218.2 PC219.2 PC220.2 PC301.2 PC302.2 PC303.2 PC305.2 PC306.2 PC308.2 PC309.2 PC310.2 PC311.2 PC312.2 PC313.2 PC401.2 PC402.2 PC403.2 PC404.2 PC406.2 PC407.2 PC408.2 PC409.2 PC410.2 PC411.2 PC412.2 PC413.2 PC415.2 PC416.2 PC417.2 PC418.2 PC419.2 PC420.2 PC422.2 PC424.2 PC501.2 PC502.1 PC504.2 PC505.2 PC506.2 PC507.2 PC508.2 PC510.2 PC511.2 PC601.2 PC602.2 PC603.2 PC604.2 PC605.1 PC606.2 PC608.2 PC612.2 PC613.1 PC614.1 PC616.1 PC618.1 PC619.1 PC621.1 PC622.2 PC625.1 PC628.2 PC629.1 PC631.2 PC636.1 PC641.2 PC643.2 PC644.2 PC645.2 PC647.1 PC649.2 PC651.1 PC652.2 PC654.1 PC656.2 PC657.2 PC658.2 PC659.2 PC660.2 PC661.2 PC662.2 PC672.2 PC673.2 PC677.2 PC678.2 PC679.2 PC680.2 PC685.2 PC686.2 PC688.2 PC801.2 PC803.2 PC804.2 PC805.2 PC806.2 PC807.2 PC808.1 PC810.2 PC811.2 PC812.2 PC813.2 PC814.2 PC815.2 PC816.2 PC817.2 PC818.2 PC819.2 PC820.2 PC822.2 PC823.1 PC824.1 PC825.2 PC826.2 PC827.2 PC828.2 PC829.1 PC831.2 PC832.2 PC833.2 PC834.1 PC835.2 PC901.2 PC903.1 PC905.1 PC906.2 PC907.2 PC908.2 PC1001.2 PC1002.2 PC1003.2 PC1004.2 PC1005.2 PC1006.2 PC1007.2 PC1008.2 PC1009.2 PC1010.2 PC1011.2 PC1012.2 PC1013.2 PC1014.2 PC1015.2 PC1016.2 PC1017.2 PC1018.2 PC1019.2 PC1020.2 PC1021.2 PC1022.2 PC1023.2 PC1024.2 PC1025.2 PC1026.2 PC1027.2 PC1028.2 PC1029.2 PC1030.2 PC1031.2 PC1032.2 PC1033.2 PC1034.2 PC1035.2 PC1036.2 PC1037.2 PC1038.2 PC1039.2 PC1040.2 PC1041.2 PC1042.2 PC1043.2 PC1044.2 PC1045.2 PC1046.2 PC1047.2 PC1048.2 PC1049.2 PC1050.2 PC1051.2 PC1052.2 PC1053.2 PC1054.2 PC1055.2 PC1056.2 PC1057.2 PC1058.2 PC1059.2 PC1060.2 PC1061.2 PC1062.2 PC1063.2 PC1064.2 PC1065.2 PC1066.2 PC1067.2 PC1068.2 PC1069.2 PC1070.2 PC1071.2 PC1072.2 PC1073.2 PC1074.2 PC1075.2 PC1076.2 PC1077.2 PC1078.2 PC1079.2 PC1080.2 PC1081.2 PC1082.2 PC1083.2 PC1084.2 PC1085.2 PC1086.2 PC1087.2 PC1088.2 PC1089.2 PC1090.2 PC1091.2 PC1092.2 PC1093.2 PC1094.2 PC1095.2 PC1096.2 PC1097.2 PC1098.2 PC1099.2 PC1125.2 PC1126.2 PC1127.2 PC1128.2 PC1129.2 PC1130.2 PC1131.2 PC1132.2 PC1133.2 PC1134.2 PC1135.2 PC1136.2 PC1137.2 PC1138.2 PC1139.2 PC1140.2 PC1141.2 PC1142.2 PC1143.2 PC1144.2 PC1145.2 PC1146.2 PC1147.2 PC1148.2 PC1149.2 PC1150.2 PC1151.2 PC1152.2 PC1153.2 PC1164.2 PC1170.2 PC1171.2 PC1172.2 PC1173.2 PC1174.2 PC1175.2 PC1176.2 PC1177.2 PC1178.2 PC1179.2 PC1180.2 PC1181.2 PC1500.2 PC1501.2 PC1503.2 PC1504.2 PD2.1 PD3.1 PD6.1 PD7.1 PH601.1 PH603.1 PJP1.2 PJP6.2 PJPDC1.6 PJPDC1.7 PQ1.6 PQ4.3 PQ201.3 PQ201.4 PQ201.5 PQ501.5 PQ501.6 PQ501.7 PQ808.3 PQ808.4 PQ808.5 PQ809.3 PQ902.1 PQ902.4 PQ906.3 PQ907.1 PQ907.4 PQ908.3 PQ911.1 PQ911.4 PR10.1 PR12.2 PR13.2 PR15.2 PR103.2 PR110.2 PR116.2 PR118.2 PR209.2 PR302.2 PR310.2 PR311.2 PR403.2 PR407.2 PR412.1 PR415.2 PR416.2 PR419.2 PR420.2 PR424.2 PR427.2 PR428.2 PR505.2 PR506.2 PR509.2 PR510.2 PR608.2 PR611.2 PR613.1 PR629.1 PR631.1 PR647.1 PR651.2 PR653.1 PR654.1 PR658.1 PR662.2 PR680.2 PR813.2 PR817.2 PR822.1 PR829.2 PR831.1 PR837.2 PR908.1 PR925.2 PR929.2 PR934.2 PR1502.2 PR1503.2 PU1.2 PU100.7 PU100.8 PU100.18 PU100.21 PU101.3 PU102.7 PU102.8 PU102.18 PU102.21 PU201.1 PU201.3 PU201.14 PU201.21 PU301.9 PU401.6 PU401.15 PU401.16 PU401.17 PU402.6 PU402.15 PU402.16 PU402.17 PU501.2 PU502.1 PU602.41 PU603.3 PU603.9 PU605.3 PU605.9 PU606.4 PU606.9 PU801.22 PU801.29 PU901.5 PU901.14 PU901.23 PU901.32 PU901.37 PU902.3 PU903.3 PU1500.1 QA1.3 QA3.1 QA3.4 QE2.1 QE2.4 QV2.3 QV4.3 QV7.3 QV9.3 QV10.3 R268.2 R271.2 RA2.2 RA35.2 RA36.2 RA37.2 RC1.1 RC3.2 RC4.2 RC5.2 RC6.2 RC7.2 RC44.2 RC48.2 RC65.2 RC75.1 RC86.1 RC88.2 RC89.2 RC90.2 RC91.2 RC96.2 RC109.1 RC110.1 RC112.1 RC113.1 RC114.2 RC122.2 RC136.1 RC139.1 RC141.2 RC163.2 RC166.2 RC167.2 RC180.1 RC182.1 RC219.1 RC220.2 RC227.2 RC242.1 RC268.2 RC311.1 RC312.1 RC316.1 RC324.2 RC337.2 RC338.2 RC342.1 RC349.2 RD20.2 RD21.2 RD24.2 RD25.2 RD66.2 RD67.2 RD68.2 RD72.2 RD73.2 RD74.2 RE17.1 RE20.1 RE21.1 RE24.2 RE55.1 RE56.1 RE58.2 RE65.2 RE77.2 RE78.2 RE82.1 RE85.2 RE86.1 RE88.2 RE277.1 RE299.2 RE313.2 RI14.1 RL3.1 RL9.2 RL12.2 RL13.2 RN30.2 RN31.2 RN38.2 RN39.2 RN40.2 RN41.2 RN45.2 RN46.2 RN47.2 RN52.2 RN53.2 RN54.2 RN59.2 RN60.2 RN61.2 RN62.2 RN66.2 RN67.2 RN68.2 RN72.2 RN73.2 RN74.2 RPE10.5 RPE10.6 RPE10.7 RPE10.8 RR20.2 RV1.2 RV2.2 RV3.1 RV20.2 RV50.2 RV61.2 RV62.2 RV63.2 RV64.2 RV65.2 RV67.1 RV68.1 RV70.1 RV73.2 RV74.2 RV75.2 RV76.2 RV77.2 RV78.2 RV79.2 RV89.2 RV100.2 RV502.1 RV503.1 RV508.1 RV509.1 RV600.2 RV606.1 RV607.1 RV608.1 RV609.1 RV616.2 RV617.2 RV618.2 RV619.2 RV620.2 RV621.2 RV660.2 RZ10.1 RZ27.2 RZ38.1 RZ40.1 RZ62.2 RZ111.2 ST2.1(TP-1) SW1.4 SW1.5 SW3.1 SW3.3 UA1.49 UC1.A5 UC1.A67 UC1.A70 UC1.AA2 UC1.AA4 UC1.AA65 UC1.AA68 UC1.AB8 UC1.AB15 UC1.AB16 UC1.AB18 UC1.AB21 UC1.AD8 UC1.AD13 UC1.AD16 UC1.AD19 UC1.AD20 UC1.AD21 UC1.AD62 UC1.AE64 UC1.AE65 UC1.AE66 UC1.AE67 UC1.AE68 UC1.AE69 UC1.AF1 UC1.AF2 UC1.AF4 UC1.AF10 UC1.AF15 UC1.AF17 UC1.AF63 UC1.AG16 UC1.AG17 UC1.AG18 UC1.AG19 UC1.AG20 UC1.AG21 UC1.AG71 UC1.AH6 UC1.AH13 UC1.AH63 UC1.AH64 UC1.AH67 UC1.AJ4 UC1.AJ15 UC1.AJ18 UC1.AJ20 UC1.AK8 UC1.AK11 UC1.AK16 UC1.AK18 UC1.AK21 UC1.AK22 UC1.AK27 UC1.AK63 UC1.AK68 UC1.AK69 UC1.AL2 UC1.AL4 UC1.AL28 UC1.AL32 UC1.AL35 UC1.AL38 UC1.AL45 UC1.AL48 UC1.AL52 UC1.AL55 UC1.AL58 UC1.AL64 UC1.AL65 UC1.AL66 UC1.AM8 UC1.AM13 UC1.AM21 UC1.AM25 UC1.AM27 UC1.AM43 UC1.AM45 UC1.AM46 UC1.AM55 UC1.AM60 UC1.AM61 UC1.AM68 UC1.AM71 UC1.AN20 UC1.AN23 UC1.AN28 UC1.AN30 UC1.AN32 UC1.AN33 UC1.AN35 UC1.AN37 UC1.AN38 UC1.AN40 UC1.AN42 UC1.AN58 UC1.AN63 UC1.AP10 UC1.AP18 UC1.AP20 UC1.AP23 UC1.AP28 UC1.AP32 UC1.AP35 UC1.AP38 UC1.AP42 UC1.AP58 UC1.AP63 UC1.AP68 UC1.AP70 UC1.AR5 UC1.AR8 UC1.AR11 UC1.AR15 UC1.AR16 UC1.AR20 UC1.AR23 UC1.AR28 UC1.AR35 UC1.AR42 UC1.AR43 UC1.AR45 UC1.AR46 UC1.AR48 UC1.AR50 UC1.AR52 UC1.AR53 UC1.AR55 UC1.AR58 UC1.AR63 UC1.AT2 UC1.AT4 UC1.AT20 UC1.AT23 UC1.AT28 UC1.AT35 UC1.AT42 UC1.AT56 UC1.AT58 UC1.AT63 UC1.AT68 UC1.AT71 UC1.AU10 UC1.AU15 UC1.AU20 UC1.AU32 UC1.AU38 UC1.AV1 UC1.AV68 UC1.AV69 UC1.AV70 UC1.AV71 UC1.AW6 UC1.AW8 UC1.AW10 UC1.AW12 UC1.AW14 UC1.AW16 UC1.AW18 UC1.AW21 UC1.AW23 UC1.AW26 UC1.AW28 UC1.AW30 UC1.AW32 UC1.AW34 UC1.AW36 UC1.AW38 UC1.AW43 UC1.AW45 UC1.AW47 UC1.AW49 UC1.AW51 UC1.AW53 UC1.AW55 UC1.AW57 UC1.AW60 UC1.AW62 UC1.AW64 UC1.AW66 UC1.AY3 UC1.AY66 UC1.AY71 UC1.B10 UC1.B14 UC1.B18 UC1.B22 UC1.B30 UC1.B34 UC1.B39 UC1.B44 UC1.B48 UC1.B53 UC1.B58 UC1.B62 UC1.B66 UC1.B71 UC1.BA1 UC1.BA2 UC1.BA6 UC1.BA10 UC1.BA14 UC1.BA18 UC1.BA23 UC1.BA28 UC1.BA32 UC1.BA36 UC1.BA41 UC1.BA45 UC1.BA49 UC1.BA53 UC1.BA57 UC1.BA62 UC1.BA66 UC1.BA71 UC1.BB6 UC1.BB18 UC1.BB26 UC1.BB30 UC1.BB34 UC1.BB38 UC1.BB43 UC1.BB55 UC1.BB60 UC1.BB64 UC1.BB67 UC1.BB70 UC1.C1 UC1.C5 UC1.C25 UC1.D6 UC1.D10 UC1.D11 UC1.D14 UC1.D18 UC1.D22 UC1.D25 UC1.D26 UC1.D30 UC1.D34 UC1.D39 UC1.D44 UC1.D45 UC1.D47 UC1.D48 UC1.D53 UC1.D58 UC1.D62 UC1.D66 UC1.D69 UC1.E6 UC1.E11 UC1.E15 UC1.E18 UC1.E21 UC1.E46 UC1.E50 UC1.E53 UC1.E56 UC1.E65 UC1.E71 UC1.F1 UC1.F2 UC1.F4 UC1.F8 UC1.F13 UC1.F22 UC1.F23 UC1.F27 UC1.F28 UC1.F32 UC1.F33 UC1.F35 UC1.F37 UC1.F38 UC1.F40 UC1.F42 UC1.F68 UC1.G5 UC1.G6 UC1.G10 UC1.G22 UC1.G43 UC1.G45 UC1.G48 UC1.G52 UC1.G55 UC1.G58 UC1.G60 UC1.G63 UC1.G66 UC1.H15 UC1.H18 UC1.H71 UC1.J8 UC1.J11 UC1.J13 UC1.J25 UC1.J28 UC1.J32 UC1.J35 UC1.J38 UC1.J42 UC1.K16 UC1.K18 UC1.K22 UC1.K61 UC1.K63 UC1.K64 UC1.K65 UC1.K66 UC1.K67 UC1.K68 UC1.K70 UC1.K71 UC1.L2 UC1.L4 UC1.L8 UC1.L11 UC1.L16 UC1.L17 UC1.L18 UC1.L20 UC1.N6 UC1.N10 UC1.N13 UC1.N19 UC1.N21 UC1.N65 UC1.N68 UC1.P17 UC1.P19 UC1.P20 UC1.P21 UC1.R6 UC1.R13 UC1.T2 UC1.T4 UC1.T15 UC1.T17 UC1.T18 UC1.T21 UC1.U10 UC1.U63 UC1.U64 UC1.U66 UC1.U67 UC1.U69 UC1.U70 UC1.V16 UC1.V17 UC1.V18 UC1.W6 UC1.W9 UC1.W13 UC1.Y17 UC1.Y19 UC1.Y20 UC1.Y21 UC5.4 UC6.4 UC7.3 UC8.7 UC8.15 UC12.3 UC13.3 UC14.3 UD1.3 UE1.B27 UE1.C1 UE2.B11 UE2.B18 UE2.B54 UE2.B60 UE2.B66 UE2.C1 UE3.3 UE4.3 UE5.3 UI1.2 UI2.2 UI3.14 UI3.17 UL1.49 UL2.3 UL4.43 UN4.7 UN4.25 UN5.7 UN5.25 UR2.33 UV2.2 UV7.11 UV7.19 UV7.52 UV7.61 UV8.C5 UV8.C13 UV8.C14 UV8.D4 UV8.D5 UV8.D6 UV8.D7 UV8.D8 UV8.D9 UV8.D10 UV8.D11 UV8.D13 UV8.D14 UV8.E4 UV8.E11 UV8.F4 UV8.F5 UV8.F6 UV8.F7 UV8.F8 UV8.F9 UV8.F10 UV8.F11 UV8.G4 UV8.G5 UV8.G6 UV8.G7 UV8.G8 UV8.G9 UV8.G10 UV8.G11 UV8.H4 UV8.H10 UV8.J5 UV8.J6 UV8.J7 UV8.J8 UV8.J9 UV8.J11 UV8.J12 UV8.K5 UV8.L6 UV8.L7 UV8.L8 UV9.4 UV11.7 UV12.7 UV24.2 UV26.11 UV26.19 UV26.52 UV26.61 UV27.2 UV27.4 UV28.5 UV29.11 UZ2.11 UZ2.15 UZ3.11 UZ3.15 UZ4.11 UZ4.15 UZ5.11 UZ5.15 UZ6.3 UZ8.5 UZ8.9 UZ10.3 UZ12.9 UZ12.16 UZ12.23 UZ12.32 UZ12.33 UZ19.5 UZ20.5 UZ21.5 UZ22.5 UZ22.9 UZ26.5 YL1.2 YL1.4 YV2.2 YV2.4
GNDA: CA1.2 CA2.2 CA3.2 CA4.2 CA8.2 CA9.2 CA16.2 CA17.2 CA18.2 CA25.2 CA26.2 CA35.1 CA51.2 CA52.2 JHP1.7 PJP6.1 QA2.1 QA2.4 RA35.1 RA36.1 RA37.1 RA44.2 UA1.26 UA1.37
VCC_GT_SENSE: PC617.1 PC618.2 PC620.1 PR622.1 RC161.2 UC1.J70
VCCIO_SENSE: PR422.2 RC165.2 UC1.AM23
VCCSA_B+: PC608.1 PC612.1 PJP603.1 PQ501.2 PQ501.3 PQ501.4 PQ501.10
VCCSENSE: PC639.1 PC651.2 PC653.1 PR648.1 RC140.2 UC1.E32
VCCST_PWRGD: RC78.2 UC1.B65
VCCST_PWRGD_EC: RE308.2 UE2.A44
VDD_1.2V: PC209.1 PR203.1 PR205.2 PU201.11
VIN_1.8VALW: PC502.2 PJP501.2 PU501.4
VIN_1V_PRIM: PC412.1 PC413.1 PC417.1 PC418.1 PJP404.2 PU402.10 PU402.11 PU402.12
VIN_1VS_VCCIO: PC403.1 PC404.1 PC408.1 PC409.1 PJP403.2 PU401.10 PU401.11 PU401.12
VSS_GT_SENSE: PC619.2 PC620.2 PU602.6 RC163.1 UC1.J69
VSSIO_SENSE: PR412.2 RC167.1 UC1.AM22
VSSSENSE: PC653.2 PC654.2 PU602.18 RC141.1 UC1.E33
3301_ACAV_IN_NB: PR922.1 PU901.24
3301_PWRSRC: PR939.1 PU901.15
+BL_PWR_SRC: CV7.1 CV12.1 JEDP1.17 JEDP1.18 JEDP1.19 QV1.1 QV1.2 QV1.5 QV1.6
+CAP_LDO: CE7.1 UE1.B46
+COINCELL: JRTC1.1 PR2.1
+DC_IN: PC5.2 PC6.1 PL1.2 PQ1.3 PQ5.1 PQ5.2 PQ5.3 PR1.1 PR13.1 PR830.1 PR921.1
+DC_IN_SS: PC7.1 PD801.2 PD905.3 PQ5.5 PQ802.5 PQ802.6 PQ802.7 PQ802.8 PR12.1 PR935.1
+DCIN: PC814.1 PR811.2 PU801.28
+DCIN_JACK: PC1.1 PJPDC1.2 PJPDC1.3 PL1.1
+DCPRTC: CC214.1 UC1.BB10
+DDR_VREF_A_CA: JDIMM1.164 RD18.2 RD19.1 RD20.1
+DDR_VREF_A_DQ: T132.1(TP-1) UC1.AY68
+DDR_VREF_B_CA: JDIMM2.164 RD22.2 RD24.1 RD75.1
+DDR_VREF_B_DQ: CD54.1 RD75.2 UC1.BA67
+DDR_VREF_CA: CD36.1 RD19.2 UC1.AY67
+DOCK_PWR_BAR: C33.1 C317.1 C318.1 D20.2 D20.3 JDOCK1.146 JDOCK1.147 JDOCK1.149 JDOCK1.150 PD802.2 PD903.2 PD903.3 PQ904.5 PQ904.6 PQ904.7 PQ904.8 PQ905.5 PR908.2 PR924.2
+EDP_VDD: PJP29.2 UV24.1
+LCDVDD: CV8.1 CV9.1 JEDP1.30 JEDP1.31 PJP29.1
+LOM_VCT: C316.1 JDOCK1.116 JDOCK1.118
+MIC1_VREF_OUT: DA4.2 DA5.2 UA1.30
+NBDOCK_DC_IN_SS: JDOCK1.41 PD905.2 PR927.2
+PBATT: PD803.2 PD902.2 PD902.3 PL2.2 PL3.2 PQ901.5 PQ901.6 PQ901.7 PQ901.8 PQ903.5 PQ903.6 PQ903.7 PQ903.8 PR826.2 PR933.2
+PECI_VREF: CE25.1 RE59.1 UE2.B51
+PWR_SRC: CV11.1 JIR1.1 JIR1.2 PC803.1 PC804.1 PC805.1 PC806.1 PC807.1 PC811.1 PC812.1 PC835.1 PJP100.1 PJP101.1 PJP202.1 PJP301.1 PJP601.2 PL602.2 PL801.1 PR102.2 PR823.4 QV1.4 RV4.1 RZ85.1
+PWR_SRC_AC: PC902.1 PD903.1 PJP801.1 PL802.2 PQ904.1 PQ904.2 PQ904.3 PR802.1 PR939.2
+PWR_SRC_R: JUSH1.26 RZ85.2
+REGCTL_PNP10: LL1.1 UL1.7
+RREF: RR20.1 UR2.9
+RSVD_VCC3P3_1: RL6.2 UL1.1
+RTC_CELL: CC213.1 CC270.1 PC2.1 PD1.1 RA21.1 RC56.2 RC57.2 RC69.2 RE31.1 RE32.1 RE62.1 RPE5.5 RPE5.6 UC1.AK19 UC1.BB14
+RTC_CELL_VBAT: CE11.1 RE32.2 UE2.B64
+SDC_IN: PC802.1 PQ802.1 PQ802.2 PQ802.3 PR802.4 PR812.2 PR928.1 PU801.3
+SDREG2: CR35.1 UR2.24
+SIM_PWR: C263.1 JNGFF2.28 JSIM1.1
+USB_LEFT_PWR: CI1.1 CI3.1 JUSB1.1 UI1.1
+USB_REAR_PWR: CI8.1 CI10.1 JUSB2.1 UI2.1
+UZ12_TPM: CZ73.1 RZ88.2 RZ89.2 UZ12.8
+V_DDR_REF: PC210.1 PU201.4
+VCHGR: PC801.1 PC825.1 PC826.1 PC827.1 PD902.1 PQ903.1 PQ903.2 PQ903.3 PR823.1
+VDISPLAY_VCC: CV509.1 JMDP1.20 UV27.1
+VHDMI_VCC: CV26.1 CV27.1 JHDMI1.18 RV18.2 RV21.2 UV2.3
+VLDOIN_1.2V: PJP203.1 PU201.19
+VR_CAP: CE31.1 UE2.B12
+VREFOUT: CA26.1 RA5.2 RA6.2 UA1.23
+Z4012: PD1.2 PR2.2
-DCIN_JACK: PJP1.1 PJPDC1.4 PJPDC1.5
/BATPRES: PR828.2 PR904.2 PU801.15
A_ON: RPE10.3 UE2.A4 UZ8.3
AC_DIS: PQ1.5 PQ809.2 PR837.1 PR916.1 UE1.A50
AC_PRESENT: RC243.1 UC1.AY15 UE2.A54
ACAV_DOCK_SRC#: JDOCK1.42 PR920.2 PR923.1
ACAV_IN: PQ809.1 PQ907.5 PR801.2 PR815.1 PR817.1 PR918.1 UE2.A64
ACAV_IN#: PQ907.3 PR914.2 PU903.2
ACAV_IN_NB: PR833.1 PR922.2 UE2.B20
ACAVDK_SRC: PR923.2 PU901.4
ACAVIN: PR918.2 PU901.8
ADJ: RV659.2 RV660.1 UV29.2
ALW_PWRGD_3V_5V: PR101.2 PR119.2 PR120.2 UZ6.2
ALWON: PR114.1 UE2.A60
AUD_HP_NB_SENSE: CA41.1 DA2.3 JHP1.6 QA1.2 RA2.1 UE1.A41
AUD_HP_OUT_L: CA43.2 LA2.1 RA7.2 RA24.1
AUD_HP_OUT_L1: CA3.1 DA3.3 JHP1.1 LA2.2
AUD_HP_OUT_R: CA44.2 LA3.1 RA8.2 RA25.1
AUD_HP_OUT_R1: CA2.1 DA1.2 JHP1.2 LA3.2
AUD_NB_MUTE#: CA31.1 QA2.2 RA18.2 UA1.48 UE1.A39
AUD_OUT_L: RA7.1 UA1.33
AUD_OUT_R: RA8.1 UA1.32
AUD_PC_BEEP: CA27.2 CA28.2 UA1.12
AUD_PWR_EN: RC279.2 UC1.BA7 UZ5.3 UZ5.5
AUD_SENSE_A: QA1.1 UA1.13
AUD_SENSE_B: RA27.1 RA28.1 RA38.1 UA1.14
AUX_EN_WOWL: RZ38.2 RZ70.1 UE1.B67
BAT1_LED#: RZ28.1 UE2.B1
BAT2_LED#: RZ25.1 UE2.A55
BATDRV#: PQ903.4 PR825.2
BATT_WHITE#: JLED1.5 RZ25.2
BATT_YELLOW#: JLED1.4 RZ28.2
BC_CLK_ECE1117: JKBTP1.10 UE2.A20
BC_CLK_ECE5048: UE1.A30 UE2.A43
BC_DAT_ECE1117: JKBTP1.8 RPE5.2 UE2.B21
BC_DAT_ECE5048: RE36.2 UE1.B31 UE2.B45
BC_INT#_ECE1117: JKBTP1.7 UE2.A19
BC_INT#_ECE5048: UE1.A29 UE2.A42
BCM5882_ALERT#: JUSH1.14 UE1.B62
BEEP: RA13.2 UE2.B19
BIA_PWM: DV1.1 LV1.2 RV1.1
BIA_PWM_EC: DV1.2 UE2.B25
BL_PWR_SRC_ON: CV11.2 CV374.1 QV1.3 RV4.2 RV5.1
BOARD_ID: CE40.1 RE79.2 UE2.B10
BOOT_1.2V: PR202.2 PU201.18
BQ24770_REGN: PC813.1 PR801.1 PR821.2 PR827.1 PU801.24
BREATH_LED#: JDOCK1.98 QZ7.4 RZ34.1 UE2.B57
BREATH_LED#_Q: QZ7.3 RZ32.1
BREATH_WHITE_LED#: JLED1.2 RZ34.2
BREATH_WHITE_LED_SNIFF#: LED3.1 RZ32.2
BST_3V: PR100.1 PU100.1
BST_5V: PR111.1 PU102.1
BST_+1VALWP: PC304.1 PU301.6
BST_+1VALWP_C: PC304.2 PR304.1
BT_RADIO_DIS#: DZ2.1 RE11.2 UE1.A13
BT_RADIO_DIS#_R: DZ2.2 JNGFF1.46
CAM_MIC_CBL_DET#: JEDP1.14 RPC4.4 UC1.AB11
CD3301_DCIN: PC906.1 PR921.2 PU901.1
CD3301_SDC_IN: PR928.2 PU901.6
CD_PBATT_OFF: PR937.1 PU901.27
CFG0: JXDP1.9 RC113.2 RC126.1 UC1.E68
CFG1: JXDP1.11 RC112.2 UC1.B67
CFG2: JXDP1.15 UC1.D65
CFG3: JXDP1.17 RC110.2 RC121.2 UC1.D67
CFG4: JXDP1.27 RC109.2 UC1.E70
CFG5: JXDP1.29 UC1.C68
CFG6: JXDP1.33 UC1.D68
CFG7: JXDP1.35 UC1.C67
CFG8: JXDP1.10 UC1.F71
CFG9: JXDP1.12 UC1.G69
CFG10: JXDP1.16 UC1.F70
CFG11: JXDP1.18 UC1.G68
CFG12: JXDP1.28 UC1.H70
CFG13: JXDP1.30 UC1.G71
CFG14: JXDP1.34 UC1.H69
CFG15: JXDP1.36 UC1.G70
CFG16: JXDP1.6 UC1.E63
CFG17: JXDP1.4 UC1.F63
CFG18: JXDP1.24 UC1.E66
CFG19: JXDP1.22 UC1.F66
CFG_RCOMP: RC114.1 UC1.E60
CHAGER_SRC: PC816.1 PC817.1 PC818.1 PC819.1 PC820.1 PC822.1 PJP801.2 PL802.1 PQ808.2
CHARGER_SMBCLK: PR835.1 RPE6.2 UE2.B50
CHARGER_SMBDAT: PR836.1 RPE6.1 UE2.A47
CHG_LGATE: PQ808.6 PU801.23
CHG_SNUB: PC832.1 PR824.1
CHG_SW: PC821.1 PL801.2 PQ808.7 PR824.2 PU801.27
CHG_UGATE: PQ808.1 PU801.26
CLK_27M_IN: CV115.1 RV80.1 UV8.K1 YV2.1
CLK_27M_OUT: RV80.2 RV81.2 UV8.L1
CLK_27M_OUT_R: CV113.1 RV81.1 YV2.3
CLK_ITPXDP_N: RC297.1 UC1.F43
CLK_ITPXDP_N_R: JXDP1.42 RC297.2
CLK_ITPXDP_P: RC298.1 UC1.E43
CLK_ITPXDP_P_R: JXDP1.40 RC298.2
CLK_KBD: JDOCK1.78 RPE2.8 UE2.A38
CLK_MSE: JDOCK1.71 RPE2.6 UE2.A39
CLK_PCI_5048: CC3.2 RC16.2 RE27.1 UE1.A28
CLK_PCI_DOCK: CC6.2 JDOCK1.121 R273.1 RC24.2
CLK_PCI_LPDEBUG: CC5.2 JLPDE1.10 RC22.2
CLK_PCI_MEC: CC4.2 RC18.2 RE66.1 UE2.A29
CLK_PCIE_N0: JNGFF2.45 UC1.D42
CLK_PCIE_N1: JNGFF1.41 UC1.B42
CLK_PCIE_N2: JNGFF1.65 UC1.D41
CLK_PCIE_N3: JNGFF3.53 UC1.D40
CLK_PCIE_N4: UC1.B40 UL1.45
CLK_PCIE_N5: UC1.E40 UR2.6
CLK_PCIE_P0: JNGFF2.47 UC1.C42
CLK_PCIE_P1: JNGFF1.39 UC1.A42
CLK_PCIE_P2: JNGFF1.63 UC1.C41
CLK_PCIE_P3: JNGFF3.55 UC1.C40
CLK_PCIE_P4: UC1.A40 UL1.44
CLK_PCIE_P5: UC1.E38 UR2.5
CLK_TP_SIO: CZ31.1 RZ19.2 RZ23.2 UE2.A37
CLK_TP_SIO_R: JKBTP1.14 RZ23.1
CLKDET#: T121.1(TP-1) UC1.AY8
CLKREQ_PCIE#0: JNGFF2.44 RC189.2 UC1.AR10
CLKREQ_PCIE#1: JNGFF1.45 RC47.2 UC1.AT7
CLKREQ_PCIE#2: JNGFF1.60 RC50.2 UC1.AT8
CLKREQ_PCIE#3: JNGFF3.52 RC59.2 UC1.AT10
CLKREQ_PCIE#4: RC51.2 RL4.1 UC1.AU8 UL1.48
CLKREQ_PCIE#5: RC190.2 UC1.AU7 UR2.2
CLKRUN#: RC27.1 UC1.AW11 UE1.B20 UE2.A32
CMPIN: PC833.1 PR830.2 PR831.2 PR832.1 PU801.13
CMPOUT: PC834.2 PR832.2 PR833.2 PR834.1 PU801.14
COMP_IA: PC636.2 PR639.2 PU602.16
COMP_VSA: PC628.1 PR630.1 PU602.24
CONTACTLESS_DET#: JUSH1.4 RC278.2 UC1.W11
CORE_SNUB: PC662.1 PR663.2
CORE_SW: PL603.4 PR663.1 PU603.4
CORE_VID0: PR408.1 UC1.AN11
CORE_VID1: PR411.1 UC1.AN13
CPU_B+: PC606.1 PC656.1 PC657.1 PC658.1 PC659.1 PC660.1 PC680.1 PC686.1 PJP601.1 PJP602.2 PJP603.2 PL602.1 PR603.2 PU603.5
CPU_DP1_AUXN: RC179.2 UC1.G50
CPU_DP1_AUXP: RC180.2 UC1.F50
CPU_DP1_CTRL_CLK: QV3.1 RC175.1 UC1.L13
CPU_DP1_CTRL_DATA: QV3.4 RC178.1 UC1.L12
CPU_DP1_HPD: QV5.3 RC312.2 RV22.1 UC1.L9
CPU_DP1_N0: CV18.2 UC1.E55
CPU_DP1_N1: CV22.2 UC1.E58
CPU_DP1_N2: CV29.2 UC1.F53
CPU_DP1_N3: CV14.2 UC1.F56
CPU_DP1_P0: CV17.2 UC1.F55
CPU_DP1_P1: CV21.2 UC1.F58
CPU_DP1_P2: CV28.2 UC1.G53
CPU_DP1_P3: CV13.2 UC1.G56
CPU_DP2_AUXN: CV80.1 RC181.2 UC1.E48
CPU_DP2_AUXN_C: CV80.2 UV7.25
CPU_DP2_AUXP: CV79.1 RC182.2 UC1.F48
CPU_DP2_AUXP_C: CV79.2 UV7.24
CPU_DP2_CTRL_CLK: RC176.1 UC1.N7 UV7.22
CPU_DP2_CTRL_DATA: RC177.1 UC1.N8 UV7.23
CPU_DP2_HPD: RC242.2 UC1.L7 UV7.3
CPU_DP2_N0: CV72.1 UC1.C50
CPU_DP2_N0_C: CV72.2 UV7.7
CPU_DP2_N1: CV74.1 UC1.C52
CPU_DP2_N1_C: CV74.2 UV7.10
CPU_DP2_N2: CV76.1 UC1.A50
CPU_DP2_N2_C: CV76.2 UV7.13
CPU_DP2_N3: CV78.1 UC1.D51
CPU_DP2_N3_C: CV78.2 UV7.16
CPU_DP2_P0: CV71.1 UC1.D50
CPU_DP2_P0_C: CV71.2 UV7.6
CPU_DP2_P1: CV73.1 UC1.D52
CPU_DP2_P1_C: CV73.2 UV7.9
CPU_DP2_P2: CV75.1 UC1.B50
CPU_DP2_P2_C: CV75.2 UV7.12
CPU_DP2_P3: CV77.1 UC1.C51
CPU_DP2_P3_C: CV77.2 UV7.15
CPU_DP3_AUXN: T1.1(TP-1) UC1.G46
CPU_DP3_AUXP: T2.1(TP-1) UC1.F46
CPU_ID: RE298.1 RE299.1 UE1.B60
CPU_POPIRCOMP: RC88.1 UC1.AT16
CPU_XDP_PRDY#: JXDP1.5 UC1.D56
CPU_XDP_PREQ#: JXDP1.3 RC138.2 UC1.D61
CPU_XDP_TCLK: JXDP1.57 RC139.2 RC328.2 UC1.B61
CPU_XDP_TDI: RC134.2 UC1.D60 UC8.6
CPU_XDP_TDO: RC135.2 UC1.A61 UC8.3
CPU_XDP_TMS: RC131.2 UC1.C60 UC8.8
CPU_XDP_TRST#: CC308.1 RC136.2 UC1.B59 UC1.C61 UC8.11
CS_1.2V: PR203.2 PU201.13
CSI2_COMP: RC3.1 UC1.E13
CSS_GC: PR804.1 PU901.10
CSSN_1: PQ803.3 PQ805.3 PR805.1 PR807.1 PR809.1
CSSP_1: PQ801.3 PQ804.3 PR805.2 PR806.1 PR808.1
CV2_ON: JUSH1.24 RPE10.2 UE2.A9
D_CLKRUN#: JDOCK1.111 RPE8.4 UE1.A19
D_DLDRQ1#: JDOCK1.117 RPE8.2 UE1.B24
D_LAD0: JDOCK1.97 UE1.B29
D_LAD1: JDOCK1.99 UE1.B28
D_LAD2: JDOCK1.103 UE1.A25
D_LAD3: JDOCK1.105 UE1.A24
D_LFRAME#: JDOCK1.109 UE1.B23
D_SERIRQ: JDOCK1.115 RPE8.3 UE1.A20
DAI_12MHZ#: JDOCK1.89 R41.1 RA30.1
DAI_BCLK#: JDOCK1.77 R6.1 RA31.1
DAI_DI: JDOCK1.83 UA1.24
DAI_DO#: JDOCK1.85 RA32.1
DAI_LRCK#: JDOCK1.79 UA1.18
DAT_KBD: JDOCK1.80 RPE2.7 UE2.B41
DAT_MSE: JDOCK1.73 RPE2.5 UE2.B42
DAT_TP_SIO: CZ30.1 RZ18.2 RZ22.2 UE2.B40
DAT_TP_SIO_R: JKBTP1.13 RZ22.1
DC_BLOCK_GC: PR803.2 PU901.7
DC_IN_SS: PR935.2 PU901.34
